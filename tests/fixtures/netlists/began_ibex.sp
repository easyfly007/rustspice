* BeGAN Power Grid Benchmark: ibex (ASAP7, regular PDN)
* Source: BeGAN Power Grid Benchmarks, UMN-EDA
* https://github.com/UMN-EDA/BeGAN-benchmarks
* Real circuit benchmark (ibex RISC-V core, ASAP7 technology)
* Elements: R (resistors/vias), I (current loads), V (power supply)
* Nodes: 25199, Resistors: 27418, V sources: 1, I sources: 5476
R0 n1_M2_60_60 n1_M2_1140_60 0.988200
R1 n1_M2_1140_60 n1_M2_2220_60 0.988200
R2 n1_M2_2220_60 n1_M2_3300_60 0.988200
R3 n1_M2_3300_60 n1_M2_4380_60 0.988200
R4 n1_M2_4380_60 n1_M2_5460_60 0.988200
R5 n1_M2_5460_60 n1_M2_6540_60 0.988200
R6 n1_M2_6540_60 n1_M2_7620_60 0.988200
R7 n1_M2_7620_60 n1_M2_8700_60 0.988200
R8 n1_M2_8700_60 n1_M2_9780_60 0.988200
R9 n1_M2_9780_60 n1_M2_10860_60 0.988200
R10 n1_M2_10860_60 n1_M2_11940_60 0.988200
R11 n1_M2_11940_60 n1_M2_13020_60 0.988200
R12 n1_M2_13020_60 n1_M2_14100_60 0.988200
R13 n1_M2_14100_60 n1_M2_15180_60 0.988200
R14 n1_M2_15180_60 n1_M2_16260_60 0.988200
R15 n1_M2_16260_60 n1_M2_17340_60 0.988200
R16 n1_M2_17340_60 n1_M2_18420_60 0.988200
R17 n1_M2_18420_60 n1_M2_19500_60 0.988200
R18 n1_M2_19500_60 n1_M2_20580_60 0.988200
R19 n1_M2_20580_60 n1_M2_21660_60 0.988200
R20 n1_M2_21660_60 n1_M2_22740_60 0.988200
R21 n1_M2_22740_60 n1_M2_23820_60 0.988200
R22 n1_M2_23820_60 n1_M2_24900_60 0.988200
R23 n1_M2_24900_60 n1_M2_25980_60 0.988200
R24 n1_M2_25980_60 n1_M2_27060_60 0.988200
R25 n1_M2_27060_60 n1_M2_28140_60 0.988200
R26 n1_M2_28140_60 n1_M2_29220_60 0.988200
R27 n1_M2_29220_60 n1_M2_30300_60 0.988200
R28 n1_M2_30300_60 n1_M2_31380_60 0.988200
R29 n1_M2_31380_60 n1_M2_32460_60 0.988200
R30 n1_M2_32460_60 n1_M2_33540_60 0.988200
R31 n1_M2_33540_60 n1_M2_34620_60 0.988200
R32 n1_M2_34620_60 n1_M2_35700_60 0.988200
R33 n1_M2_35700_60 n1_M2_36780_60 0.988200
R34 n1_M2_36780_60 n1_M2_37860_60 0.988200
R35 n1_M2_37860_60 n1_M2_38940_60 0.988200
R36 n1_M2_38940_60 n1_M2_40020_60 0.988200
R37 n1_M2_40020_60 n1_M2_41100_60 0.988200
R38 n1_M2_41100_60 n1_M2_42180_60 0.988200
R39 n1_M2_42180_60 n1_M2_43260_60 0.988200
R40 n1_M2_43260_60 n1_M2_44340_60 0.988200
R41 n1_M2_44340_60 n1_M2_45420_60 0.988200
R42 n1_M2_45420_60 n1_M2_46500_60 0.988200
R43 n1_M2_46500_60 n1_M2_47580_60 0.988200
R44 n1_M2_47580_60 n1_M2_48660_60 0.988200
R45 n1_M2_48660_60 n1_M2_49740_60 0.988200
R46 n1_M2_49740_60 n1_M2_50820_60 0.988200
R47 n1_M2_50820_60 n1_M2_51900_60 0.988200
R48 n1_M2_51900_60 n1_M2_52980_60 0.988200
R49 n1_M2_52980_60 n1_M2_54060_60 0.988200
R50 n1_M2_54060_60 n1_M2_55140_60 0.988200
R51 n1_M2_55140_60 n1_M2_56220_60 0.988200
R52 n1_M2_56220_60 n1_M2_57300_60 0.988200
R53 n1_M2_57300_60 n1_M2_58380_60 0.988200
R54 n1_M2_58380_60 n1_M2_59460_60 0.988200
R55 n1_M2_59460_60 n1_M2_60540_60 0.988200
R56 n1_M2_60540_60 n1_M2_61620_60 0.988200
R57 n1_M2_61620_60 n1_M2_62700_60 0.988200
R58 n1_M2_62700_60 n1_M2_63780_60 0.988200
R59 n1_M2_63780_60 n1_M2_64860_60 0.988200
R60 n1_M2_64860_60 n1_M2_65940_60 0.988200
R61 n1_M2_65940_60 n1_M2_67020_60 0.988200
R62 n1_M2_67020_60 n1_M2_68100_60 0.988200
R63 n1_M2_68100_60 n1_M2_69180_60 0.988200
R64 n1_M2_69180_60 n1_M2_70260_60 0.988200
R65 n1_M2_70260_60 n1_M2_71340_60 0.988200
R66 n1_M2_71340_60 n1_M2_72420_60 0.988200
R67 n1_M2_72420_60 n1_M2_73500_60 0.988200
R68 n1_M2_73500_60 n1_M2_74580_60 0.988200
R69 n1_M2_74580_60 n1_M2_75660_60 0.988200
R70 n1_M2_75660_60 n1_M2_76740_60 0.988200
R71 n1_M2_76740_60 n1_M2_77820_60 0.988200
R72 n1_M2_77820_60 n1_M2_78900_60 0.988200
R73 n1_M2_78900_60 n1_M2_79980_60 0.988200
R74 n1_M2_79980_60 n1_M2_81060_60 0.988200
R75 n1_M2_81060_60 n1_M2_82140_60 0.988200
R76 n1_M2_82140_60 n1_M2_83220_60 0.988200
R77 n1_M2_83220_60 n1_M2_84300_60 0.988200
R78 n1_M2_84300_60 n1_M2_85380_60 0.988200
R79 n1_M2_85380_60 n1_M2_86460_60 0.988200
R80 n1_M2_86460_60 n1_M2_87540_60 0.988200
R81 n1_M2_87540_60 n1_M2_88620_60 0.988200
R82 n1_M2_88620_60 n1_M2_89700_60 0.988200
R83 n1_M2_89700_60 n1_M2_90780_60 0.988200
R84 n1_M2_90780_60 n1_M2_91860_60 0.988200
R85 n1_M2_91860_60 n1_M2_92940_60 0.988200
R86 n1_M2_92940_60 n1_M2_94020_60 0.988200
R87 n1_M2_94020_60 n1_M2_95100_60 0.988200
R88 n1_M2_95100_60 n1_M2_96180_60 0.988200
R89 n1_M2_96180_60 n1_M2_97260_60 0.988200
R90 n1_M2_97260_60 n1_M2_98340_60 0.988200
R91 n1_M2_98340_60 n1_M2_99420_60 0.988200
R92 n1_M2_99420_60 n1_M2_100500_60 0.988200
R93 n1_M2_100500_60 n1_M2_101580_60 0.988200
R94 n1_M2_101580_60 n1_M2_102660_60 0.988200
R95 n1_M2_102660_60 n1_M2_103740_60 0.988200
R96 n1_M2_103740_60 n1_M2_104820_60 0.988200
R97 n1_M2_104820_60 n1_M2_105900_60 0.988200
R98 n1_M2_105900_60 n1_M2_106980_60 0.988200
R99 n1_M2_106980_60 n1_M2_108060_60 0.988200
R100 n1_M2_108060_60 n1_M2_109140_60 0.988200
R101 n1_M2_109140_60 n1_M2_110220_60 0.988200
R102 n1_M2_110220_60 n1_M2_111300_60 0.988200
R103 n1_M2_111300_60 n1_M2_112380_60 0.988200
R104 n1_M2_112380_60 n1_M2_113460_60 0.988200
R105 n1_M2_113460_60 n1_M2_114540_60 0.988200
R106 n1_M2_114540_60 n1_M2_115620_60 0.988200
R107 n1_M2_115620_60 n1_M2_116700_60 0.988200
R108 n1_M2_116700_60 n1_M2_117780_60 0.988200
R109 n1_M2_117780_60 n1_M2_118860_60 0.988200
R110 n1_M2_118860_60 n1_M2_119940_60 0.988200
R111 n1_M2_119940_60 n1_M2_121020_60 0.988200
R112 n1_M2_121020_60 n1_M2_122100_60 0.988200
R113 n1_M2_122100_60 n1_M2_123180_60 0.988200
R114 n1_M2_123180_60 n1_M2_124260_60 0.988200
R115 n1_M2_124260_60 n1_M2_125340_60 0.988200
R116 n1_M2_125340_60 n1_M2_126420_60 0.988200
R117 n1_M2_126420_60 n1_M2_127500_60 0.988200
R118 n1_M2_127500_60 n1_M2_128580_60 0.988200
R119 n1_M2_128580_60 n1_M2_129660_60 0.988200
R120 n1_M2_129660_60 n1_M2_130740_60 0.988200
R121 n1_M2_130740_60 n1_M2_131820_60 0.988200
R122 n1_M2_131820_60 n1_M2_132900_60 0.988200
R123 n1_M2_132900_60 n1_M2_133980_60 0.988200
R124 n1_M2_133980_60 n1_M2_135060_60 0.988200
R125 n1_M2_135060_60 n1_M2_136140_60 0.988200
R126 n1_M2_136140_60 n1_M2_137220_60 0.988200
R127 n1_M2_137220_60 n1_M2_138300_60 0.988200
R128 n1_M2_138300_60 n1_M2_139380_60 0.988200
R129 n1_M2_139380_60 n1_M2_140460_60 0.988200
R130 n1_M2_140460_60 n1_M2_141540_60 0.988200
R131 n1_M2_141540_60 n1_M2_142620_60 0.988200
R132 n1_M2_142620_60 n1_M2_143700_60 0.988200
R133 n1_M2_143700_60 n1_M2_144780_60 0.988200
R134 n1_M2_144780_60 n1_M2_145860_60 0.988200
R135 n1_M2_145860_60 n1_M2_146940_60 0.988200
R136 n1_M2_60_1140 n1_M2_1140_1140 0.988200
R137 n1_M2_1140_1140 n1_M2_2220_1140 0.988200
R138 n1_M2_2220_1140 n1_M2_3300_1140 0.988200
R139 n1_M2_3300_1140 n1_M2_4380_1140 0.988200
R140 n1_M2_4380_1140 n1_M2_5460_1140 0.988200
R141 n1_M2_5460_1140 n1_M2_6540_1140 0.988200
R142 n1_M2_6540_1140 n1_M2_7620_1140 0.988200
R143 n1_M2_7620_1140 n1_M2_8700_1140 0.988200
R144 n1_M2_8700_1140 n1_M2_9780_1140 0.988200
R145 n1_M2_9780_1140 n1_M2_10860_1140 0.988200
R146 n1_M2_10860_1140 n1_M2_11940_1140 0.988200
R147 n1_M2_11940_1140 n1_M2_13020_1140 0.988200
R148 n1_M2_13020_1140 n1_M2_14100_1140 0.988200
R149 n1_M2_14100_1140 n1_M2_15180_1140 0.988200
R150 n1_M2_15180_1140 n1_M2_16260_1140 0.988200
R151 n1_M2_16260_1140 n1_M2_17340_1140 0.988200
R152 n1_M2_17340_1140 n1_M2_18420_1140 0.988200
R153 n1_M2_18420_1140 n1_M2_19500_1140 0.988200
R154 n1_M2_19500_1140 n1_M2_20580_1140 0.988200
R155 n1_M2_20580_1140 n1_M2_21660_1140 0.988200
R156 n1_M2_21660_1140 n1_M2_22740_1140 0.988200
R157 n1_M2_22740_1140 n1_M2_23820_1140 0.988200
R158 n1_M2_23820_1140 n1_M2_24900_1140 0.988200
R159 n1_M2_24900_1140 n1_M2_25980_1140 0.988200
R160 n1_M2_25980_1140 n1_M2_27060_1140 0.988200
R161 n1_M2_27060_1140 n1_M2_28140_1140 0.988200
R162 n1_M2_28140_1140 n1_M2_29220_1140 0.988200
R163 n1_M2_29220_1140 n1_M2_30300_1140 0.988200
R164 n1_M2_30300_1140 n1_M2_31380_1140 0.988200
R165 n1_M2_31380_1140 n1_M2_32460_1140 0.988200
R166 n1_M2_32460_1140 n1_M2_33540_1140 0.988200
R167 n1_M2_33540_1140 n1_M2_34620_1140 0.988200
R168 n1_M2_34620_1140 n1_M2_35700_1140 0.988200
R169 n1_M2_35700_1140 n1_M2_36780_1140 0.988200
R170 n1_M2_36780_1140 n1_M2_37860_1140 0.988200
R171 n1_M2_37860_1140 n1_M2_38940_1140 0.988200
R172 n1_M2_38940_1140 n1_M2_40020_1140 0.988200
R173 n1_M2_40020_1140 n1_M2_41100_1140 0.988200
R174 n1_M2_41100_1140 n1_M2_42180_1140 0.988200
R175 n1_M2_42180_1140 n1_M2_43260_1140 0.988200
R176 n1_M2_43260_1140 n1_M2_44340_1140 0.988200
R177 n1_M2_44340_1140 n1_M2_45420_1140 0.988200
R178 n1_M2_45420_1140 n1_M2_46500_1140 0.988200
R179 n1_M2_46500_1140 n1_M2_47580_1140 0.988200
R180 n1_M2_47580_1140 n1_M2_48660_1140 0.988200
R181 n1_M2_48660_1140 n1_M2_49740_1140 0.988200
R182 n1_M2_49740_1140 n1_M2_50820_1140 0.988200
R183 n1_M2_50820_1140 n1_M2_51900_1140 0.988200
R184 n1_M2_51900_1140 n1_M2_52980_1140 0.988200
R185 n1_M2_52980_1140 n1_M2_54060_1140 0.988200
R186 n1_M2_54060_1140 n1_M2_55140_1140 0.988200
R187 n1_M2_55140_1140 n1_M2_56220_1140 0.988200
R188 n1_M2_56220_1140 n1_M2_57300_1140 0.988200
R189 n1_M2_57300_1140 n1_M2_58380_1140 0.988200
R190 n1_M2_58380_1140 n1_M2_59460_1140 0.988200
R191 n1_M2_59460_1140 n1_M2_60540_1140 0.988200
R192 n1_M2_60540_1140 n1_M2_61620_1140 0.988200
R193 n1_M2_61620_1140 n1_M2_62700_1140 0.988200
R194 n1_M2_62700_1140 n1_M2_63780_1140 0.988200
R195 n1_M2_63780_1140 n1_M2_64860_1140 0.988200
R196 n1_M2_64860_1140 n1_M2_65940_1140 0.988200
R197 n1_M2_65940_1140 n1_M2_67020_1140 0.988200
R198 n1_M2_67020_1140 n1_M2_68100_1140 0.988200
R199 n1_M2_68100_1140 n1_M2_69180_1140 0.988200
R200 n1_M2_69180_1140 n1_M2_70260_1140 0.988200
R201 n1_M2_70260_1140 n1_M2_71340_1140 0.988200
R202 n1_M2_71340_1140 n1_M2_72420_1140 0.988200
R203 n1_M2_72420_1140 n1_M2_73500_1140 0.988200
R204 n1_M2_73500_1140 n1_M2_74580_1140 0.988200
R205 n1_M2_74580_1140 n1_M2_75660_1140 0.988200
R206 n1_M2_75660_1140 n1_M2_76740_1140 0.988200
R207 n1_M2_76740_1140 n1_M2_77820_1140 0.988200
R208 n1_M2_77820_1140 n1_M2_78900_1140 0.988200
R209 n1_M2_78900_1140 n1_M2_79980_1140 0.988200
R210 n1_M2_79980_1140 n1_M2_81060_1140 0.988200
R211 n1_M2_81060_1140 n1_M2_82140_1140 0.988200
R212 n1_M2_82140_1140 n1_M2_83220_1140 0.988200
R213 n1_M2_83220_1140 n1_M2_84300_1140 0.988200
R214 n1_M2_84300_1140 n1_M2_85380_1140 0.988200
R215 n1_M2_85380_1140 n1_M2_86460_1140 0.988200
R216 n1_M2_86460_1140 n1_M2_87540_1140 0.988200
R217 n1_M2_87540_1140 n1_M2_88620_1140 0.988200
R218 n1_M2_88620_1140 n1_M2_89700_1140 0.988200
R219 n1_M2_89700_1140 n1_M2_90780_1140 0.988200
R220 n1_M2_90780_1140 n1_M2_91860_1140 0.988200
R221 n1_M2_91860_1140 n1_M2_92940_1140 0.988200
R222 n1_M2_92940_1140 n1_M2_94020_1140 0.988200
R223 n1_M2_94020_1140 n1_M2_95100_1140 0.988200
R224 n1_M2_95100_1140 n1_M2_96180_1140 0.988200
R225 n1_M2_96180_1140 n1_M2_97260_1140 0.988200
R226 n1_M2_97260_1140 n1_M2_98340_1140 0.988200
R227 n1_M2_98340_1140 n1_M2_99420_1140 0.988200
R228 n1_M2_99420_1140 n1_M2_100500_1140 0.988200
R229 n1_M2_100500_1140 n1_M2_101580_1140 0.988200
R230 n1_M2_101580_1140 n1_M2_102660_1140 0.988200
R231 n1_M2_102660_1140 n1_M2_103740_1140 0.988200
R232 n1_M2_103740_1140 n1_M2_104820_1140 0.988200
R233 n1_M2_104820_1140 n1_M2_105900_1140 0.988200
R234 n1_M2_105900_1140 n1_M2_106980_1140 0.988200
R235 n1_M2_106980_1140 n1_M2_108060_1140 0.988200
R236 n1_M2_108060_1140 n1_M2_109140_1140 0.988200
R237 n1_M2_109140_1140 n1_M2_110220_1140 0.988200
R238 n1_M2_110220_1140 n1_M2_111300_1140 0.988200
R239 n1_M2_111300_1140 n1_M2_112380_1140 0.988200
R240 n1_M2_112380_1140 n1_M2_113460_1140 0.988200
R241 n1_M2_113460_1140 n1_M2_114540_1140 0.988200
R242 n1_M2_114540_1140 n1_M2_115620_1140 0.988200
R243 n1_M2_115620_1140 n1_M2_116700_1140 0.988200
R244 n1_M2_116700_1140 n1_M2_117780_1140 0.988200
R245 n1_M2_117780_1140 n1_M2_118860_1140 0.988200
R246 n1_M2_118860_1140 n1_M2_119940_1140 0.988200
R247 n1_M2_119940_1140 n1_M2_121020_1140 0.988200
R248 n1_M2_121020_1140 n1_M2_122100_1140 0.988200
R249 n1_M2_122100_1140 n1_M2_123180_1140 0.988200
R250 n1_M2_123180_1140 n1_M2_124260_1140 0.988200
R251 n1_M2_124260_1140 n1_M2_125340_1140 0.988200
R252 n1_M2_125340_1140 n1_M2_126420_1140 0.988200
R253 n1_M2_126420_1140 n1_M2_127500_1140 0.988200
R254 n1_M2_127500_1140 n1_M2_128580_1140 0.988200
R255 n1_M2_128580_1140 n1_M2_129660_1140 0.988200
R256 n1_M2_129660_1140 n1_M2_130740_1140 0.988200
R257 n1_M2_130740_1140 n1_M2_131820_1140 0.988200
R258 n1_M2_131820_1140 n1_M2_132900_1140 0.988200
R259 n1_M2_132900_1140 n1_M2_133980_1140 0.988200
R260 n1_M2_133980_1140 n1_M2_135060_1140 0.988200
R261 n1_M2_135060_1140 n1_M2_136140_1140 0.988200
R262 n1_M2_136140_1140 n1_M2_137220_1140 0.988200
R263 n1_M2_137220_1140 n1_M2_138300_1140 0.988200
R264 n1_M2_138300_1140 n1_M2_139380_1140 0.988200
R265 n1_M2_139380_1140 n1_M2_140460_1140 0.988200
R266 n1_M2_140460_1140 n1_M2_141540_1140 0.988200
R267 n1_M2_141540_1140 n1_M2_142620_1140 0.988200
R268 n1_M2_142620_1140 n1_M2_143700_1140 0.988200
R269 n1_M2_143700_1140 n1_M2_144780_1140 0.988200
R270 n1_M2_144780_1140 n1_M2_145860_1140 0.988200
R271 n1_M2_145860_1140 n1_M2_146940_1140 0.988200
R272 n1_M2_60_2220 n1_M2_1140_2220 0.988200
R273 n1_M2_1140_2220 n1_M2_2220_2220 0.988200
R274 n1_M2_2220_2220 n1_M2_3300_2220 0.988200
R275 n1_M2_3300_2220 n1_M2_4380_2220 0.988200
R276 n1_M2_4380_2220 n1_M2_5460_2220 0.988200
R277 n1_M2_5460_2220 n1_M2_6540_2220 0.988200
R278 n1_M2_6540_2220 n1_M2_7620_2220 0.988200
R279 n1_M2_7620_2220 n1_M2_8700_2220 0.988200
R280 n1_M2_8700_2220 n1_M2_9780_2220 0.988200
R281 n1_M2_9780_2220 n1_M2_10860_2220 0.988200
R282 n1_M2_10860_2220 n1_M2_11940_2220 0.988200
R283 n1_M2_11940_2220 n1_M2_13020_2220 0.988200
R284 n1_M2_13020_2220 n1_M2_14100_2220 0.988200
R285 n1_M2_14100_2220 n1_M2_15180_2220 0.988200
R286 n1_M2_15180_2220 n1_M2_16260_2220 0.988200
R287 n1_M2_16260_2220 n1_M2_17340_2220 0.988200
R288 n1_M2_17340_2220 n1_M2_18420_2220 0.988200
R289 n1_M2_18420_2220 n1_M2_19500_2220 0.988200
R290 n1_M2_19500_2220 n1_M2_20580_2220 0.988200
R291 n1_M2_20580_2220 n1_M2_21660_2220 0.988200
R292 n1_M2_21660_2220 n1_M2_22740_2220 0.988200
R293 n1_M2_22740_2220 n1_M2_23820_2220 0.988200
R294 n1_M2_23820_2220 n1_M2_24900_2220 0.988200
R295 n1_M2_24900_2220 n1_M2_25980_2220 0.988200
R296 n1_M2_25980_2220 n1_M2_27060_2220 0.988200
R297 n1_M2_27060_2220 n1_M2_28140_2220 0.988200
R298 n1_M2_28140_2220 n1_M2_29220_2220 0.988200
R299 n1_M2_29220_2220 n1_M2_30300_2220 0.988200
R300 n1_M2_30300_2220 n1_M2_31380_2220 0.988200
R301 n1_M2_31380_2220 n1_M2_32460_2220 0.988200
R302 n1_M2_32460_2220 n1_M2_33540_2220 0.988200
R303 n1_M2_33540_2220 n1_M2_34620_2220 0.988200
R304 n1_M2_34620_2220 n1_M2_35700_2220 0.988200
R305 n1_M2_35700_2220 n1_M2_36780_2220 0.988200
R306 n1_M2_36780_2220 n1_M2_37860_2220 0.988200
R307 n1_M2_37860_2220 n1_M2_38940_2220 0.988200
R308 n1_M2_38940_2220 n1_M2_40020_2220 0.988200
R309 n1_M2_40020_2220 n1_M2_41100_2220 0.988200
R310 n1_M2_41100_2220 n1_M2_42180_2220 0.988200
R311 n1_M2_42180_2220 n1_M2_43260_2220 0.988200
R312 n1_M2_43260_2220 n1_M2_44340_2220 0.988200
R313 n1_M2_44340_2220 n1_M2_45420_2220 0.988200
R314 n1_M2_45420_2220 n1_M2_46500_2220 0.988200
R315 n1_M2_46500_2220 n1_M2_47580_2220 0.988200
R316 n1_M2_47580_2220 n1_M2_48660_2220 0.988200
R317 n1_M2_48660_2220 n1_M2_49740_2220 0.988200
R318 n1_M2_49740_2220 n1_M2_50820_2220 0.988200
R319 n1_M2_50820_2220 n1_M2_51900_2220 0.988200
R320 n1_M2_51900_2220 n1_M2_52980_2220 0.988200
R321 n1_M2_52980_2220 n1_M2_54060_2220 0.988200
R322 n1_M2_54060_2220 n1_M2_55140_2220 0.988200
R323 n1_M2_55140_2220 n1_M2_56220_2220 0.988200
R324 n1_M2_56220_2220 n1_M2_57300_2220 0.988200
R325 n1_M2_57300_2220 n1_M2_58380_2220 0.988200
R326 n1_M2_58380_2220 n1_M2_59460_2220 0.988200
R327 n1_M2_59460_2220 n1_M2_60540_2220 0.988200
R328 n1_M2_60540_2220 n1_M2_61620_2220 0.988200
R329 n1_M2_61620_2220 n1_M2_62700_2220 0.988200
R330 n1_M2_62700_2220 n1_M2_63780_2220 0.988200
R331 n1_M2_63780_2220 n1_M2_64860_2220 0.988200
R332 n1_M2_64860_2220 n1_M2_65940_2220 0.988200
R333 n1_M2_65940_2220 n1_M2_67020_2220 0.988200
R334 n1_M2_67020_2220 n1_M2_68100_2220 0.988200
R335 n1_M2_68100_2220 n1_M2_69180_2220 0.988200
R336 n1_M2_69180_2220 n1_M2_70260_2220 0.988200
R337 n1_M2_70260_2220 n1_M2_71340_2220 0.988200
R338 n1_M2_71340_2220 n1_M2_72420_2220 0.988200
R339 n1_M2_72420_2220 n1_M2_73500_2220 0.988200
R340 n1_M2_73500_2220 n1_M2_74580_2220 0.988200
R341 n1_M2_74580_2220 n1_M2_75660_2220 0.988200
R342 n1_M2_75660_2220 n1_M2_76740_2220 0.988200
R343 n1_M2_76740_2220 n1_M2_77820_2220 0.988200
R344 n1_M2_77820_2220 n1_M2_78900_2220 0.988200
R345 n1_M2_78900_2220 n1_M2_79980_2220 0.988200
R346 n1_M2_79980_2220 n1_M2_81060_2220 0.988200
R347 n1_M2_81060_2220 n1_M2_82140_2220 0.988200
R348 n1_M2_82140_2220 n1_M2_83220_2220 0.988200
R349 n1_M2_83220_2220 n1_M2_84300_2220 0.988200
R350 n1_M2_84300_2220 n1_M2_85380_2220 0.988200
R351 n1_M2_85380_2220 n1_M2_86460_2220 0.988200
R352 n1_M2_86460_2220 n1_M2_87540_2220 0.988200
R353 n1_M2_87540_2220 n1_M2_88620_2220 0.988200
R354 n1_M2_88620_2220 n1_M2_89700_2220 0.988200
R355 n1_M2_89700_2220 n1_M2_90780_2220 0.988200
R356 n1_M2_90780_2220 n1_M2_91860_2220 0.988200
R357 n1_M2_91860_2220 n1_M2_92940_2220 0.988200
R358 n1_M2_92940_2220 n1_M2_94020_2220 0.988200
R359 n1_M2_94020_2220 n1_M2_95100_2220 0.988200
R360 n1_M2_95100_2220 n1_M2_96180_2220 0.988200
R361 n1_M2_96180_2220 n1_M2_97260_2220 0.988200
R362 n1_M2_97260_2220 n1_M2_98340_2220 0.988200
R363 n1_M2_98340_2220 n1_M2_99420_2220 0.988200
R364 n1_M2_99420_2220 n1_M2_100500_2220 0.988200
R365 n1_M2_100500_2220 n1_M2_101580_2220 0.988200
R366 n1_M2_101580_2220 n1_M2_102660_2220 0.988200
R367 n1_M2_102660_2220 n1_M2_103740_2220 0.988200
R368 n1_M2_103740_2220 n1_M2_104820_2220 0.988200
R369 n1_M2_104820_2220 n1_M2_105900_2220 0.988200
R370 n1_M2_105900_2220 n1_M2_106980_2220 0.988200
R371 n1_M2_106980_2220 n1_M2_108060_2220 0.988200
R372 n1_M2_108060_2220 n1_M2_109140_2220 0.988200
R373 n1_M2_109140_2220 n1_M2_110220_2220 0.988200
R374 n1_M2_110220_2220 n1_M2_111300_2220 0.988200
R375 n1_M2_111300_2220 n1_M2_112380_2220 0.988200
R376 n1_M2_112380_2220 n1_M2_113460_2220 0.988200
R377 n1_M2_113460_2220 n1_M2_114540_2220 0.988200
R378 n1_M2_114540_2220 n1_M2_115620_2220 0.988200
R379 n1_M2_115620_2220 n1_M2_116700_2220 0.988200
R380 n1_M2_116700_2220 n1_M2_117780_2220 0.988200
R381 n1_M2_117780_2220 n1_M2_118860_2220 0.988200
R382 n1_M2_118860_2220 n1_M2_119940_2220 0.988200
R383 n1_M2_119940_2220 n1_M2_121020_2220 0.988200
R384 n1_M2_121020_2220 n1_M2_122100_2220 0.988200
R385 n1_M2_122100_2220 n1_M2_123180_2220 0.988200
R386 n1_M2_123180_2220 n1_M2_124260_2220 0.988200
R387 n1_M2_124260_2220 n1_M2_125340_2220 0.988200
R388 n1_M2_125340_2220 n1_M2_126420_2220 0.988200
R389 n1_M2_126420_2220 n1_M2_127500_2220 0.988200
R390 n1_M2_127500_2220 n1_M2_128580_2220 0.988200
R391 n1_M2_128580_2220 n1_M2_129660_2220 0.988200
R392 n1_M2_129660_2220 n1_M2_130740_2220 0.988200
R393 n1_M2_130740_2220 n1_M2_131820_2220 0.988200
R394 n1_M2_131820_2220 n1_M2_132900_2220 0.988200
R395 n1_M2_132900_2220 n1_M2_133980_2220 0.988200
R396 n1_M2_133980_2220 n1_M2_135060_2220 0.988200
R397 n1_M2_135060_2220 n1_M2_136140_2220 0.988200
R398 n1_M2_136140_2220 n1_M2_137220_2220 0.988200
R399 n1_M2_137220_2220 n1_M2_138300_2220 0.988200
R400 n1_M2_138300_2220 n1_M2_139380_2220 0.988200
R401 n1_M2_139380_2220 n1_M2_140460_2220 0.988200
R402 n1_M2_140460_2220 n1_M2_141540_2220 0.988200
R403 n1_M2_141540_2220 n1_M2_142620_2220 0.988200
R404 n1_M2_142620_2220 n1_M2_143700_2220 0.988200
R405 n1_M2_143700_2220 n1_M2_144780_2220 0.988200
R406 n1_M2_144780_2220 n1_M2_145860_2220 0.988200
R407 n1_M2_145860_2220 n1_M2_146940_2220 0.988200
R408 n1_M2_60_3300 n1_M2_1140_3300 0.988200
R409 n1_M2_1140_3300 n1_M2_2220_3300 0.988200
R410 n1_M2_2220_3300 n1_M2_3300_3300 0.988200
R411 n1_M2_3300_3300 n1_M2_4380_3300 0.988200
R412 n1_M2_4380_3300 n1_M2_5460_3300 0.988200
R413 n1_M2_5460_3300 n1_M2_6540_3300 0.988200
R414 n1_M2_6540_3300 n1_M2_7620_3300 0.988200
R415 n1_M2_7620_3300 n1_M2_8700_3300 0.988200
R416 n1_M2_8700_3300 n1_M2_9780_3300 0.988200
R417 n1_M2_9780_3300 n1_M2_10860_3300 0.988200
R418 n1_M2_10860_3300 n1_M2_11940_3300 0.988200
R419 n1_M2_11940_3300 n1_M2_13020_3300 0.988200
R420 n1_M2_13020_3300 n1_M2_14100_3300 0.988200
R421 n1_M2_14100_3300 n1_M2_15180_3300 0.988200
R422 n1_M2_15180_3300 n1_M2_16260_3300 0.988200
R423 n1_M2_16260_3300 n1_M2_17340_3300 0.988200
R424 n1_M2_17340_3300 n1_M2_18420_3300 0.988200
R425 n1_M2_18420_3300 n1_M2_19500_3300 0.988200
R426 n1_M2_19500_3300 n1_M2_20580_3300 0.988200
R427 n1_M2_20580_3300 n1_M2_21660_3300 0.988200
R428 n1_M2_21660_3300 n1_M2_22740_3300 0.988200
R429 n1_M2_22740_3300 n1_M2_23820_3300 0.988200
R430 n1_M2_23820_3300 n1_M2_24900_3300 0.988200
R431 n1_M2_24900_3300 n1_M2_25980_3300 0.988200
R432 n1_M2_25980_3300 n1_M2_27060_3300 0.988200
R433 n1_M2_27060_3300 n1_M2_28140_3300 0.988200
R434 n1_M2_28140_3300 n1_M2_29220_3300 0.988200
R435 n1_M2_29220_3300 n1_M2_30300_3300 0.988200
R436 n1_M2_30300_3300 n1_M2_31380_3300 0.988200
R437 n1_M2_31380_3300 n1_M2_32460_3300 0.988200
R438 n1_M2_32460_3300 n1_M2_33540_3300 0.988200
R439 n1_M2_33540_3300 n1_M2_34620_3300 0.988200
R440 n1_M2_34620_3300 n1_M2_35700_3300 0.988200
R441 n1_M2_35700_3300 n1_M2_36780_3300 0.988200
R442 n1_M2_36780_3300 n1_M2_37860_3300 0.988200
R443 n1_M2_37860_3300 n1_M2_38940_3300 0.988200
R444 n1_M2_38940_3300 n1_M2_40020_3300 0.988200
R445 n1_M2_40020_3300 n1_M2_41100_3300 0.988200
R446 n1_M2_41100_3300 n1_M2_42180_3300 0.988200
R447 n1_M2_42180_3300 n1_M2_43260_3300 0.988200
R448 n1_M2_43260_3300 n1_M2_44340_3300 0.988200
R449 n1_M2_44340_3300 n1_M2_45420_3300 0.988200
R450 n1_M2_45420_3300 n1_M2_46500_3300 0.988200
R451 n1_M2_46500_3300 n1_M2_47580_3300 0.988200
R452 n1_M2_47580_3300 n1_M2_48660_3300 0.988200
R453 n1_M2_48660_3300 n1_M2_49740_3300 0.988200
R454 n1_M2_49740_3300 n1_M2_50820_3300 0.988200
R455 n1_M2_50820_3300 n1_M2_51900_3300 0.988200
R456 n1_M2_51900_3300 n1_M2_52980_3300 0.988200
R457 n1_M2_52980_3300 n1_M2_54060_3300 0.988200
R458 n1_M2_54060_3300 n1_M2_55140_3300 0.988200
R459 n1_M2_55140_3300 n1_M2_56220_3300 0.988200
R460 n1_M2_56220_3300 n1_M2_57300_3300 0.988200
R461 n1_M2_57300_3300 n1_M2_58380_3300 0.988200
R462 n1_M2_58380_3300 n1_M2_59460_3300 0.988200
R463 n1_M2_59460_3300 n1_M2_60540_3300 0.988200
R464 n1_M2_60540_3300 n1_M2_61620_3300 0.988200
R465 n1_M2_61620_3300 n1_M2_62700_3300 0.988200
R466 n1_M2_62700_3300 n1_M2_63780_3300 0.988200
R467 n1_M2_63780_3300 n1_M2_64860_3300 0.988200
R468 n1_M2_64860_3300 n1_M2_65940_3300 0.988200
R469 n1_M2_65940_3300 n1_M2_67020_3300 0.988200
R470 n1_M2_67020_3300 n1_M2_68100_3300 0.988200
R471 n1_M2_68100_3300 n1_M2_69180_3300 0.988200
R472 n1_M2_69180_3300 n1_M2_70260_3300 0.988200
R473 n1_M2_70260_3300 n1_M2_71340_3300 0.988200
R474 n1_M2_71340_3300 n1_M2_72420_3300 0.988200
R475 n1_M2_72420_3300 n1_M2_73500_3300 0.988200
R476 n1_M2_73500_3300 n1_M2_74580_3300 0.988200
R477 n1_M2_74580_3300 n1_M2_75660_3300 0.988200
R478 n1_M2_75660_3300 n1_M2_76740_3300 0.988200
R479 n1_M2_76740_3300 n1_M2_77820_3300 0.988200
R480 n1_M2_77820_3300 n1_M2_78900_3300 0.988200
R481 n1_M2_78900_3300 n1_M2_79980_3300 0.988200
R482 n1_M2_79980_3300 n1_M2_81060_3300 0.988200
R483 n1_M2_81060_3300 n1_M2_82140_3300 0.988200
R484 n1_M2_82140_3300 n1_M2_83220_3300 0.988200
R485 n1_M2_83220_3300 n1_M2_84300_3300 0.988200
R486 n1_M2_84300_3300 n1_M2_85380_3300 0.988200
R487 n1_M2_85380_3300 n1_M2_86460_3300 0.988200
R488 n1_M2_86460_3300 n1_M2_87540_3300 0.988200
R489 n1_M2_87540_3300 n1_M2_88620_3300 0.988200
R490 n1_M2_88620_3300 n1_M2_89700_3300 0.988200
R491 n1_M2_89700_3300 n1_M2_90780_3300 0.988200
R492 n1_M2_90780_3300 n1_M2_91860_3300 0.988200
R493 n1_M2_91860_3300 n1_M2_92940_3300 0.988200
R494 n1_M2_92940_3300 n1_M2_94020_3300 0.988200
R495 n1_M2_94020_3300 n1_M2_95100_3300 0.988200
R496 n1_M2_95100_3300 n1_M2_96180_3300 0.988200
R497 n1_M2_96180_3300 n1_M2_97260_3300 0.988200
R498 n1_M2_97260_3300 n1_M2_98340_3300 0.988200
R499 n1_M2_98340_3300 n1_M2_99420_3300 0.988200
R500 n1_M2_99420_3300 n1_M2_100500_3300 0.988200
R501 n1_M2_100500_3300 n1_M2_101580_3300 0.988200
R502 n1_M2_101580_3300 n1_M2_102660_3300 0.988200
R503 n1_M2_102660_3300 n1_M2_103740_3300 0.988200
R504 n1_M2_103740_3300 n1_M2_104820_3300 0.988200
R505 n1_M2_104820_3300 n1_M2_105900_3300 0.988200
R506 n1_M2_105900_3300 n1_M2_106980_3300 0.988200
R507 n1_M2_106980_3300 n1_M2_108060_3300 0.988200
R508 n1_M2_108060_3300 n1_M2_109140_3300 0.988200
R509 n1_M2_109140_3300 n1_M2_110220_3300 0.988200
R510 n1_M2_110220_3300 n1_M2_111300_3300 0.988200
R511 n1_M2_111300_3300 n1_M2_112380_3300 0.988200
R512 n1_M2_112380_3300 n1_M2_113460_3300 0.988200
R513 n1_M2_113460_3300 n1_M2_114540_3300 0.988200
R514 n1_M2_114540_3300 n1_M2_115620_3300 0.988200
R515 n1_M2_115620_3300 n1_M2_116700_3300 0.988200
R516 n1_M2_116700_3300 n1_M2_117780_3300 0.988200
R517 n1_M2_117780_3300 n1_M2_118860_3300 0.988200
R518 n1_M2_118860_3300 n1_M2_119940_3300 0.988200
R519 n1_M2_119940_3300 n1_M2_121020_3300 0.988200
R520 n1_M2_121020_3300 n1_M2_122100_3300 0.988200
R521 n1_M2_122100_3300 n1_M2_123180_3300 0.988200
R522 n1_M2_123180_3300 n1_M2_124260_3300 0.988200
R523 n1_M2_124260_3300 n1_M2_125340_3300 0.988200
R524 n1_M2_125340_3300 n1_M2_126420_3300 0.988200
R525 n1_M2_126420_3300 n1_M2_127500_3300 0.988200
R526 n1_M2_127500_3300 n1_M2_128580_3300 0.988200
R527 n1_M2_128580_3300 n1_M2_129660_3300 0.988200
R528 n1_M2_129660_3300 n1_M2_130740_3300 0.988200
R529 n1_M2_130740_3300 n1_M2_131820_3300 0.988200
R530 n1_M2_131820_3300 n1_M2_132900_3300 0.988200
R531 n1_M2_132900_3300 n1_M2_133980_3300 0.988200
R532 n1_M2_133980_3300 n1_M2_135060_3300 0.988200
R533 n1_M2_135060_3300 n1_M2_136140_3300 0.988200
R534 n1_M2_136140_3300 n1_M2_137220_3300 0.988200
R535 n1_M2_137220_3300 n1_M2_138300_3300 0.988200
R536 n1_M2_138300_3300 n1_M2_139380_3300 0.988200
R537 n1_M2_139380_3300 n1_M2_140460_3300 0.988200
R538 n1_M2_140460_3300 n1_M2_141540_3300 0.988200
R539 n1_M2_141540_3300 n1_M2_142620_3300 0.988200
R540 n1_M2_142620_3300 n1_M2_143700_3300 0.988200
R541 n1_M2_143700_3300 n1_M2_144780_3300 0.988200
R542 n1_M2_144780_3300 n1_M2_145860_3300 0.988200
R543 n1_M2_145860_3300 n1_M2_146940_3300 0.988200
R544 n1_M2_60_4380 n1_M2_1140_4380 0.988200
R545 n1_M2_1140_4380 n1_M2_2220_4380 0.988200
R546 n1_M2_2220_4380 n1_M2_3300_4380 0.988200
R547 n1_M2_3300_4380 n1_M2_4380_4380 0.988200
R548 n1_M2_4380_4380 n1_M2_5460_4380 0.988200
R549 n1_M2_5460_4380 n1_M2_6540_4380 0.988200
R550 n1_M2_6540_4380 n1_M2_7620_4380 0.988200
R551 n1_M2_7620_4380 n1_M2_8700_4380 0.988200
R552 n1_M2_8700_4380 n1_M2_9780_4380 0.988200
R553 n1_M2_9780_4380 n1_M2_10860_4380 0.988200
R554 n1_M2_10860_4380 n1_M2_11940_4380 0.988200
R555 n1_M2_11940_4380 n1_M2_13020_4380 0.988200
R556 n1_M2_13020_4380 n1_M2_14100_4380 0.988200
R557 n1_M2_14100_4380 n1_M2_15180_4380 0.988200
R558 n1_M2_15180_4380 n1_M2_16260_4380 0.988200
R559 n1_M2_16260_4380 n1_M2_17340_4380 0.988200
R560 n1_M2_17340_4380 n1_M2_18420_4380 0.988200
R561 n1_M2_18420_4380 n1_M2_19500_4380 0.988200
R562 n1_M2_19500_4380 n1_M2_20580_4380 0.988200
R563 n1_M2_20580_4380 n1_M2_21660_4380 0.988200
R564 n1_M2_21660_4380 n1_M2_22740_4380 0.988200
R565 n1_M2_22740_4380 n1_M2_23820_4380 0.988200
R566 n1_M2_23820_4380 n1_M2_24900_4380 0.988200
R567 n1_M2_24900_4380 n1_M2_25980_4380 0.988200
R568 n1_M2_25980_4380 n1_M2_27060_4380 0.988200
R569 n1_M2_27060_4380 n1_M2_28140_4380 0.988200
R570 n1_M2_28140_4380 n1_M2_29220_4380 0.988200
R571 n1_M2_29220_4380 n1_M2_30300_4380 0.988200
R572 n1_M2_30300_4380 n1_M2_31380_4380 0.988200
R573 n1_M2_31380_4380 n1_M2_32460_4380 0.988200
R574 n1_M2_32460_4380 n1_M2_33540_4380 0.988200
R575 n1_M2_33540_4380 n1_M2_34620_4380 0.988200
R576 n1_M2_34620_4380 n1_M2_35700_4380 0.988200
R577 n1_M2_35700_4380 n1_M2_36780_4380 0.988200
R578 n1_M2_36780_4380 n1_M2_37860_4380 0.988200
R579 n1_M2_37860_4380 n1_M2_38940_4380 0.988200
R580 n1_M2_38940_4380 n1_M2_40020_4380 0.988200
R581 n1_M2_40020_4380 n1_M2_41100_4380 0.988200
R582 n1_M2_41100_4380 n1_M2_42180_4380 0.988200
R583 n1_M2_42180_4380 n1_M2_43260_4380 0.988200
R584 n1_M2_43260_4380 n1_M2_44340_4380 0.988200
R585 n1_M2_44340_4380 n1_M2_45420_4380 0.988200
R586 n1_M2_45420_4380 n1_M2_46500_4380 0.988200
R587 n1_M2_46500_4380 n1_M2_47580_4380 0.988200
R588 n1_M2_47580_4380 n1_M2_48660_4380 0.988200
R589 n1_M2_48660_4380 n1_M2_49740_4380 0.988200
R590 n1_M2_49740_4380 n1_M2_50820_4380 0.988200
R591 n1_M2_50820_4380 n1_M2_51900_4380 0.988200
R592 n1_M2_51900_4380 n1_M2_52980_4380 0.988200
R593 n1_M2_52980_4380 n1_M2_54060_4380 0.988200
R594 n1_M2_54060_4380 n1_M2_55140_4380 0.988200
R595 n1_M2_55140_4380 n1_M2_56220_4380 0.988200
R596 n1_M2_56220_4380 n1_M2_57300_4380 0.988200
R597 n1_M2_57300_4380 n1_M2_58380_4380 0.988200
R598 n1_M2_58380_4380 n1_M2_59460_4380 0.988200
R599 n1_M2_59460_4380 n1_M2_60540_4380 0.988200
R600 n1_M2_60540_4380 n1_M2_61620_4380 0.988200
R601 n1_M2_61620_4380 n1_M2_62700_4380 0.988200
R602 n1_M2_62700_4380 n1_M2_63780_4380 0.988200
R603 n1_M2_63780_4380 n1_M2_64860_4380 0.988200
R604 n1_M2_64860_4380 n1_M2_65940_4380 0.988200
R605 n1_M2_65940_4380 n1_M2_67020_4380 0.988200
R606 n1_M2_67020_4380 n1_M2_68100_4380 0.988200
R607 n1_M2_68100_4380 n1_M2_69180_4380 0.988200
R608 n1_M2_69180_4380 n1_M2_70260_4380 0.988200
R609 n1_M2_70260_4380 n1_M2_71340_4380 0.988200
R610 n1_M2_71340_4380 n1_M2_72420_4380 0.988200
R611 n1_M2_72420_4380 n1_M2_73500_4380 0.988200
R612 n1_M2_73500_4380 n1_M2_74580_4380 0.988200
R613 n1_M2_74580_4380 n1_M2_75660_4380 0.988200
R614 n1_M2_75660_4380 n1_M2_76740_4380 0.988200
R615 n1_M2_76740_4380 n1_M2_77820_4380 0.988200
R616 n1_M2_77820_4380 n1_M2_78900_4380 0.988200
R617 n1_M2_78900_4380 n1_M2_79980_4380 0.988200
R618 n1_M2_79980_4380 n1_M2_81060_4380 0.988200
R619 n1_M2_81060_4380 n1_M2_82140_4380 0.988200
R620 n1_M2_82140_4380 n1_M2_83220_4380 0.988200
R621 n1_M2_83220_4380 n1_M2_84300_4380 0.988200
R622 n1_M2_84300_4380 n1_M2_85380_4380 0.988200
R623 n1_M2_85380_4380 n1_M2_86460_4380 0.988200
R624 n1_M2_86460_4380 n1_M2_87540_4380 0.988200
R625 n1_M2_87540_4380 n1_M2_88620_4380 0.988200
R626 n1_M2_88620_4380 n1_M2_89700_4380 0.988200
R627 n1_M2_89700_4380 n1_M2_90780_4380 0.988200
R628 n1_M2_90780_4380 n1_M2_91860_4380 0.988200
R629 n1_M2_91860_4380 n1_M2_92940_4380 0.988200
R630 n1_M2_92940_4380 n1_M2_94020_4380 0.988200
R631 n1_M2_94020_4380 n1_M2_95100_4380 0.988200
R632 n1_M2_95100_4380 n1_M2_96180_4380 0.988200
R633 n1_M2_96180_4380 n1_M2_97260_4380 0.988200
R634 n1_M2_97260_4380 n1_M2_98340_4380 0.988200
R635 n1_M2_98340_4380 n1_M2_99420_4380 0.988200
R636 n1_M2_99420_4380 n1_M2_100500_4380 0.988200
R637 n1_M2_100500_4380 n1_M2_101580_4380 0.988200
R638 n1_M2_101580_4380 n1_M2_102660_4380 0.988200
R639 n1_M2_102660_4380 n1_M2_103740_4380 0.988200
R640 n1_M2_103740_4380 n1_M2_104820_4380 0.988200
R641 n1_M2_104820_4380 n1_M2_105900_4380 0.988200
R642 n1_M2_105900_4380 n1_M2_106980_4380 0.988200
R643 n1_M2_106980_4380 n1_M2_108060_4380 0.988200
R644 n1_M2_108060_4380 n1_M2_109140_4380 0.988200
R645 n1_M2_109140_4380 n1_M2_110220_4380 0.988200
R646 n1_M2_110220_4380 n1_M2_111300_4380 0.988200
R647 n1_M2_111300_4380 n1_M2_112380_4380 0.988200
R648 n1_M2_112380_4380 n1_M2_113460_4380 0.988200
R649 n1_M2_113460_4380 n1_M2_114540_4380 0.988200
R650 n1_M2_114540_4380 n1_M2_115620_4380 0.988200
R651 n1_M2_115620_4380 n1_M2_116700_4380 0.988200
R652 n1_M2_116700_4380 n1_M2_117780_4380 0.988200
R653 n1_M2_117780_4380 n1_M2_118860_4380 0.988200
R654 n1_M2_118860_4380 n1_M2_119940_4380 0.988200
R655 n1_M2_119940_4380 n1_M2_121020_4380 0.988200
R656 n1_M2_121020_4380 n1_M2_122100_4380 0.988200
R657 n1_M2_122100_4380 n1_M2_123180_4380 0.988200
R658 n1_M2_123180_4380 n1_M2_124260_4380 0.988200
R659 n1_M2_124260_4380 n1_M2_125340_4380 0.988200
R660 n1_M2_125340_4380 n1_M2_126420_4380 0.988200
R661 n1_M2_126420_4380 n1_M2_127500_4380 0.988200
R662 n1_M2_127500_4380 n1_M2_128580_4380 0.988200
R663 n1_M2_128580_4380 n1_M2_129660_4380 0.988200
R664 n1_M2_129660_4380 n1_M2_130740_4380 0.988200
R665 n1_M2_130740_4380 n1_M2_131820_4380 0.988200
R666 n1_M2_131820_4380 n1_M2_132900_4380 0.988200
R667 n1_M2_132900_4380 n1_M2_133980_4380 0.988200
R668 n1_M2_133980_4380 n1_M2_135060_4380 0.988200
R669 n1_M2_135060_4380 n1_M2_136140_4380 0.988200
R670 n1_M2_136140_4380 n1_M2_137220_4380 0.988200
R671 n1_M2_137220_4380 n1_M2_138300_4380 0.988200
R672 n1_M2_138300_4380 n1_M2_139380_4380 0.988200
R673 n1_M2_139380_4380 n1_M2_140460_4380 0.988200
R674 n1_M2_140460_4380 n1_M2_141540_4380 0.988200
R675 n1_M2_141540_4380 n1_M2_142620_4380 0.988200
R676 n1_M2_142620_4380 n1_M2_143700_4380 0.988200
R677 n1_M2_143700_4380 n1_M2_144780_4380 0.988200
R678 n1_M2_144780_4380 n1_M2_145860_4380 0.988200
R679 n1_M2_145860_4380 n1_M2_146940_4380 0.988200
R680 n1_M2_60_5460 n1_M2_1140_5460 0.988200
R681 n1_M2_1140_5460 n1_M2_2220_5460 0.988200
R682 n1_M2_2220_5460 n1_M2_3300_5460 0.988200
R683 n1_M2_3300_5460 n1_M2_4380_5460 0.988200
R684 n1_M2_4380_5460 n1_M2_5460_5460 0.988200
R685 n1_M2_5460_5460 n1_M2_6540_5460 0.988200
R686 n1_M2_6540_5460 n1_M2_7620_5460 0.988200
R687 n1_M2_7620_5460 n1_M2_8700_5460 0.988200
R688 n1_M2_8700_5460 n1_M2_9780_5460 0.988200
R689 n1_M2_9780_5460 n1_M2_10860_5460 0.988200
R690 n1_M2_10860_5460 n1_M2_11940_5460 0.988200
R691 n1_M2_11940_5460 n1_M2_13020_5460 0.988200
R692 n1_M2_13020_5460 n1_M2_14100_5460 0.988200
R693 n1_M2_14100_5460 n1_M2_15180_5460 0.988200
R694 n1_M2_15180_5460 n1_M2_16260_5460 0.988200
R695 n1_M2_16260_5460 n1_M2_17340_5460 0.988200
R696 n1_M2_17340_5460 n1_M2_18420_5460 0.988200
R697 n1_M2_18420_5460 n1_M2_19500_5460 0.988200
R698 n1_M2_19500_5460 n1_M2_20580_5460 0.988200
R699 n1_M2_20580_5460 n1_M2_21660_5460 0.988200
R700 n1_M2_21660_5460 n1_M2_22740_5460 0.988200
R701 n1_M2_22740_5460 n1_M2_23820_5460 0.988200
R702 n1_M2_23820_5460 n1_M2_24900_5460 0.988200
R703 n1_M2_24900_5460 n1_M2_25980_5460 0.988200
R704 n1_M2_25980_5460 n1_M2_27060_5460 0.988200
R705 n1_M2_27060_5460 n1_M2_28140_5460 0.988200
R706 n1_M2_28140_5460 n1_M2_29220_5460 0.988200
R707 n1_M2_29220_5460 n1_M2_30300_5460 0.988200
R708 n1_M2_30300_5460 n1_M2_31380_5460 0.988200
R709 n1_M2_31380_5460 n1_M2_32460_5460 0.988200
R710 n1_M2_32460_5460 n1_M2_33540_5460 0.988200
R711 n1_M2_33540_5460 n1_M2_34620_5460 0.988200
R712 n1_M2_34620_5460 n1_M2_35700_5460 0.988200
R713 n1_M2_35700_5460 n1_M2_36780_5460 0.988200
R714 n1_M2_36780_5460 n1_M2_37860_5460 0.988200
R715 n1_M2_37860_5460 n1_M2_38940_5460 0.988200
R716 n1_M2_38940_5460 n1_M2_40020_5460 0.988200
R717 n1_M2_40020_5460 n1_M2_41100_5460 0.988200
R718 n1_M2_41100_5460 n1_M2_42180_5460 0.988200
R719 n1_M2_42180_5460 n1_M2_43260_5460 0.988200
R720 n1_M2_43260_5460 n1_M2_44340_5460 0.988200
R721 n1_M2_44340_5460 n1_M2_45420_5460 0.988200
R722 n1_M2_45420_5460 n1_M2_46500_5460 0.988200
R723 n1_M2_46500_5460 n1_M2_47580_5460 0.988200
R724 n1_M2_47580_5460 n1_M2_48660_5460 0.988200
R725 n1_M2_48660_5460 n1_M2_49740_5460 0.988200
R726 n1_M2_49740_5460 n1_M2_50820_5460 0.988200
R727 n1_M2_50820_5460 n1_M2_51900_5460 0.988200
R728 n1_M2_51900_5460 n1_M2_52980_5460 0.988200
R729 n1_M2_52980_5460 n1_M2_54060_5460 0.988200
R730 n1_M2_54060_5460 n1_M2_55140_5460 0.988200
R731 n1_M2_55140_5460 n1_M2_56220_5460 0.988200
R732 n1_M2_56220_5460 n1_M2_57300_5460 0.988200
R733 n1_M2_57300_5460 n1_M2_58380_5460 0.988200
R734 n1_M2_58380_5460 n1_M2_59460_5460 0.988200
R735 n1_M2_59460_5460 n1_M2_60540_5460 0.988200
R736 n1_M2_60540_5460 n1_M2_61620_5460 0.988200
R737 n1_M2_61620_5460 n1_M2_62700_5460 0.988200
R738 n1_M2_62700_5460 n1_M2_63780_5460 0.988200
R739 n1_M2_63780_5460 n1_M2_64860_5460 0.988200
R740 n1_M2_64860_5460 n1_M2_65940_5460 0.988200
R741 n1_M2_65940_5460 n1_M2_67020_5460 0.988200
R742 n1_M2_67020_5460 n1_M2_68100_5460 0.988200
R743 n1_M2_68100_5460 n1_M2_69180_5460 0.988200
R744 n1_M2_69180_5460 n1_M2_70260_5460 0.988200
R745 n1_M2_70260_5460 n1_M2_71340_5460 0.988200
R746 n1_M2_71340_5460 n1_M2_72420_5460 0.988200
R747 n1_M2_72420_5460 n1_M2_73500_5460 0.988200
R748 n1_M2_73500_5460 n1_M2_74580_5460 0.988200
R749 n1_M2_74580_5460 n1_M2_75660_5460 0.988200
R750 n1_M2_75660_5460 n1_M2_76740_5460 0.988200
R751 n1_M2_76740_5460 n1_M2_77820_5460 0.988200
R752 n1_M2_77820_5460 n1_M2_78900_5460 0.988200
R753 n1_M2_78900_5460 n1_M2_79980_5460 0.988200
R754 n1_M2_79980_5460 n1_M2_81060_5460 0.988200
R755 n1_M2_81060_5460 n1_M2_82140_5460 0.988200
R756 n1_M2_82140_5460 n1_M2_83220_5460 0.988200
R757 n1_M2_83220_5460 n1_M2_84300_5460 0.988200
R758 n1_M2_84300_5460 n1_M2_85380_5460 0.988200
R759 n1_M2_85380_5460 n1_M2_86460_5460 0.988200
R760 n1_M2_86460_5460 n1_M2_87540_5460 0.988200
R761 n1_M2_87540_5460 n1_M2_88620_5460 0.988200
R762 n1_M2_88620_5460 n1_M2_89700_5460 0.988200
R763 n1_M2_89700_5460 n1_M2_90780_5460 0.988200
R764 n1_M2_90780_5460 n1_M2_91860_5460 0.988200
R765 n1_M2_91860_5460 n1_M2_92940_5460 0.988200
R766 n1_M2_92940_5460 n1_M2_94020_5460 0.988200
R767 n1_M2_94020_5460 n1_M2_95100_5460 0.988200
R768 n1_M2_95100_5460 n1_M2_96180_5460 0.988200
R769 n1_M2_96180_5460 n1_M2_97260_5460 0.988200
R770 n1_M2_97260_5460 n1_M2_98340_5460 0.988200
R771 n1_M2_98340_5460 n1_M2_99420_5460 0.988200
R772 n1_M2_99420_5460 n1_M2_100500_5460 0.988200
R773 n1_M2_100500_5460 n1_M2_101580_5460 0.988200
R774 n1_M2_101580_5460 n1_M2_102660_5460 0.988200
R775 n1_M2_102660_5460 n1_M2_103740_5460 0.988200
R776 n1_M2_103740_5460 n1_M2_104820_5460 0.988200
R777 n1_M2_104820_5460 n1_M2_105900_5460 0.988200
R778 n1_M2_105900_5460 n1_M2_106980_5460 0.988200
R779 n1_M2_106980_5460 n1_M2_108060_5460 0.988200
R780 n1_M2_108060_5460 n1_M2_109140_5460 0.988200
R781 n1_M2_109140_5460 n1_M2_110220_5460 0.988200
R782 n1_M2_110220_5460 n1_M2_111300_5460 0.988200
R783 n1_M2_111300_5460 n1_M2_112380_5460 0.988200
R784 n1_M2_112380_5460 n1_M2_113460_5460 0.988200
R785 n1_M2_113460_5460 n1_M2_114540_5460 0.988200
R786 n1_M2_114540_5460 n1_M2_115620_5460 0.988200
R787 n1_M2_115620_5460 n1_M2_116700_5460 0.988200
R788 n1_M2_116700_5460 n1_M2_117780_5460 0.988200
R789 n1_M2_117780_5460 n1_M2_118860_5460 0.988200
R790 n1_M2_118860_5460 n1_M2_119940_5460 0.988200
R791 n1_M2_119940_5460 n1_M2_121020_5460 0.988200
R792 n1_M2_121020_5460 n1_M2_122100_5460 0.988200
R793 n1_M2_122100_5460 n1_M2_123180_5460 0.988200
R794 n1_M2_123180_5460 n1_M2_124260_5460 0.988200
R795 n1_M2_124260_5460 n1_M2_125340_5460 0.988200
R796 n1_M2_125340_5460 n1_M2_126420_5460 0.988200
R797 n1_M2_126420_5460 n1_M2_127500_5460 0.988200
R798 n1_M2_127500_5460 n1_M2_128580_5460 0.988200
R799 n1_M2_128580_5460 n1_M2_129660_5460 0.988200
R800 n1_M2_129660_5460 n1_M2_130740_5460 0.988200
R801 n1_M2_130740_5460 n1_M2_131820_5460 0.988200
R802 n1_M2_131820_5460 n1_M2_132900_5460 0.988200
R803 n1_M2_132900_5460 n1_M2_133980_5460 0.988200
R804 n1_M2_133980_5460 n1_M2_135060_5460 0.988200
R805 n1_M2_135060_5460 n1_M2_136140_5460 0.988200
R806 n1_M2_136140_5460 n1_M2_137220_5460 0.988200
R807 n1_M2_137220_5460 n1_M2_138300_5460 0.988200
R808 n1_M2_138300_5460 n1_M2_139380_5460 0.988200
R809 n1_M2_139380_5460 n1_M2_140460_5460 0.988200
R810 n1_M2_140460_5460 n1_M2_141540_5460 0.988200
R811 n1_M2_141540_5460 n1_M2_142620_5460 0.988200
R812 n1_M2_142620_5460 n1_M2_143700_5460 0.988200
R813 n1_M2_143700_5460 n1_M2_144780_5460 0.988200
R814 n1_M2_144780_5460 n1_M2_145860_5460 0.988200
R815 n1_M2_145860_5460 n1_M2_146940_5460 0.988200
R816 n1_M2_60_6540 n1_M2_1140_6540 0.988200
R817 n1_M2_1140_6540 n1_M2_2220_6540 0.988200
R818 n1_M2_2220_6540 n1_M2_3300_6540 0.988200
R819 n1_M2_3300_6540 n1_M2_4380_6540 0.988200
R820 n1_M2_4380_6540 n1_M2_5460_6540 0.988200
R821 n1_M2_5460_6540 n1_M2_6540_6540 0.988200
R822 n1_M2_6540_6540 n1_M2_7620_6540 0.988200
R823 n1_M2_7620_6540 n1_M2_8700_6540 0.988200
R824 n1_M2_8700_6540 n1_M2_9780_6540 0.988200
R825 n1_M2_9780_6540 n1_M2_10860_6540 0.988200
R826 n1_M2_10860_6540 n1_M2_11940_6540 0.988200
R827 n1_M2_11940_6540 n1_M2_13020_6540 0.988200
R828 n1_M2_13020_6540 n1_M2_14100_6540 0.988200
R829 n1_M2_14100_6540 n1_M2_15180_6540 0.988200
R830 n1_M2_15180_6540 n1_M2_16260_6540 0.988200
R831 n1_M2_16260_6540 n1_M2_17340_6540 0.988200
R832 n1_M2_17340_6540 n1_M2_18420_6540 0.988200
R833 n1_M2_18420_6540 n1_M2_19500_6540 0.988200
R834 n1_M2_19500_6540 n1_M2_20580_6540 0.988200
R835 n1_M2_20580_6540 n1_M2_21660_6540 0.988200
R836 n1_M2_21660_6540 n1_M2_22740_6540 0.988200
R837 n1_M2_22740_6540 n1_M2_23820_6540 0.988200
R838 n1_M2_23820_6540 n1_M2_24900_6540 0.988200
R839 n1_M2_24900_6540 n1_M2_25980_6540 0.988200
R840 n1_M2_25980_6540 n1_M2_27060_6540 0.988200
R841 n1_M2_27060_6540 n1_M2_28140_6540 0.988200
R842 n1_M2_28140_6540 n1_M2_29220_6540 0.988200
R843 n1_M2_29220_6540 n1_M2_30300_6540 0.988200
R844 n1_M2_30300_6540 n1_M2_31380_6540 0.988200
R845 n1_M2_31380_6540 n1_M2_32460_6540 0.988200
R846 n1_M2_32460_6540 n1_M2_33540_6540 0.988200
R847 n1_M2_33540_6540 n1_M2_34620_6540 0.988200
R848 n1_M2_34620_6540 n1_M2_35700_6540 0.988200
R849 n1_M2_35700_6540 n1_M2_36780_6540 0.988200
R850 n1_M2_36780_6540 n1_M2_37860_6540 0.988200
R851 n1_M2_37860_6540 n1_M2_38940_6540 0.988200
R852 n1_M2_38940_6540 n1_M2_40020_6540 0.988200
R853 n1_M2_40020_6540 n1_M2_41100_6540 0.988200
R854 n1_M2_41100_6540 n1_M2_42180_6540 0.988200
R855 n1_M2_42180_6540 n1_M2_43260_6540 0.988200
R856 n1_M2_43260_6540 n1_M2_44340_6540 0.988200
R857 n1_M2_44340_6540 n1_M2_45420_6540 0.988200
R858 n1_M2_45420_6540 n1_M2_46500_6540 0.988200
R859 n1_M2_46500_6540 n1_M2_47580_6540 0.988200
R860 n1_M2_47580_6540 n1_M2_48660_6540 0.988200
R861 n1_M2_48660_6540 n1_M2_49740_6540 0.988200
R862 n1_M2_49740_6540 n1_M2_50820_6540 0.988200
R863 n1_M2_50820_6540 n1_M2_51900_6540 0.988200
R864 n1_M2_51900_6540 n1_M2_52980_6540 0.988200
R865 n1_M2_52980_6540 n1_M2_54060_6540 0.988200
R866 n1_M2_54060_6540 n1_M2_55140_6540 0.988200
R867 n1_M2_55140_6540 n1_M2_56220_6540 0.988200
R868 n1_M2_56220_6540 n1_M2_57300_6540 0.988200
R869 n1_M2_57300_6540 n1_M2_58380_6540 0.988200
R870 n1_M2_58380_6540 n1_M2_59460_6540 0.988200
R871 n1_M2_59460_6540 n1_M2_60540_6540 0.988200
R872 n1_M2_60540_6540 n1_M2_61620_6540 0.988200
R873 n1_M2_61620_6540 n1_M2_62700_6540 0.988200
R874 n1_M2_62700_6540 n1_M2_63780_6540 0.988200
R875 n1_M2_63780_6540 n1_M2_64860_6540 0.988200
R876 n1_M2_64860_6540 n1_M2_65940_6540 0.988200
R877 n1_M2_65940_6540 n1_M2_67020_6540 0.988200
R878 n1_M2_67020_6540 n1_M2_68100_6540 0.988200
R879 n1_M2_68100_6540 n1_M2_69180_6540 0.988200
R880 n1_M2_69180_6540 n1_M2_70260_6540 0.988200
R881 n1_M2_70260_6540 n1_M2_71340_6540 0.988200
R882 n1_M2_71340_6540 n1_M2_72420_6540 0.988200
R883 n1_M2_72420_6540 n1_M2_73500_6540 0.988200
R884 n1_M2_73500_6540 n1_M2_74580_6540 0.988200
R885 n1_M2_74580_6540 n1_M2_75660_6540 0.988200
R886 n1_M2_75660_6540 n1_M2_76740_6540 0.988200
R887 n1_M2_76740_6540 n1_M2_77820_6540 0.988200
R888 n1_M2_77820_6540 n1_M2_78900_6540 0.988200
R889 n1_M2_78900_6540 n1_M2_79980_6540 0.988200
R890 n1_M2_79980_6540 n1_M2_81060_6540 0.988200
R891 n1_M2_81060_6540 n1_M2_82140_6540 0.988200
R892 n1_M2_82140_6540 n1_M2_83220_6540 0.988200
R893 n1_M2_83220_6540 n1_M2_84300_6540 0.988200
R894 n1_M2_84300_6540 n1_M2_85380_6540 0.988200
R895 n1_M2_85380_6540 n1_M2_86460_6540 0.988200
R896 n1_M2_86460_6540 n1_M2_87540_6540 0.988200
R897 n1_M2_87540_6540 n1_M2_88620_6540 0.988200
R898 n1_M2_88620_6540 n1_M2_89700_6540 0.988200
R899 n1_M2_89700_6540 n1_M2_90780_6540 0.988200
R900 n1_M2_90780_6540 n1_M2_91860_6540 0.988200
R901 n1_M2_91860_6540 n1_M2_92940_6540 0.988200
R902 n1_M2_92940_6540 n1_M2_94020_6540 0.988200
R903 n1_M2_94020_6540 n1_M2_95100_6540 0.988200
R904 n1_M2_95100_6540 n1_M2_96180_6540 0.988200
R905 n1_M2_96180_6540 n1_M2_97260_6540 0.988200
R906 n1_M2_97260_6540 n1_M2_98340_6540 0.988200
R907 n1_M2_98340_6540 n1_M2_99420_6540 0.988200
R908 n1_M2_99420_6540 n1_M2_100500_6540 0.988200
R909 n1_M2_100500_6540 n1_M2_101580_6540 0.988200
R910 n1_M2_101580_6540 n1_M2_102660_6540 0.988200
R911 n1_M2_102660_6540 n1_M2_103740_6540 0.988200
R912 n1_M2_103740_6540 n1_M2_104820_6540 0.988200
R913 n1_M2_104820_6540 n1_M2_105900_6540 0.988200
R914 n1_M2_105900_6540 n1_M2_106980_6540 0.988200
R915 n1_M2_106980_6540 n1_M2_108060_6540 0.988200
R916 n1_M2_108060_6540 n1_M2_109140_6540 0.988200
R917 n1_M2_109140_6540 n1_M2_110220_6540 0.988200
R918 n1_M2_110220_6540 n1_M2_111300_6540 0.988200
R919 n1_M2_111300_6540 n1_M2_112380_6540 0.988200
R920 n1_M2_112380_6540 n1_M2_113460_6540 0.988200
R921 n1_M2_113460_6540 n1_M2_114540_6540 0.988200
R922 n1_M2_114540_6540 n1_M2_115620_6540 0.988200
R923 n1_M2_115620_6540 n1_M2_116700_6540 0.988200
R924 n1_M2_116700_6540 n1_M2_117780_6540 0.988200
R925 n1_M2_117780_6540 n1_M2_118860_6540 0.988200
R926 n1_M2_118860_6540 n1_M2_119940_6540 0.988200
R927 n1_M2_119940_6540 n1_M2_121020_6540 0.988200
R928 n1_M2_121020_6540 n1_M2_122100_6540 0.988200
R929 n1_M2_122100_6540 n1_M2_123180_6540 0.988200
R930 n1_M2_123180_6540 n1_M2_124260_6540 0.988200
R931 n1_M2_124260_6540 n1_M2_125340_6540 0.988200
R932 n1_M2_125340_6540 n1_M2_126420_6540 0.988200
R933 n1_M2_126420_6540 n1_M2_127500_6540 0.988200
R934 n1_M2_127500_6540 n1_M2_128580_6540 0.988200
R935 n1_M2_128580_6540 n1_M2_129660_6540 0.988200
R936 n1_M2_129660_6540 n1_M2_130740_6540 0.988200
R937 n1_M2_130740_6540 n1_M2_131820_6540 0.988200
R938 n1_M2_131820_6540 n1_M2_132900_6540 0.988200
R939 n1_M2_132900_6540 n1_M2_133980_6540 0.988200
R940 n1_M2_133980_6540 n1_M2_135060_6540 0.988200
R941 n1_M2_135060_6540 n1_M2_136140_6540 0.988200
R942 n1_M2_136140_6540 n1_M2_137220_6540 0.988200
R943 n1_M2_137220_6540 n1_M2_138300_6540 0.988200
R944 n1_M2_138300_6540 n1_M2_139380_6540 0.988200
R945 n1_M2_139380_6540 n1_M2_140460_6540 0.988200
R946 n1_M2_140460_6540 n1_M2_141540_6540 0.988200
R947 n1_M2_141540_6540 n1_M2_142620_6540 0.988200
R948 n1_M2_142620_6540 n1_M2_143700_6540 0.988200
R949 n1_M2_143700_6540 n1_M2_144780_6540 0.988200
R950 n1_M2_144780_6540 n1_M2_145860_6540 0.988200
R951 n1_M2_145860_6540 n1_M2_146940_6540 0.988200
R952 n1_M2_60_7620 n1_M2_1140_7620 0.988200
R953 n1_M2_1140_7620 n1_M2_2220_7620 0.988200
R954 n1_M2_2220_7620 n1_M2_3300_7620 0.988200
R955 n1_M2_3300_7620 n1_M2_4380_7620 0.988200
R956 n1_M2_4380_7620 n1_M2_5460_7620 0.988200
R957 n1_M2_5460_7620 n1_M2_6540_7620 0.988200
R958 n1_M2_6540_7620 n1_M2_7620_7620 0.988200
R959 n1_M2_7620_7620 n1_M2_8700_7620 0.988200
R960 n1_M2_8700_7620 n1_M2_9780_7620 0.988200
R961 n1_M2_9780_7620 n1_M2_10860_7620 0.988200
R962 n1_M2_10860_7620 n1_M2_11940_7620 0.988200
R963 n1_M2_11940_7620 n1_M2_13020_7620 0.988200
R964 n1_M2_13020_7620 n1_M2_14100_7620 0.988200
R965 n1_M2_14100_7620 n1_M2_15180_7620 0.988200
R966 n1_M2_15180_7620 n1_M2_16260_7620 0.988200
R967 n1_M2_16260_7620 n1_M2_17340_7620 0.988200
R968 n1_M2_17340_7620 n1_M2_18420_7620 0.988200
R969 n1_M2_18420_7620 n1_M2_19500_7620 0.988200
R970 n1_M2_19500_7620 n1_M2_20580_7620 0.988200
R971 n1_M2_20580_7620 n1_M2_21660_7620 0.988200
R972 n1_M2_21660_7620 n1_M2_22740_7620 0.988200
R973 n1_M2_22740_7620 n1_M2_23820_7620 0.988200
R974 n1_M2_23820_7620 n1_M2_24900_7620 0.988200
R975 n1_M2_24900_7620 n1_M2_25980_7620 0.988200
R976 n1_M2_25980_7620 n1_M2_27060_7620 0.988200
R977 n1_M2_27060_7620 n1_M2_28140_7620 0.988200
R978 n1_M2_28140_7620 n1_M2_29220_7620 0.988200
R979 n1_M2_29220_7620 n1_M2_30300_7620 0.988200
R980 n1_M2_30300_7620 n1_M2_31380_7620 0.988200
R981 n1_M2_31380_7620 n1_M2_32460_7620 0.988200
R982 n1_M2_32460_7620 n1_M2_33540_7620 0.988200
R983 n1_M2_33540_7620 n1_M2_34620_7620 0.988200
R984 n1_M2_34620_7620 n1_M2_35700_7620 0.988200
R985 n1_M2_35700_7620 n1_M2_36780_7620 0.988200
R986 n1_M2_36780_7620 n1_M2_37860_7620 0.988200
R987 n1_M2_37860_7620 n1_M2_38940_7620 0.988200
R988 n1_M2_38940_7620 n1_M2_40020_7620 0.988200
R989 n1_M2_40020_7620 n1_M2_41100_7620 0.988200
R990 n1_M2_41100_7620 n1_M2_42180_7620 0.988200
R991 n1_M2_42180_7620 n1_M2_43260_7620 0.988200
R992 n1_M2_43260_7620 n1_M2_44340_7620 0.988200
R993 n1_M2_44340_7620 n1_M2_45420_7620 0.988200
R994 n1_M2_45420_7620 n1_M2_46500_7620 0.988200
R995 n1_M2_46500_7620 n1_M2_47580_7620 0.988200
R996 n1_M2_47580_7620 n1_M2_48660_7620 0.988200
R997 n1_M2_48660_7620 n1_M2_49740_7620 0.988200
R998 n1_M2_49740_7620 n1_M2_50820_7620 0.988200
R999 n1_M2_50820_7620 n1_M2_51900_7620 0.988200
R1000 n1_M2_51900_7620 n1_M2_52980_7620 0.988200
R1001 n1_M2_52980_7620 n1_M2_54060_7620 0.988200
R1002 n1_M2_54060_7620 n1_M2_55140_7620 0.988200
R1003 n1_M2_55140_7620 n1_M2_56220_7620 0.988200
R1004 n1_M2_56220_7620 n1_M2_57300_7620 0.988200
R1005 n1_M2_57300_7620 n1_M2_58380_7620 0.988200
R1006 n1_M2_58380_7620 n1_M2_59460_7620 0.988200
R1007 n1_M2_59460_7620 n1_M2_60540_7620 0.988200
R1008 n1_M2_60540_7620 n1_M2_61620_7620 0.988200
R1009 n1_M2_61620_7620 n1_M2_62700_7620 0.988200
R1010 n1_M2_62700_7620 n1_M2_63780_7620 0.988200
R1011 n1_M2_63780_7620 n1_M2_64860_7620 0.988200
R1012 n1_M2_64860_7620 n1_M2_65940_7620 0.988200
R1013 n1_M2_65940_7620 n1_M2_67020_7620 0.988200
R1014 n1_M2_67020_7620 n1_M2_68100_7620 0.988200
R1015 n1_M2_68100_7620 n1_M2_69180_7620 0.988200
R1016 n1_M2_69180_7620 n1_M2_70260_7620 0.988200
R1017 n1_M2_70260_7620 n1_M2_71340_7620 0.988200
R1018 n1_M2_71340_7620 n1_M2_72420_7620 0.988200
R1019 n1_M2_72420_7620 n1_M2_73500_7620 0.988200
R1020 n1_M2_73500_7620 n1_M2_74580_7620 0.988200
R1021 n1_M2_74580_7620 n1_M2_75660_7620 0.988200
R1022 n1_M2_75660_7620 n1_M2_76740_7620 0.988200
R1023 n1_M2_76740_7620 n1_M2_77820_7620 0.988200
R1024 n1_M2_77820_7620 n1_M2_78900_7620 0.988200
R1025 n1_M2_78900_7620 n1_M2_79980_7620 0.988200
R1026 n1_M2_79980_7620 n1_M2_81060_7620 0.988200
R1027 n1_M2_81060_7620 n1_M2_82140_7620 0.988200
R1028 n1_M2_82140_7620 n1_M2_83220_7620 0.988200
R1029 n1_M2_83220_7620 n1_M2_84300_7620 0.988200
R1030 n1_M2_84300_7620 n1_M2_85380_7620 0.988200
R1031 n1_M2_85380_7620 n1_M2_86460_7620 0.988200
R1032 n1_M2_86460_7620 n1_M2_87540_7620 0.988200
R1033 n1_M2_87540_7620 n1_M2_88620_7620 0.988200
R1034 n1_M2_88620_7620 n1_M2_89700_7620 0.988200
R1035 n1_M2_89700_7620 n1_M2_90780_7620 0.988200
R1036 n1_M2_90780_7620 n1_M2_91860_7620 0.988200
R1037 n1_M2_91860_7620 n1_M2_92940_7620 0.988200
R1038 n1_M2_92940_7620 n1_M2_94020_7620 0.988200
R1039 n1_M2_94020_7620 n1_M2_95100_7620 0.988200
R1040 n1_M2_95100_7620 n1_M2_96180_7620 0.988200
R1041 n1_M2_96180_7620 n1_M2_97260_7620 0.988200
R1042 n1_M2_97260_7620 n1_M2_98340_7620 0.988200
R1043 n1_M2_98340_7620 n1_M2_99420_7620 0.988200
R1044 n1_M2_99420_7620 n1_M2_100500_7620 0.988200
R1045 n1_M2_100500_7620 n1_M2_101580_7620 0.988200
R1046 n1_M2_101580_7620 n1_M2_102660_7620 0.988200
R1047 n1_M2_102660_7620 n1_M2_103740_7620 0.988200
R1048 n1_M2_103740_7620 n1_M2_104820_7620 0.988200
R1049 n1_M2_104820_7620 n1_M2_105900_7620 0.988200
R1050 n1_M2_105900_7620 n1_M2_106980_7620 0.988200
R1051 n1_M2_106980_7620 n1_M2_108060_7620 0.988200
R1052 n1_M2_108060_7620 n1_M2_109140_7620 0.988200
R1053 n1_M2_109140_7620 n1_M2_110220_7620 0.988200
R1054 n1_M2_110220_7620 n1_M2_111300_7620 0.988200
R1055 n1_M2_111300_7620 n1_M2_112380_7620 0.988200
R1056 n1_M2_112380_7620 n1_M2_113460_7620 0.988200
R1057 n1_M2_113460_7620 n1_M2_114540_7620 0.988200
R1058 n1_M2_114540_7620 n1_M2_115620_7620 0.988200
R1059 n1_M2_115620_7620 n1_M2_116700_7620 0.988200
R1060 n1_M2_116700_7620 n1_M2_117780_7620 0.988200
R1061 n1_M2_117780_7620 n1_M2_118860_7620 0.988200
R1062 n1_M2_118860_7620 n1_M2_119940_7620 0.988200
R1063 n1_M2_119940_7620 n1_M2_121020_7620 0.988200
R1064 n1_M2_121020_7620 n1_M2_122100_7620 0.988200
R1065 n1_M2_122100_7620 n1_M2_123180_7620 0.988200
R1066 n1_M2_123180_7620 n1_M2_124260_7620 0.988200
R1067 n1_M2_124260_7620 n1_M2_125340_7620 0.988200
R1068 n1_M2_125340_7620 n1_M2_126420_7620 0.988200
R1069 n1_M2_126420_7620 n1_M2_127500_7620 0.988200
R1070 n1_M2_127500_7620 n1_M2_128580_7620 0.988200
R1071 n1_M2_128580_7620 n1_M2_129660_7620 0.988200
R1072 n1_M2_129660_7620 n1_M2_130740_7620 0.988200
R1073 n1_M2_130740_7620 n1_M2_131820_7620 0.988200
R1074 n1_M2_131820_7620 n1_M2_132900_7620 0.988200
R1075 n1_M2_132900_7620 n1_M2_133980_7620 0.988200
R1076 n1_M2_133980_7620 n1_M2_135060_7620 0.988200
R1077 n1_M2_135060_7620 n1_M2_136140_7620 0.988200
R1078 n1_M2_136140_7620 n1_M2_137220_7620 0.988200
R1079 n1_M2_137220_7620 n1_M2_138300_7620 0.988200
R1080 n1_M2_138300_7620 n1_M2_139380_7620 0.988200
R1081 n1_M2_139380_7620 n1_M2_140460_7620 0.988200
R1082 n1_M2_140460_7620 n1_M2_141540_7620 0.988200
R1083 n1_M2_141540_7620 n1_M2_142620_7620 0.988200
R1084 n1_M2_142620_7620 n1_M2_143700_7620 0.988200
R1085 n1_M2_143700_7620 n1_M2_144780_7620 0.988200
R1086 n1_M2_144780_7620 n1_M2_145860_7620 0.988200
R1087 n1_M2_145860_7620 n1_M2_146940_7620 0.988200
R1088 n1_M2_60_8700 n1_M2_1140_8700 0.988200
R1089 n1_M2_1140_8700 n1_M2_2220_8700 0.988200
R1090 n1_M2_2220_8700 n1_M2_3300_8700 0.988200
R1091 n1_M2_3300_8700 n1_M2_4380_8700 0.988200
R1092 n1_M2_4380_8700 n1_M2_5460_8700 0.988200
R1093 n1_M2_5460_8700 n1_M2_6540_8700 0.988200
R1094 n1_M2_6540_8700 n1_M2_7620_8700 0.988200
R1095 n1_M2_7620_8700 n1_M2_8700_8700 0.988200
R1096 n1_M2_8700_8700 n1_M2_9780_8700 0.988200
R1097 n1_M2_9780_8700 n1_M2_10860_8700 0.988200
R1098 n1_M2_10860_8700 n1_M2_11940_8700 0.988200
R1099 n1_M2_11940_8700 n1_M2_13020_8700 0.988200
R1100 n1_M2_13020_8700 n1_M2_14100_8700 0.988200
R1101 n1_M2_14100_8700 n1_M2_15180_8700 0.988200
R1102 n1_M2_15180_8700 n1_M2_16260_8700 0.988200
R1103 n1_M2_16260_8700 n1_M2_17340_8700 0.988200
R1104 n1_M2_17340_8700 n1_M2_18420_8700 0.988200
R1105 n1_M2_18420_8700 n1_M2_19500_8700 0.988200
R1106 n1_M2_19500_8700 n1_M2_20580_8700 0.988200
R1107 n1_M2_20580_8700 n1_M2_21660_8700 0.988200
R1108 n1_M2_21660_8700 n1_M2_22740_8700 0.988200
R1109 n1_M2_22740_8700 n1_M2_23820_8700 0.988200
R1110 n1_M2_23820_8700 n1_M2_24900_8700 0.988200
R1111 n1_M2_24900_8700 n1_M2_25980_8700 0.988200
R1112 n1_M2_25980_8700 n1_M2_27060_8700 0.988200
R1113 n1_M2_27060_8700 n1_M2_28140_8700 0.988200
R1114 n1_M2_28140_8700 n1_M2_29220_8700 0.988200
R1115 n1_M2_29220_8700 n1_M2_30300_8700 0.988200
R1116 n1_M2_30300_8700 n1_M2_31380_8700 0.988200
R1117 n1_M2_31380_8700 n1_M2_32460_8700 0.988200
R1118 n1_M2_32460_8700 n1_M2_33540_8700 0.988200
R1119 n1_M2_33540_8700 n1_M2_34620_8700 0.988200
R1120 n1_M2_34620_8700 n1_M2_35700_8700 0.988200
R1121 n1_M2_35700_8700 n1_M2_36780_8700 0.988200
R1122 n1_M2_36780_8700 n1_M2_37860_8700 0.988200
R1123 n1_M2_37860_8700 n1_M2_38940_8700 0.988200
R1124 n1_M2_38940_8700 n1_M2_40020_8700 0.988200
R1125 n1_M2_40020_8700 n1_M2_41100_8700 0.988200
R1126 n1_M2_41100_8700 n1_M2_42180_8700 0.988200
R1127 n1_M2_42180_8700 n1_M2_43260_8700 0.988200
R1128 n1_M2_43260_8700 n1_M2_44340_8700 0.988200
R1129 n1_M2_44340_8700 n1_M2_45420_8700 0.988200
R1130 n1_M2_45420_8700 n1_M2_46500_8700 0.988200
R1131 n1_M2_46500_8700 n1_M2_47580_8700 0.988200
R1132 n1_M2_47580_8700 n1_M2_48660_8700 0.988200
R1133 n1_M2_48660_8700 n1_M2_49740_8700 0.988200
R1134 n1_M2_49740_8700 n1_M2_50820_8700 0.988200
R1135 n1_M2_50820_8700 n1_M2_51900_8700 0.988200
R1136 n1_M2_51900_8700 n1_M2_52980_8700 0.988200
R1137 n1_M2_52980_8700 n1_M2_54060_8700 0.988200
R1138 n1_M2_54060_8700 n1_M2_55140_8700 0.988200
R1139 n1_M2_55140_8700 n1_M2_56220_8700 0.988200
R1140 n1_M2_56220_8700 n1_M2_57300_8700 0.988200
R1141 n1_M2_57300_8700 n1_M2_58380_8700 0.988200
R1142 n1_M2_58380_8700 n1_M2_59460_8700 0.988200
R1143 n1_M2_59460_8700 n1_M2_60540_8700 0.988200
R1144 n1_M2_60540_8700 n1_M2_61620_8700 0.988200
R1145 n1_M2_61620_8700 n1_M2_62700_8700 0.988200
R1146 n1_M2_62700_8700 n1_M2_63780_8700 0.988200
R1147 n1_M2_63780_8700 n1_M2_64860_8700 0.988200
R1148 n1_M2_64860_8700 n1_M2_65940_8700 0.988200
R1149 n1_M2_65940_8700 n1_M2_67020_8700 0.988200
R1150 n1_M2_67020_8700 n1_M2_68100_8700 0.988200
R1151 n1_M2_68100_8700 n1_M2_69180_8700 0.988200
R1152 n1_M2_69180_8700 n1_M2_70260_8700 0.988200
R1153 n1_M2_70260_8700 n1_M2_71340_8700 0.988200
R1154 n1_M2_71340_8700 n1_M2_72420_8700 0.988200
R1155 n1_M2_72420_8700 n1_M2_73500_8700 0.988200
R1156 n1_M2_73500_8700 n1_M2_74580_8700 0.988200
R1157 n1_M2_74580_8700 n1_M2_75660_8700 0.988200
R1158 n1_M2_75660_8700 n1_M2_76740_8700 0.988200
R1159 n1_M2_76740_8700 n1_M2_77820_8700 0.988200
R1160 n1_M2_77820_8700 n1_M2_78900_8700 0.988200
R1161 n1_M2_78900_8700 n1_M2_79980_8700 0.988200
R1162 n1_M2_79980_8700 n1_M2_81060_8700 0.988200
R1163 n1_M2_81060_8700 n1_M2_82140_8700 0.988200
R1164 n1_M2_82140_8700 n1_M2_83220_8700 0.988200
R1165 n1_M2_83220_8700 n1_M2_84300_8700 0.988200
R1166 n1_M2_84300_8700 n1_M2_85380_8700 0.988200
R1167 n1_M2_85380_8700 n1_M2_86460_8700 0.988200
R1168 n1_M2_86460_8700 n1_M2_87540_8700 0.988200
R1169 n1_M2_87540_8700 n1_M2_88620_8700 0.988200
R1170 n1_M2_88620_8700 n1_M2_89700_8700 0.988200
R1171 n1_M2_89700_8700 n1_M2_90780_8700 0.988200
R1172 n1_M2_90780_8700 n1_M2_91860_8700 0.988200
R1173 n1_M2_91860_8700 n1_M2_92940_8700 0.988200
R1174 n1_M2_92940_8700 n1_M2_94020_8700 0.988200
R1175 n1_M2_94020_8700 n1_M2_95100_8700 0.988200
R1176 n1_M2_95100_8700 n1_M2_96180_8700 0.988200
R1177 n1_M2_96180_8700 n1_M2_97260_8700 0.988200
R1178 n1_M2_97260_8700 n1_M2_98340_8700 0.988200
R1179 n1_M2_98340_8700 n1_M2_99420_8700 0.988200
R1180 n1_M2_99420_8700 n1_M2_100500_8700 0.988200
R1181 n1_M2_100500_8700 n1_M2_101580_8700 0.988200
R1182 n1_M2_101580_8700 n1_M2_102660_8700 0.988200
R1183 n1_M2_102660_8700 n1_M2_103740_8700 0.988200
R1184 n1_M2_103740_8700 n1_M2_104820_8700 0.988200
R1185 n1_M2_104820_8700 n1_M2_105900_8700 0.988200
R1186 n1_M2_105900_8700 n1_M2_106980_8700 0.988200
R1187 n1_M2_106980_8700 n1_M2_108060_8700 0.988200
R1188 n1_M2_108060_8700 n1_M2_109140_8700 0.988200
R1189 n1_M2_109140_8700 n1_M2_110220_8700 0.988200
R1190 n1_M2_110220_8700 n1_M2_111300_8700 0.988200
R1191 n1_M2_111300_8700 n1_M2_112380_8700 0.988200
R1192 n1_M2_112380_8700 n1_M2_113460_8700 0.988200
R1193 n1_M2_113460_8700 n1_M2_114540_8700 0.988200
R1194 n1_M2_114540_8700 n1_M2_115620_8700 0.988200
R1195 n1_M2_115620_8700 n1_M2_116700_8700 0.988200
R1196 n1_M2_116700_8700 n1_M2_117780_8700 0.988200
R1197 n1_M2_117780_8700 n1_M2_118860_8700 0.988200
R1198 n1_M2_118860_8700 n1_M2_119940_8700 0.988200
R1199 n1_M2_119940_8700 n1_M2_121020_8700 0.988200
R1200 n1_M2_121020_8700 n1_M2_122100_8700 0.988200
R1201 n1_M2_122100_8700 n1_M2_123180_8700 0.988200
R1202 n1_M2_123180_8700 n1_M2_124260_8700 0.988200
R1203 n1_M2_124260_8700 n1_M2_125340_8700 0.988200
R1204 n1_M2_125340_8700 n1_M2_126420_8700 0.988200
R1205 n1_M2_126420_8700 n1_M2_127500_8700 0.988200
R1206 n1_M2_127500_8700 n1_M2_128580_8700 0.988200
R1207 n1_M2_128580_8700 n1_M2_129660_8700 0.988200
R1208 n1_M2_129660_8700 n1_M2_130740_8700 0.988200
R1209 n1_M2_130740_8700 n1_M2_131820_8700 0.988200
R1210 n1_M2_131820_8700 n1_M2_132900_8700 0.988200
R1211 n1_M2_132900_8700 n1_M2_133980_8700 0.988200
R1212 n1_M2_133980_8700 n1_M2_135060_8700 0.988200
R1213 n1_M2_135060_8700 n1_M2_136140_8700 0.988200
R1214 n1_M2_136140_8700 n1_M2_137220_8700 0.988200
R1215 n1_M2_137220_8700 n1_M2_138300_8700 0.988200
R1216 n1_M2_138300_8700 n1_M2_139380_8700 0.988200
R1217 n1_M2_139380_8700 n1_M2_140460_8700 0.988200
R1218 n1_M2_140460_8700 n1_M2_141540_8700 0.988200
R1219 n1_M2_141540_8700 n1_M2_142620_8700 0.988200
R1220 n1_M2_142620_8700 n1_M2_143700_8700 0.988200
R1221 n1_M2_143700_8700 n1_M2_144780_8700 0.988200
R1222 n1_M2_144780_8700 n1_M2_145860_8700 0.988200
R1223 n1_M2_145860_8700 n1_M2_146940_8700 0.988200
R1224 n1_M2_60_9780 n1_M2_1140_9780 0.988200
R1225 n1_M2_1140_9780 n1_M2_2220_9780 0.988200
R1226 n1_M2_2220_9780 n1_M2_3300_9780 0.988200
R1227 n1_M2_3300_9780 n1_M2_4380_9780 0.988200
R1228 n1_M2_4380_9780 n1_M2_5460_9780 0.988200
R1229 n1_M2_5460_9780 n1_M2_6540_9780 0.988200
R1230 n1_M2_6540_9780 n1_M2_7620_9780 0.988200
R1231 n1_M2_7620_9780 n1_M2_8700_9780 0.988200
R1232 n1_M2_8700_9780 n1_M2_9780_9780 0.988200
R1233 n1_M2_9780_9780 n1_M2_10860_9780 0.988200
R1234 n1_M2_10860_9780 n1_M2_11940_9780 0.988200
R1235 n1_M2_11940_9780 n1_M2_13020_9780 0.988200
R1236 n1_M2_13020_9780 n1_M2_14100_9780 0.988200
R1237 n1_M2_14100_9780 n1_M2_15180_9780 0.988200
R1238 n1_M2_15180_9780 n1_M2_16260_9780 0.988200
R1239 n1_M2_16260_9780 n1_M2_17340_9780 0.988200
R1240 n1_M2_17340_9780 n1_M2_18420_9780 0.988200
R1241 n1_M2_18420_9780 n1_M2_19500_9780 0.988200
R1242 n1_M2_19500_9780 n1_M2_20580_9780 0.988200
R1243 n1_M2_20580_9780 n1_M2_21660_9780 0.988200
R1244 n1_M2_21660_9780 n1_M2_22740_9780 0.988200
R1245 n1_M2_22740_9780 n1_M2_23820_9780 0.988200
R1246 n1_M2_23820_9780 n1_M2_24900_9780 0.988200
R1247 n1_M2_24900_9780 n1_M2_25980_9780 0.988200
R1248 n1_M2_25980_9780 n1_M2_27060_9780 0.988200
R1249 n1_M2_27060_9780 n1_M2_28140_9780 0.988200
R1250 n1_M2_28140_9780 n1_M2_29220_9780 0.988200
R1251 n1_M2_29220_9780 n1_M2_30300_9780 0.988200
R1252 n1_M2_30300_9780 n1_M2_31380_9780 0.988200
R1253 n1_M2_31380_9780 n1_M2_32460_9780 0.988200
R1254 n1_M2_32460_9780 n1_M2_33540_9780 0.988200
R1255 n1_M2_33540_9780 n1_M2_34620_9780 0.988200
R1256 n1_M2_34620_9780 n1_M2_35700_9780 0.988200
R1257 n1_M2_35700_9780 n1_M2_36780_9780 0.988200
R1258 n1_M2_36780_9780 n1_M2_37860_9780 0.988200
R1259 n1_M2_37860_9780 n1_M2_38940_9780 0.988200
R1260 n1_M2_38940_9780 n1_M2_40020_9780 0.988200
R1261 n1_M2_40020_9780 n1_M2_41100_9780 0.988200
R1262 n1_M2_41100_9780 n1_M2_42180_9780 0.988200
R1263 n1_M2_42180_9780 n1_M2_43260_9780 0.988200
R1264 n1_M2_43260_9780 n1_M2_44340_9780 0.988200
R1265 n1_M2_44340_9780 n1_M2_45420_9780 0.988200
R1266 n1_M2_45420_9780 n1_M2_46500_9780 0.988200
R1267 n1_M2_46500_9780 n1_M2_47580_9780 0.988200
R1268 n1_M2_47580_9780 n1_M2_48660_9780 0.988200
R1269 n1_M2_48660_9780 n1_M2_49740_9780 0.988200
R1270 n1_M2_49740_9780 n1_M2_50820_9780 0.988200
R1271 n1_M2_50820_9780 n1_M2_51900_9780 0.988200
R1272 n1_M2_51900_9780 n1_M2_52980_9780 0.988200
R1273 n1_M2_52980_9780 n1_M2_54060_9780 0.988200
R1274 n1_M2_54060_9780 n1_M2_55140_9780 0.988200
R1275 n1_M2_55140_9780 n1_M2_56220_9780 0.988200
R1276 n1_M2_56220_9780 n1_M2_57300_9780 0.988200
R1277 n1_M2_57300_9780 n1_M2_58380_9780 0.988200
R1278 n1_M2_58380_9780 n1_M2_59460_9780 0.988200
R1279 n1_M2_59460_9780 n1_M2_60540_9780 0.988200
R1280 n1_M2_60540_9780 n1_M2_61620_9780 0.988200
R1281 n1_M2_61620_9780 n1_M2_62700_9780 0.988200
R1282 n1_M2_62700_9780 n1_M2_63780_9780 0.988200
R1283 n1_M2_63780_9780 n1_M2_64860_9780 0.988200
R1284 n1_M2_64860_9780 n1_M2_65940_9780 0.988200
R1285 n1_M2_65940_9780 n1_M2_67020_9780 0.988200
R1286 n1_M2_67020_9780 n1_M2_68100_9780 0.988200
R1287 n1_M2_68100_9780 n1_M2_69180_9780 0.988200
R1288 n1_M2_69180_9780 n1_M2_70260_9780 0.988200
R1289 n1_M2_70260_9780 n1_M2_71340_9780 0.988200
R1290 n1_M2_71340_9780 n1_M2_72420_9780 0.988200
R1291 n1_M2_72420_9780 n1_M2_73500_9780 0.988200
R1292 n1_M2_73500_9780 n1_M2_74580_9780 0.988200
R1293 n1_M2_74580_9780 n1_M2_75660_9780 0.988200
R1294 n1_M2_75660_9780 n1_M2_76740_9780 0.988200
R1295 n1_M2_76740_9780 n1_M2_77820_9780 0.988200
R1296 n1_M2_77820_9780 n1_M2_78900_9780 0.988200
R1297 n1_M2_78900_9780 n1_M2_79980_9780 0.988200
R1298 n1_M2_79980_9780 n1_M2_81060_9780 0.988200
R1299 n1_M2_81060_9780 n1_M2_82140_9780 0.988200
R1300 n1_M2_82140_9780 n1_M2_83220_9780 0.988200
R1301 n1_M2_83220_9780 n1_M2_84300_9780 0.988200
R1302 n1_M2_84300_9780 n1_M2_85380_9780 0.988200
R1303 n1_M2_85380_9780 n1_M2_86460_9780 0.988200
R1304 n1_M2_86460_9780 n1_M2_87540_9780 0.988200
R1305 n1_M2_87540_9780 n1_M2_88620_9780 0.988200
R1306 n1_M2_88620_9780 n1_M2_89700_9780 0.988200
R1307 n1_M2_89700_9780 n1_M2_90780_9780 0.988200
R1308 n1_M2_90780_9780 n1_M2_91860_9780 0.988200
R1309 n1_M2_91860_9780 n1_M2_92940_9780 0.988200
R1310 n1_M2_92940_9780 n1_M2_94020_9780 0.988200
R1311 n1_M2_94020_9780 n1_M2_95100_9780 0.988200
R1312 n1_M2_95100_9780 n1_M2_96180_9780 0.988200
R1313 n1_M2_96180_9780 n1_M2_97260_9780 0.988200
R1314 n1_M2_97260_9780 n1_M2_98340_9780 0.988200
R1315 n1_M2_98340_9780 n1_M2_99420_9780 0.988200
R1316 n1_M2_99420_9780 n1_M2_100500_9780 0.988200
R1317 n1_M2_100500_9780 n1_M2_101580_9780 0.988200
R1318 n1_M2_101580_9780 n1_M2_102660_9780 0.988200
R1319 n1_M2_102660_9780 n1_M2_103740_9780 0.988200
R1320 n1_M2_103740_9780 n1_M2_104820_9780 0.988200
R1321 n1_M2_104820_9780 n1_M2_105900_9780 0.988200
R1322 n1_M2_105900_9780 n1_M2_106980_9780 0.988200
R1323 n1_M2_106980_9780 n1_M2_108060_9780 0.988200
R1324 n1_M2_108060_9780 n1_M2_109140_9780 0.988200
R1325 n1_M2_109140_9780 n1_M2_110220_9780 0.988200
R1326 n1_M2_110220_9780 n1_M2_111300_9780 0.988200
R1327 n1_M2_111300_9780 n1_M2_112380_9780 0.988200
R1328 n1_M2_112380_9780 n1_M2_113460_9780 0.988200
R1329 n1_M2_113460_9780 n1_M2_114540_9780 0.988200
R1330 n1_M2_114540_9780 n1_M2_115620_9780 0.988200
R1331 n1_M2_115620_9780 n1_M2_116700_9780 0.988200
R1332 n1_M2_116700_9780 n1_M2_117780_9780 0.988200
R1333 n1_M2_117780_9780 n1_M2_118860_9780 0.988200
R1334 n1_M2_118860_9780 n1_M2_119940_9780 0.988200
R1335 n1_M2_119940_9780 n1_M2_121020_9780 0.988200
R1336 n1_M2_121020_9780 n1_M2_122100_9780 0.988200
R1337 n1_M2_122100_9780 n1_M2_123180_9780 0.988200
R1338 n1_M2_123180_9780 n1_M2_124260_9780 0.988200
R1339 n1_M2_124260_9780 n1_M2_125340_9780 0.988200
R1340 n1_M2_125340_9780 n1_M2_126420_9780 0.988200
R1341 n1_M2_126420_9780 n1_M2_127500_9780 0.988200
R1342 n1_M2_127500_9780 n1_M2_128580_9780 0.988200
R1343 n1_M2_128580_9780 n1_M2_129660_9780 0.988200
R1344 n1_M2_129660_9780 n1_M2_130740_9780 0.988200
R1345 n1_M2_130740_9780 n1_M2_131820_9780 0.988200
R1346 n1_M2_131820_9780 n1_M2_132900_9780 0.988200
R1347 n1_M2_132900_9780 n1_M2_133980_9780 0.988200
R1348 n1_M2_133980_9780 n1_M2_135060_9780 0.988200
R1349 n1_M2_135060_9780 n1_M2_136140_9780 0.988200
R1350 n1_M2_136140_9780 n1_M2_137220_9780 0.988200
R1351 n1_M2_137220_9780 n1_M2_138300_9780 0.988200
R1352 n1_M2_138300_9780 n1_M2_139380_9780 0.988200
R1353 n1_M2_139380_9780 n1_M2_140460_9780 0.988200
R1354 n1_M2_140460_9780 n1_M2_141540_9780 0.988200
R1355 n1_M2_141540_9780 n1_M2_142620_9780 0.988200
R1356 n1_M2_142620_9780 n1_M2_143700_9780 0.988200
R1357 n1_M2_143700_9780 n1_M2_144780_9780 0.988200
R1358 n1_M2_144780_9780 n1_M2_145860_9780 0.988200
R1359 n1_M2_145860_9780 n1_M2_146940_9780 0.988200
R1360 n1_M2_60_10860 n1_M2_1140_10860 0.988200
R1361 n1_M2_1140_10860 n1_M2_2220_10860 0.988200
R1362 n1_M2_2220_10860 n1_M2_3300_10860 0.988200
R1363 n1_M2_3300_10860 n1_M2_4380_10860 0.988200
R1364 n1_M2_4380_10860 n1_M2_5460_10860 0.988200
R1365 n1_M2_5460_10860 n1_M2_6540_10860 0.988200
R1366 n1_M2_6540_10860 n1_M2_7620_10860 0.988200
R1367 n1_M2_7620_10860 n1_M2_8700_10860 0.988200
R1368 n1_M2_8700_10860 n1_M2_9780_10860 0.988200
R1369 n1_M2_9780_10860 n1_M2_10860_10860 0.988200
R1370 n1_M2_10860_10860 n1_M2_11940_10860 0.988200
R1371 n1_M2_11940_10860 n1_M2_13020_10860 0.988200
R1372 n1_M2_13020_10860 n1_M2_14100_10860 0.988200
R1373 n1_M2_14100_10860 n1_M2_15180_10860 0.988200
R1374 n1_M2_15180_10860 n1_M2_16260_10860 0.988200
R1375 n1_M2_16260_10860 n1_M2_17340_10860 0.988200
R1376 n1_M2_17340_10860 n1_M2_18420_10860 0.988200
R1377 n1_M2_18420_10860 n1_M2_19500_10860 0.988200
R1378 n1_M2_19500_10860 n1_M2_20580_10860 0.988200
R1379 n1_M2_20580_10860 n1_M2_21660_10860 0.988200
R1380 n1_M2_21660_10860 n1_M2_22740_10860 0.988200
R1381 n1_M2_22740_10860 n1_M2_23820_10860 0.988200
R1382 n1_M2_23820_10860 n1_M2_24900_10860 0.988200
R1383 n1_M2_24900_10860 n1_M2_25980_10860 0.988200
R1384 n1_M2_25980_10860 n1_M2_27060_10860 0.988200
R1385 n1_M2_27060_10860 n1_M2_28140_10860 0.988200
R1386 n1_M2_28140_10860 n1_M2_29220_10860 0.988200
R1387 n1_M2_29220_10860 n1_M2_30300_10860 0.988200
R1388 n1_M2_30300_10860 n1_M2_31380_10860 0.988200
R1389 n1_M2_31380_10860 n1_M2_32460_10860 0.988200
R1390 n1_M2_32460_10860 n1_M2_33540_10860 0.988200
R1391 n1_M2_33540_10860 n1_M2_34620_10860 0.988200
R1392 n1_M2_34620_10860 n1_M2_35700_10860 0.988200
R1393 n1_M2_35700_10860 n1_M2_36780_10860 0.988200
R1394 n1_M2_36780_10860 n1_M2_37860_10860 0.988200
R1395 n1_M2_37860_10860 n1_M2_38940_10860 0.988200
R1396 n1_M2_38940_10860 n1_M2_40020_10860 0.988200
R1397 n1_M2_40020_10860 n1_M2_41100_10860 0.988200
R1398 n1_M2_41100_10860 n1_M2_42180_10860 0.988200
R1399 n1_M2_42180_10860 n1_M2_43260_10860 0.988200
R1400 n1_M2_43260_10860 n1_M2_44340_10860 0.988200
R1401 n1_M2_44340_10860 n1_M2_45420_10860 0.988200
R1402 n1_M2_45420_10860 n1_M2_46500_10860 0.988200
R1403 n1_M2_46500_10860 n1_M2_47580_10860 0.988200
R1404 n1_M2_47580_10860 n1_M2_48660_10860 0.988200
R1405 n1_M2_48660_10860 n1_M2_49740_10860 0.988200
R1406 n1_M2_49740_10860 n1_M2_50820_10860 0.988200
R1407 n1_M2_50820_10860 n1_M2_51900_10860 0.988200
R1408 n1_M2_51900_10860 n1_M2_52980_10860 0.988200
R1409 n1_M2_52980_10860 n1_M2_54060_10860 0.988200
R1410 n1_M2_54060_10860 n1_M2_55140_10860 0.988200
R1411 n1_M2_55140_10860 n1_M2_56220_10860 0.988200
R1412 n1_M2_56220_10860 n1_M2_57300_10860 0.988200
R1413 n1_M2_57300_10860 n1_M2_58380_10860 0.988200
R1414 n1_M2_58380_10860 n1_M2_59460_10860 0.988200
R1415 n1_M2_59460_10860 n1_M2_60540_10860 0.988200
R1416 n1_M2_60540_10860 n1_M2_61620_10860 0.988200
R1417 n1_M2_61620_10860 n1_M2_62700_10860 0.988200
R1418 n1_M2_62700_10860 n1_M2_63780_10860 0.988200
R1419 n1_M2_63780_10860 n1_M2_64860_10860 0.988200
R1420 n1_M2_64860_10860 n1_M2_65940_10860 0.988200
R1421 n1_M2_65940_10860 n1_M2_67020_10860 0.988200
R1422 n1_M2_67020_10860 n1_M2_68100_10860 0.988200
R1423 n1_M2_68100_10860 n1_M2_69180_10860 0.988200
R1424 n1_M2_69180_10860 n1_M2_70260_10860 0.988200
R1425 n1_M2_70260_10860 n1_M2_71340_10860 0.988200
R1426 n1_M2_71340_10860 n1_M2_72420_10860 0.988200
R1427 n1_M2_72420_10860 n1_M2_73500_10860 0.988200
R1428 n1_M2_73500_10860 n1_M2_74580_10860 0.988200
R1429 n1_M2_74580_10860 n1_M2_75660_10860 0.988200
R1430 n1_M2_75660_10860 n1_M2_76740_10860 0.988200
R1431 n1_M2_76740_10860 n1_M2_77820_10860 0.988200
R1432 n1_M2_77820_10860 n1_M2_78900_10860 0.988200
R1433 n1_M2_78900_10860 n1_M2_79980_10860 0.988200
R1434 n1_M2_79980_10860 n1_M2_81060_10860 0.988200
R1435 n1_M2_81060_10860 n1_M2_82140_10860 0.988200
R1436 n1_M2_82140_10860 n1_M2_83220_10860 0.988200
R1437 n1_M2_83220_10860 n1_M2_84300_10860 0.988200
R1438 n1_M2_84300_10860 n1_M2_85380_10860 0.988200
R1439 n1_M2_85380_10860 n1_M2_86460_10860 0.988200
R1440 n1_M2_86460_10860 n1_M2_87540_10860 0.988200
R1441 n1_M2_87540_10860 n1_M2_88620_10860 0.988200
R1442 n1_M2_88620_10860 n1_M2_89700_10860 0.988200
R1443 n1_M2_89700_10860 n1_M2_90780_10860 0.988200
R1444 n1_M2_90780_10860 n1_M2_91860_10860 0.988200
R1445 n1_M2_91860_10860 n1_M2_92940_10860 0.988200
R1446 n1_M2_92940_10860 n1_M2_94020_10860 0.988200
R1447 n1_M2_94020_10860 n1_M2_95100_10860 0.988200
R1448 n1_M2_95100_10860 n1_M2_96180_10860 0.988200
R1449 n1_M2_96180_10860 n1_M2_97260_10860 0.988200
R1450 n1_M2_97260_10860 n1_M2_98340_10860 0.988200
R1451 n1_M2_98340_10860 n1_M2_99420_10860 0.988200
R1452 n1_M2_99420_10860 n1_M2_100500_10860 0.988200
R1453 n1_M2_100500_10860 n1_M2_101580_10860 0.988200
R1454 n1_M2_101580_10860 n1_M2_102660_10860 0.988200
R1455 n1_M2_102660_10860 n1_M2_103740_10860 0.988200
R1456 n1_M2_103740_10860 n1_M2_104820_10860 0.988200
R1457 n1_M2_104820_10860 n1_M2_105900_10860 0.988200
R1458 n1_M2_105900_10860 n1_M2_106980_10860 0.988200
R1459 n1_M2_106980_10860 n1_M2_108060_10860 0.988200
R1460 n1_M2_108060_10860 n1_M2_109140_10860 0.988200
R1461 n1_M2_109140_10860 n1_M2_110220_10860 0.988200
R1462 n1_M2_110220_10860 n1_M2_111300_10860 0.988200
R1463 n1_M2_111300_10860 n1_M2_112380_10860 0.988200
R1464 n1_M2_112380_10860 n1_M2_113460_10860 0.988200
R1465 n1_M2_113460_10860 n1_M2_114540_10860 0.988200
R1466 n1_M2_114540_10860 n1_M2_115620_10860 0.988200
R1467 n1_M2_115620_10860 n1_M2_116700_10860 0.988200
R1468 n1_M2_116700_10860 n1_M2_117780_10860 0.988200
R1469 n1_M2_117780_10860 n1_M2_118860_10860 0.988200
R1470 n1_M2_118860_10860 n1_M2_119940_10860 0.988200
R1471 n1_M2_119940_10860 n1_M2_121020_10860 0.988200
R1472 n1_M2_121020_10860 n1_M2_122100_10860 0.988200
R1473 n1_M2_122100_10860 n1_M2_123180_10860 0.988200
R1474 n1_M2_123180_10860 n1_M2_124260_10860 0.988200
R1475 n1_M2_124260_10860 n1_M2_125340_10860 0.988200
R1476 n1_M2_125340_10860 n1_M2_126420_10860 0.988200
R1477 n1_M2_126420_10860 n1_M2_127500_10860 0.988200
R1478 n1_M2_127500_10860 n1_M2_128580_10860 0.988200
R1479 n1_M2_128580_10860 n1_M2_129660_10860 0.988200
R1480 n1_M2_129660_10860 n1_M2_130740_10860 0.988200
R1481 n1_M2_130740_10860 n1_M2_131820_10860 0.988200
R1482 n1_M2_131820_10860 n1_M2_132900_10860 0.988200
R1483 n1_M2_132900_10860 n1_M2_133980_10860 0.988200
R1484 n1_M2_133980_10860 n1_M2_135060_10860 0.988200
R1485 n1_M2_135060_10860 n1_M2_136140_10860 0.988200
R1486 n1_M2_136140_10860 n1_M2_137220_10860 0.988200
R1487 n1_M2_137220_10860 n1_M2_138300_10860 0.988200
R1488 n1_M2_138300_10860 n1_M2_139380_10860 0.988200
R1489 n1_M2_139380_10860 n1_M2_140460_10860 0.988200
R1490 n1_M2_140460_10860 n1_M2_141540_10860 0.988200
R1491 n1_M2_141540_10860 n1_M2_142620_10860 0.988200
R1492 n1_M2_142620_10860 n1_M2_143700_10860 0.988200
R1493 n1_M2_143700_10860 n1_M2_144780_10860 0.988200
R1494 n1_M2_144780_10860 n1_M2_145860_10860 0.988200
R1495 n1_M2_145860_10860 n1_M2_146940_10860 0.988200
R1496 n1_M2_60_11940 n1_M2_1140_11940 0.988200
R1497 n1_M2_1140_11940 n1_M2_2220_11940 0.988200
R1498 n1_M2_2220_11940 n1_M2_3300_11940 0.988200
R1499 n1_M2_3300_11940 n1_M2_4380_11940 0.988200
R1500 n1_M2_4380_11940 n1_M2_5460_11940 0.988200
R1501 n1_M2_5460_11940 n1_M2_6540_11940 0.988200
R1502 n1_M2_6540_11940 n1_M2_7620_11940 0.988200
R1503 n1_M2_7620_11940 n1_M2_8700_11940 0.988200
R1504 n1_M2_8700_11940 n1_M2_9780_11940 0.988200
R1505 n1_M2_9780_11940 n1_M2_10860_11940 0.988200
R1506 n1_M2_10860_11940 n1_M2_11940_11940 0.988200
R1507 n1_M2_11940_11940 n1_M2_13020_11940 0.988200
R1508 n1_M2_13020_11940 n1_M2_14100_11940 0.988200
R1509 n1_M2_14100_11940 n1_M2_15180_11940 0.988200
R1510 n1_M2_15180_11940 n1_M2_16260_11940 0.988200
R1511 n1_M2_16260_11940 n1_M2_17340_11940 0.988200
R1512 n1_M2_17340_11940 n1_M2_18420_11940 0.988200
R1513 n1_M2_18420_11940 n1_M2_19500_11940 0.988200
R1514 n1_M2_19500_11940 n1_M2_20580_11940 0.988200
R1515 n1_M2_20580_11940 n1_M2_21660_11940 0.988200
R1516 n1_M2_21660_11940 n1_M2_22740_11940 0.988200
R1517 n1_M2_22740_11940 n1_M2_23820_11940 0.988200
R1518 n1_M2_23820_11940 n1_M2_24900_11940 0.988200
R1519 n1_M2_24900_11940 n1_M2_25980_11940 0.988200
R1520 n1_M2_25980_11940 n1_M2_27060_11940 0.988200
R1521 n1_M2_27060_11940 n1_M2_28140_11940 0.988200
R1522 n1_M2_28140_11940 n1_M2_29220_11940 0.988200
R1523 n1_M2_29220_11940 n1_M2_30300_11940 0.988200
R1524 n1_M2_30300_11940 n1_M2_31380_11940 0.988200
R1525 n1_M2_31380_11940 n1_M2_32460_11940 0.988200
R1526 n1_M2_32460_11940 n1_M2_33540_11940 0.988200
R1527 n1_M2_33540_11940 n1_M2_34620_11940 0.988200
R1528 n1_M2_34620_11940 n1_M2_35700_11940 0.988200
R1529 n1_M2_35700_11940 n1_M2_36780_11940 0.988200
R1530 n1_M2_36780_11940 n1_M2_37860_11940 0.988200
R1531 n1_M2_37860_11940 n1_M2_38940_11940 0.988200
R1532 n1_M2_38940_11940 n1_M2_40020_11940 0.988200
R1533 n1_M2_40020_11940 n1_M2_41100_11940 0.988200
R1534 n1_M2_41100_11940 n1_M2_42180_11940 0.988200
R1535 n1_M2_42180_11940 n1_M2_43260_11940 0.988200
R1536 n1_M2_43260_11940 n1_M2_44340_11940 0.988200
R1537 n1_M2_44340_11940 n1_M2_45420_11940 0.988200
R1538 n1_M2_45420_11940 n1_M2_46500_11940 0.988200
R1539 n1_M2_46500_11940 n1_M2_47580_11940 0.988200
R1540 n1_M2_47580_11940 n1_M2_48660_11940 0.988200
R1541 n1_M2_48660_11940 n1_M2_49740_11940 0.988200
R1542 n1_M2_49740_11940 n1_M2_50820_11940 0.988200
R1543 n1_M2_50820_11940 n1_M2_51900_11940 0.988200
R1544 n1_M2_51900_11940 n1_M2_52980_11940 0.988200
R1545 n1_M2_52980_11940 n1_M2_54060_11940 0.988200
R1546 n1_M2_54060_11940 n1_M2_55140_11940 0.988200
R1547 n1_M2_55140_11940 n1_M2_56220_11940 0.988200
R1548 n1_M2_56220_11940 n1_M2_57300_11940 0.988200
R1549 n1_M2_57300_11940 n1_M2_58380_11940 0.988200
R1550 n1_M2_58380_11940 n1_M2_59460_11940 0.988200
R1551 n1_M2_59460_11940 n1_M2_60540_11940 0.988200
R1552 n1_M2_60540_11940 n1_M2_61620_11940 0.988200
R1553 n1_M2_61620_11940 n1_M2_62700_11940 0.988200
R1554 n1_M2_62700_11940 n1_M2_63780_11940 0.988200
R1555 n1_M2_63780_11940 n1_M2_64860_11940 0.988200
R1556 n1_M2_64860_11940 n1_M2_65940_11940 0.988200
R1557 n1_M2_65940_11940 n1_M2_67020_11940 0.988200
R1558 n1_M2_67020_11940 n1_M2_68100_11940 0.988200
R1559 n1_M2_68100_11940 n1_M2_69180_11940 0.988200
R1560 n1_M2_69180_11940 n1_M2_70260_11940 0.988200
R1561 n1_M2_70260_11940 n1_M2_71340_11940 0.988200
R1562 n1_M2_71340_11940 n1_M2_72420_11940 0.988200
R1563 n1_M2_72420_11940 n1_M2_73500_11940 0.988200
R1564 n1_M2_73500_11940 n1_M2_74580_11940 0.988200
R1565 n1_M2_74580_11940 n1_M2_75660_11940 0.988200
R1566 n1_M2_75660_11940 n1_M2_76740_11940 0.988200
R1567 n1_M2_76740_11940 n1_M2_77820_11940 0.988200
R1568 n1_M2_77820_11940 n1_M2_78900_11940 0.988200
R1569 n1_M2_78900_11940 n1_M2_79980_11940 0.988200
R1570 n1_M2_79980_11940 n1_M2_81060_11940 0.988200
R1571 n1_M2_81060_11940 n1_M2_82140_11940 0.988200
R1572 n1_M2_82140_11940 n1_M2_83220_11940 0.988200
R1573 n1_M2_83220_11940 n1_M2_84300_11940 0.988200
R1574 n1_M2_84300_11940 n1_M2_85380_11940 0.988200
R1575 n1_M2_85380_11940 n1_M2_86460_11940 0.988200
R1576 n1_M2_86460_11940 n1_M2_87540_11940 0.988200
R1577 n1_M2_87540_11940 n1_M2_88620_11940 0.988200
R1578 n1_M2_88620_11940 n1_M2_89700_11940 0.988200
R1579 n1_M2_89700_11940 n1_M2_90780_11940 0.988200
R1580 n1_M2_90780_11940 n1_M2_91860_11940 0.988200
R1581 n1_M2_91860_11940 n1_M2_92940_11940 0.988200
R1582 n1_M2_92940_11940 n1_M2_94020_11940 0.988200
R1583 n1_M2_94020_11940 n1_M2_95100_11940 0.988200
R1584 n1_M2_95100_11940 n1_M2_96180_11940 0.988200
R1585 n1_M2_96180_11940 n1_M2_97260_11940 0.988200
R1586 n1_M2_97260_11940 n1_M2_98340_11940 0.988200
R1587 n1_M2_98340_11940 n1_M2_99420_11940 0.988200
R1588 n1_M2_99420_11940 n1_M2_100500_11940 0.988200
R1589 n1_M2_100500_11940 n1_M2_101580_11940 0.988200
R1590 n1_M2_101580_11940 n1_M2_102660_11940 0.988200
R1591 n1_M2_102660_11940 n1_M2_103740_11940 0.988200
R1592 n1_M2_103740_11940 n1_M2_104820_11940 0.988200
R1593 n1_M2_104820_11940 n1_M2_105900_11940 0.988200
R1594 n1_M2_105900_11940 n1_M2_106980_11940 0.988200
R1595 n1_M2_106980_11940 n1_M2_108060_11940 0.988200
R1596 n1_M2_108060_11940 n1_M2_109140_11940 0.988200
R1597 n1_M2_109140_11940 n1_M2_110220_11940 0.988200
R1598 n1_M2_110220_11940 n1_M2_111300_11940 0.988200
R1599 n1_M2_111300_11940 n1_M2_112380_11940 0.988200
R1600 n1_M2_112380_11940 n1_M2_113460_11940 0.988200
R1601 n1_M2_113460_11940 n1_M2_114540_11940 0.988200
R1602 n1_M2_114540_11940 n1_M2_115620_11940 0.988200
R1603 n1_M2_115620_11940 n1_M2_116700_11940 0.988200
R1604 n1_M2_116700_11940 n1_M2_117780_11940 0.988200
R1605 n1_M2_117780_11940 n1_M2_118860_11940 0.988200
R1606 n1_M2_118860_11940 n1_M2_119940_11940 0.988200
R1607 n1_M2_119940_11940 n1_M2_121020_11940 0.988200
R1608 n1_M2_121020_11940 n1_M2_122100_11940 0.988200
R1609 n1_M2_122100_11940 n1_M2_123180_11940 0.988200
R1610 n1_M2_123180_11940 n1_M2_124260_11940 0.988200
R1611 n1_M2_124260_11940 n1_M2_125340_11940 0.988200
R1612 n1_M2_125340_11940 n1_M2_126420_11940 0.988200
R1613 n1_M2_126420_11940 n1_M2_127500_11940 0.988200
R1614 n1_M2_127500_11940 n1_M2_128580_11940 0.988200
R1615 n1_M2_128580_11940 n1_M2_129660_11940 0.988200
R1616 n1_M2_129660_11940 n1_M2_130740_11940 0.988200
R1617 n1_M2_130740_11940 n1_M2_131820_11940 0.988200
R1618 n1_M2_131820_11940 n1_M2_132900_11940 0.988200
R1619 n1_M2_132900_11940 n1_M2_133980_11940 0.988200
R1620 n1_M2_133980_11940 n1_M2_135060_11940 0.988200
R1621 n1_M2_135060_11940 n1_M2_136140_11940 0.988200
R1622 n1_M2_136140_11940 n1_M2_137220_11940 0.988200
R1623 n1_M2_137220_11940 n1_M2_138300_11940 0.988200
R1624 n1_M2_138300_11940 n1_M2_139380_11940 0.988200
R1625 n1_M2_139380_11940 n1_M2_140460_11940 0.988200
R1626 n1_M2_140460_11940 n1_M2_141540_11940 0.988200
R1627 n1_M2_141540_11940 n1_M2_142620_11940 0.988200
R1628 n1_M2_142620_11940 n1_M2_143700_11940 0.988200
R1629 n1_M2_143700_11940 n1_M2_144780_11940 0.988200
R1630 n1_M2_144780_11940 n1_M2_145860_11940 0.988200
R1631 n1_M2_145860_11940 n1_M2_146940_11940 0.988200
R1632 n1_M2_60_13020 n1_M2_1140_13020 0.988200
R1633 n1_M2_1140_13020 n1_M2_2220_13020 0.988200
R1634 n1_M2_2220_13020 n1_M2_3300_13020 0.988200
R1635 n1_M2_3300_13020 n1_M2_4380_13020 0.988200
R1636 n1_M2_4380_13020 n1_M2_5460_13020 0.988200
R1637 n1_M2_5460_13020 n1_M2_6540_13020 0.988200
R1638 n1_M2_6540_13020 n1_M2_7620_13020 0.988200
R1639 n1_M2_7620_13020 n1_M2_8700_13020 0.988200
R1640 n1_M2_8700_13020 n1_M2_9780_13020 0.988200
R1641 n1_M2_9780_13020 n1_M2_10860_13020 0.988200
R1642 n1_M2_10860_13020 n1_M2_11940_13020 0.988200
R1643 n1_M2_11940_13020 n1_M2_13020_13020 0.988200
R1644 n1_M2_13020_13020 n1_M2_14100_13020 0.988200
R1645 n1_M2_14100_13020 n1_M2_15180_13020 0.988200
R1646 n1_M2_15180_13020 n1_M2_16260_13020 0.988200
R1647 n1_M2_16260_13020 n1_M2_17340_13020 0.988200
R1648 n1_M2_17340_13020 n1_M2_18420_13020 0.988200
R1649 n1_M2_18420_13020 n1_M2_19500_13020 0.988200
R1650 n1_M2_19500_13020 n1_M2_20580_13020 0.988200
R1651 n1_M2_20580_13020 n1_M2_21660_13020 0.988200
R1652 n1_M2_21660_13020 n1_M2_22740_13020 0.988200
R1653 n1_M2_22740_13020 n1_M2_23820_13020 0.988200
R1654 n1_M2_23820_13020 n1_M2_24900_13020 0.988200
R1655 n1_M2_24900_13020 n1_M2_25980_13020 0.988200
R1656 n1_M2_25980_13020 n1_M2_27060_13020 0.988200
R1657 n1_M2_27060_13020 n1_M2_28140_13020 0.988200
R1658 n1_M2_28140_13020 n1_M2_29220_13020 0.988200
R1659 n1_M2_29220_13020 n1_M2_30300_13020 0.988200
R1660 n1_M2_30300_13020 n1_M2_31380_13020 0.988200
R1661 n1_M2_31380_13020 n1_M2_32460_13020 0.988200
R1662 n1_M2_32460_13020 n1_M2_33540_13020 0.988200
R1663 n1_M2_33540_13020 n1_M2_34620_13020 0.988200
R1664 n1_M2_34620_13020 n1_M2_35700_13020 0.988200
R1665 n1_M2_35700_13020 n1_M2_36780_13020 0.988200
R1666 n1_M2_36780_13020 n1_M2_37860_13020 0.988200
R1667 n1_M2_37860_13020 n1_M2_38940_13020 0.988200
R1668 n1_M2_38940_13020 n1_M2_40020_13020 0.988200
R1669 n1_M2_40020_13020 n1_M2_41100_13020 0.988200
R1670 n1_M2_41100_13020 n1_M2_42180_13020 0.988200
R1671 n1_M2_42180_13020 n1_M2_43260_13020 0.988200
R1672 n1_M2_43260_13020 n1_M2_44340_13020 0.988200
R1673 n1_M2_44340_13020 n1_M2_45420_13020 0.988200
R1674 n1_M2_45420_13020 n1_M2_46500_13020 0.988200
R1675 n1_M2_46500_13020 n1_M2_47580_13020 0.988200
R1676 n1_M2_47580_13020 n1_M2_48660_13020 0.988200
R1677 n1_M2_48660_13020 n1_M2_49740_13020 0.988200
R1678 n1_M2_49740_13020 n1_M2_50820_13020 0.988200
R1679 n1_M2_50820_13020 n1_M2_51900_13020 0.988200
R1680 n1_M2_51900_13020 n1_M2_52980_13020 0.988200
R1681 n1_M2_52980_13020 n1_M2_54060_13020 0.988200
R1682 n1_M2_54060_13020 n1_M2_55140_13020 0.988200
R1683 n1_M2_55140_13020 n1_M2_56220_13020 0.988200
R1684 n1_M2_56220_13020 n1_M2_57300_13020 0.988200
R1685 n1_M2_57300_13020 n1_M2_58380_13020 0.988200
R1686 n1_M2_58380_13020 n1_M2_59460_13020 0.988200
R1687 n1_M2_59460_13020 n1_M2_60540_13020 0.988200
R1688 n1_M2_60540_13020 n1_M2_61620_13020 0.988200
R1689 n1_M2_61620_13020 n1_M2_62700_13020 0.988200
R1690 n1_M2_62700_13020 n1_M2_63780_13020 0.988200
R1691 n1_M2_63780_13020 n1_M2_64860_13020 0.988200
R1692 n1_M2_64860_13020 n1_M2_65940_13020 0.988200
R1693 n1_M2_65940_13020 n1_M2_67020_13020 0.988200
R1694 n1_M2_67020_13020 n1_M2_68100_13020 0.988200
R1695 n1_M2_68100_13020 n1_M2_69180_13020 0.988200
R1696 n1_M2_69180_13020 n1_M2_70260_13020 0.988200
R1697 n1_M2_70260_13020 n1_M2_71340_13020 0.988200
R1698 n1_M2_71340_13020 n1_M2_72420_13020 0.988200
R1699 n1_M2_72420_13020 n1_M2_73500_13020 0.988200
R1700 n1_M2_73500_13020 n1_M2_74580_13020 0.988200
R1701 n1_M2_74580_13020 n1_M2_75660_13020 0.988200
R1702 n1_M2_75660_13020 n1_M2_76740_13020 0.988200
R1703 n1_M2_76740_13020 n1_M2_77820_13020 0.988200
R1704 n1_M2_77820_13020 n1_M2_78900_13020 0.988200
R1705 n1_M2_78900_13020 n1_M2_79980_13020 0.988200
R1706 n1_M2_79980_13020 n1_M2_81060_13020 0.988200
R1707 n1_M2_81060_13020 n1_M2_82140_13020 0.988200
R1708 n1_M2_82140_13020 n1_M2_83220_13020 0.988200
R1709 n1_M2_83220_13020 n1_M2_84300_13020 0.988200
R1710 n1_M2_84300_13020 n1_M2_85380_13020 0.988200
R1711 n1_M2_85380_13020 n1_M2_86460_13020 0.988200
R1712 n1_M2_86460_13020 n1_M2_87540_13020 0.988200
R1713 n1_M2_87540_13020 n1_M2_88620_13020 0.988200
R1714 n1_M2_88620_13020 n1_M2_89700_13020 0.988200
R1715 n1_M2_89700_13020 n1_M2_90780_13020 0.988200
R1716 n1_M2_90780_13020 n1_M2_91860_13020 0.988200
R1717 n1_M2_91860_13020 n1_M2_92940_13020 0.988200
R1718 n1_M2_92940_13020 n1_M2_94020_13020 0.988200
R1719 n1_M2_94020_13020 n1_M2_95100_13020 0.988200
R1720 n1_M2_95100_13020 n1_M2_96180_13020 0.988200
R1721 n1_M2_96180_13020 n1_M2_97260_13020 0.988200
R1722 n1_M2_97260_13020 n1_M2_98340_13020 0.988200
R1723 n1_M2_98340_13020 n1_M2_99420_13020 0.988200
R1724 n1_M2_99420_13020 n1_M2_100500_13020 0.988200
R1725 n1_M2_100500_13020 n1_M2_101580_13020 0.988200
R1726 n1_M2_101580_13020 n1_M2_102660_13020 0.988200
R1727 n1_M2_102660_13020 n1_M2_103740_13020 0.988200
R1728 n1_M2_103740_13020 n1_M2_104820_13020 0.988200
R1729 n1_M2_104820_13020 n1_M2_105900_13020 0.988200
R1730 n1_M2_105900_13020 n1_M2_106980_13020 0.988200
R1731 n1_M2_106980_13020 n1_M2_108060_13020 0.988200
R1732 n1_M2_108060_13020 n1_M2_109140_13020 0.988200
R1733 n1_M2_109140_13020 n1_M2_110220_13020 0.988200
R1734 n1_M2_110220_13020 n1_M2_111300_13020 0.988200
R1735 n1_M2_111300_13020 n1_M2_112380_13020 0.988200
R1736 n1_M2_112380_13020 n1_M2_113460_13020 0.988200
R1737 n1_M2_113460_13020 n1_M2_114540_13020 0.988200
R1738 n1_M2_114540_13020 n1_M2_115620_13020 0.988200
R1739 n1_M2_115620_13020 n1_M2_116700_13020 0.988200
R1740 n1_M2_116700_13020 n1_M2_117780_13020 0.988200
R1741 n1_M2_117780_13020 n1_M2_118860_13020 0.988200
R1742 n1_M2_118860_13020 n1_M2_119940_13020 0.988200
R1743 n1_M2_119940_13020 n1_M2_121020_13020 0.988200
R1744 n1_M2_121020_13020 n1_M2_122100_13020 0.988200
R1745 n1_M2_122100_13020 n1_M2_123180_13020 0.988200
R1746 n1_M2_123180_13020 n1_M2_124260_13020 0.988200
R1747 n1_M2_124260_13020 n1_M2_125340_13020 0.988200
R1748 n1_M2_125340_13020 n1_M2_126420_13020 0.988200
R1749 n1_M2_126420_13020 n1_M2_127500_13020 0.988200
R1750 n1_M2_127500_13020 n1_M2_128580_13020 0.988200
R1751 n1_M2_128580_13020 n1_M2_129660_13020 0.988200
R1752 n1_M2_129660_13020 n1_M2_130740_13020 0.988200
R1753 n1_M2_130740_13020 n1_M2_131820_13020 0.988200
R1754 n1_M2_131820_13020 n1_M2_132900_13020 0.988200
R1755 n1_M2_132900_13020 n1_M2_133980_13020 0.988200
R1756 n1_M2_133980_13020 n1_M2_135060_13020 0.988200
R1757 n1_M2_135060_13020 n1_M2_136140_13020 0.988200
R1758 n1_M2_136140_13020 n1_M2_137220_13020 0.988200
R1759 n1_M2_137220_13020 n1_M2_138300_13020 0.988200
R1760 n1_M2_138300_13020 n1_M2_139380_13020 0.988200
R1761 n1_M2_139380_13020 n1_M2_140460_13020 0.988200
R1762 n1_M2_140460_13020 n1_M2_141540_13020 0.988200
R1763 n1_M2_141540_13020 n1_M2_142620_13020 0.988200
R1764 n1_M2_142620_13020 n1_M2_143700_13020 0.988200
R1765 n1_M2_143700_13020 n1_M2_144780_13020 0.988200
R1766 n1_M2_144780_13020 n1_M2_145860_13020 0.988200
R1767 n1_M2_145860_13020 n1_M2_146940_13020 0.988200
R1768 n1_M2_60_14100 n1_M2_1140_14100 0.988200
R1769 n1_M2_1140_14100 n1_M2_2220_14100 0.988200
R1770 n1_M2_2220_14100 n1_M2_3300_14100 0.988200
R1771 n1_M2_3300_14100 n1_M2_4380_14100 0.988200
R1772 n1_M2_4380_14100 n1_M2_5460_14100 0.988200
R1773 n1_M2_5460_14100 n1_M2_6540_14100 0.988200
R1774 n1_M2_6540_14100 n1_M2_7620_14100 0.988200
R1775 n1_M2_7620_14100 n1_M2_8700_14100 0.988200
R1776 n1_M2_8700_14100 n1_M2_9780_14100 0.988200
R1777 n1_M2_9780_14100 n1_M2_10860_14100 0.988200
R1778 n1_M2_10860_14100 n1_M2_11940_14100 0.988200
R1779 n1_M2_11940_14100 n1_M2_13020_14100 0.988200
R1780 n1_M2_13020_14100 n1_M2_14100_14100 0.988200
R1781 n1_M2_14100_14100 n1_M2_15180_14100 0.988200
R1782 n1_M2_15180_14100 n1_M2_16260_14100 0.988200
R1783 n1_M2_16260_14100 n1_M2_17340_14100 0.988200
R1784 n1_M2_17340_14100 n1_M2_18420_14100 0.988200
R1785 n1_M2_18420_14100 n1_M2_19500_14100 0.988200
R1786 n1_M2_19500_14100 n1_M2_20580_14100 0.988200
R1787 n1_M2_20580_14100 n1_M2_21660_14100 0.988200
R1788 n1_M2_21660_14100 n1_M2_22740_14100 0.988200
R1789 n1_M2_22740_14100 n1_M2_23820_14100 0.988200
R1790 n1_M2_23820_14100 n1_M2_24900_14100 0.988200
R1791 n1_M2_24900_14100 n1_M2_25980_14100 0.988200
R1792 n1_M2_25980_14100 n1_M2_27060_14100 0.988200
R1793 n1_M2_27060_14100 n1_M2_28140_14100 0.988200
R1794 n1_M2_28140_14100 n1_M2_29220_14100 0.988200
R1795 n1_M2_29220_14100 n1_M2_30300_14100 0.988200
R1796 n1_M2_30300_14100 n1_M2_31380_14100 0.988200
R1797 n1_M2_31380_14100 n1_M2_32460_14100 0.988200
R1798 n1_M2_32460_14100 n1_M2_33540_14100 0.988200
R1799 n1_M2_33540_14100 n1_M2_34620_14100 0.988200
R1800 n1_M2_34620_14100 n1_M2_35700_14100 0.988200
R1801 n1_M2_35700_14100 n1_M2_36780_14100 0.988200
R1802 n1_M2_36780_14100 n1_M2_37860_14100 0.988200
R1803 n1_M2_37860_14100 n1_M2_38940_14100 0.988200
R1804 n1_M2_38940_14100 n1_M2_40020_14100 0.988200
R1805 n1_M2_40020_14100 n1_M2_41100_14100 0.988200
R1806 n1_M2_41100_14100 n1_M2_42180_14100 0.988200
R1807 n1_M2_42180_14100 n1_M2_43260_14100 0.988200
R1808 n1_M2_43260_14100 n1_M2_44340_14100 0.988200
R1809 n1_M2_44340_14100 n1_M2_45420_14100 0.988200
R1810 n1_M2_45420_14100 n1_M2_46500_14100 0.988200
R1811 n1_M2_46500_14100 n1_M2_47580_14100 0.988200
R1812 n1_M2_47580_14100 n1_M2_48660_14100 0.988200
R1813 n1_M2_48660_14100 n1_M2_49740_14100 0.988200
R1814 n1_M2_49740_14100 n1_M2_50820_14100 0.988200
R1815 n1_M2_50820_14100 n1_M2_51900_14100 0.988200
R1816 n1_M2_51900_14100 n1_M2_52980_14100 0.988200
R1817 n1_M2_52980_14100 n1_M2_54060_14100 0.988200
R1818 n1_M2_54060_14100 n1_M2_55140_14100 0.988200
R1819 n1_M2_55140_14100 n1_M2_56220_14100 0.988200
R1820 n1_M2_56220_14100 n1_M2_57300_14100 0.988200
R1821 n1_M2_57300_14100 n1_M2_58380_14100 0.988200
R1822 n1_M2_58380_14100 n1_M2_59460_14100 0.988200
R1823 n1_M2_59460_14100 n1_M2_60540_14100 0.988200
R1824 n1_M2_60540_14100 n1_M2_61620_14100 0.988200
R1825 n1_M2_61620_14100 n1_M2_62700_14100 0.988200
R1826 n1_M2_62700_14100 n1_M2_63780_14100 0.988200
R1827 n1_M2_63780_14100 n1_M2_64860_14100 0.988200
R1828 n1_M2_64860_14100 n1_M2_65940_14100 0.988200
R1829 n1_M2_65940_14100 n1_M2_67020_14100 0.988200
R1830 n1_M2_67020_14100 n1_M2_68100_14100 0.988200
R1831 n1_M2_68100_14100 n1_M2_69180_14100 0.988200
R1832 n1_M2_69180_14100 n1_M2_70260_14100 0.988200
R1833 n1_M2_70260_14100 n1_M2_71340_14100 0.988200
R1834 n1_M2_71340_14100 n1_M2_72420_14100 0.988200
R1835 n1_M2_72420_14100 n1_M2_73500_14100 0.988200
R1836 n1_M2_73500_14100 n1_M2_74580_14100 0.988200
R1837 n1_M2_74580_14100 n1_M2_75660_14100 0.988200
R1838 n1_M2_75660_14100 n1_M2_76740_14100 0.988200
R1839 n1_M2_76740_14100 n1_M2_77820_14100 0.988200
R1840 n1_M2_77820_14100 n1_M2_78900_14100 0.988200
R1841 n1_M2_78900_14100 n1_M2_79980_14100 0.988200
R1842 n1_M2_79980_14100 n1_M2_81060_14100 0.988200
R1843 n1_M2_81060_14100 n1_M2_82140_14100 0.988200
R1844 n1_M2_82140_14100 n1_M2_83220_14100 0.988200
R1845 n1_M2_83220_14100 n1_M2_84300_14100 0.988200
R1846 n1_M2_84300_14100 n1_M2_85380_14100 0.988200
R1847 n1_M2_85380_14100 n1_M2_86460_14100 0.988200
R1848 n1_M2_86460_14100 n1_M2_87540_14100 0.988200
R1849 n1_M2_87540_14100 n1_M2_88620_14100 0.988200
R1850 n1_M2_88620_14100 n1_M2_89700_14100 0.988200
R1851 n1_M2_89700_14100 n1_M2_90780_14100 0.988200
R1852 n1_M2_90780_14100 n1_M2_91860_14100 0.988200
R1853 n1_M2_91860_14100 n1_M2_92940_14100 0.988200
R1854 n1_M2_92940_14100 n1_M2_94020_14100 0.988200
R1855 n1_M2_94020_14100 n1_M2_95100_14100 0.988200
R1856 n1_M2_95100_14100 n1_M2_96180_14100 0.988200
R1857 n1_M2_96180_14100 n1_M2_97260_14100 0.988200
R1858 n1_M2_97260_14100 n1_M2_98340_14100 0.988200
R1859 n1_M2_98340_14100 n1_M2_99420_14100 0.988200
R1860 n1_M2_99420_14100 n1_M2_100500_14100 0.988200
R1861 n1_M2_100500_14100 n1_M2_101580_14100 0.988200
R1862 n1_M2_101580_14100 n1_M2_102660_14100 0.988200
R1863 n1_M2_102660_14100 n1_M2_103740_14100 0.988200
R1864 n1_M2_103740_14100 n1_M2_104820_14100 0.988200
R1865 n1_M2_104820_14100 n1_M2_105900_14100 0.988200
R1866 n1_M2_105900_14100 n1_M2_106980_14100 0.988200
R1867 n1_M2_106980_14100 n1_M2_108060_14100 0.988200
R1868 n1_M2_108060_14100 n1_M2_109140_14100 0.988200
R1869 n1_M2_109140_14100 n1_M2_110220_14100 0.988200
R1870 n1_M2_110220_14100 n1_M2_111300_14100 0.988200
R1871 n1_M2_111300_14100 n1_M2_112380_14100 0.988200
R1872 n1_M2_112380_14100 n1_M2_113460_14100 0.988200
R1873 n1_M2_113460_14100 n1_M2_114540_14100 0.988200
R1874 n1_M2_114540_14100 n1_M2_115620_14100 0.988200
R1875 n1_M2_115620_14100 n1_M2_116700_14100 0.988200
R1876 n1_M2_116700_14100 n1_M2_117780_14100 0.988200
R1877 n1_M2_117780_14100 n1_M2_118860_14100 0.988200
R1878 n1_M2_118860_14100 n1_M2_119940_14100 0.988200
R1879 n1_M2_119940_14100 n1_M2_121020_14100 0.988200
R1880 n1_M2_121020_14100 n1_M2_122100_14100 0.988200
R1881 n1_M2_122100_14100 n1_M2_123180_14100 0.988200
R1882 n1_M2_123180_14100 n1_M2_124260_14100 0.988200
R1883 n1_M2_124260_14100 n1_M2_125340_14100 0.988200
R1884 n1_M2_125340_14100 n1_M2_126420_14100 0.988200
R1885 n1_M2_126420_14100 n1_M2_127500_14100 0.988200
R1886 n1_M2_127500_14100 n1_M2_128580_14100 0.988200
R1887 n1_M2_128580_14100 n1_M2_129660_14100 0.988200
R1888 n1_M2_129660_14100 n1_M2_130740_14100 0.988200
R1889 n1_M2_130740_14100 n1_M2_131820_14100 0.988200
R1890 n1_M2_131820_14100 n1_M2_132900_14100 0.988200
R1891 n1_M2_132900_14100 n1_M2_133980_14100 0.988200
R1892 n1_M2_133980_14100 n1_M2_135060_14100 0.988200
R1893 n1_M2_135060_14100 n1_M2_136140_14100 0.988200
R1894 n1_M2_136140_14100 n1_M2_137220_14100 0.988200
R1895 n1_M2_137220_14100 n1_M2_138300_14100 0.988200
R1896 n1_M2_138300_14100 n1_M2_139380_14100 0.988200
R1897 n1_M2_139380_14100 n1_M2_140460_14100 0.988200
R1898 n1_M2_140460_14100 n1_M2_141540_14100 0.988200
R1899 n1_M2_141540_14100 n1_M2_142620_14100 0.988200
R1900 n1_M2_142620_14100 n1_M2_143700_14100 0.988200
R1901 n1_M2_143700_14100 n1_M2_144780_14100 0.988200
R1902 n1_M2_144780_14100 n1_M2_145860_14100 0.988200
R1903 n1_M2_145860_14100 n1_M2_146940_14100 0.988200
R1904 n1_M2_60_15180 n1_M2_1140_15180 0.988200
R1905 n1_M2_1140_15180 n1_M2_2220_15180 0.988200
R1906 n1_M2_2220_15180 n1_M2_3300_15180 0.988200
R1907 n1_M2_3300_15180 n1_M2_4380_15180 0.988200
R1908 n1_M2_4380_15180 n1_M2_5460_15180 0.988200
R1909 n1_M2_5460_15180 n1_M2_6540_15180 0.988200
R1910 n1_M2_6540_15180 n1_M2_7620_15180 0.988200
R1911 n1_M2_7620_15180 n1_M2_8700_15180 0.988200
R1912 n1_M2_8700_15180 n1_M2_9780_15180 0.988200
R1913 n1_M2_9780_15180 n1_M2_10860_15180 0.988200
R1914 n1_M2_10860_15180 n1_M2_11940_15180 0.988200
R1915 n1_M2_11940_15180 n1_M2_13020_15180 0.988200
R1916 n1_M2_13020_15180 n1_M2_14100_15180 0.988200
R1917 n1_M2_14100_15180 n1_M2_15180_15180 0.988200
R1918 n1_M2_15180_15180 n1_M2_16260_15180 0.988200
R1919 n1_M2_16260_15180 n1_M2_17340_15180 0.988200
R1920 n1_M2_17340_15180 n1_M2_18420_15180 0.988200
R1921 n1_M2_18420_15180 n1_M2_19500_15180 0.988200
R1922 n1_M2_19500_15180 n1_M2_20580_15180 0.988200
R1923 n1_M2_20580_15180 n1_M2_21660_15180 0.988200
R1924 n1_M2_21660_15180 n1_M2_22740_15180 0.988200
R1925 n1_M2_22740_15180 n1_M2_23820_15180 0.988200
R1926 n1_M2_23820_15180 n1_M2_24900_15180 0.988200
R1927 n1_M2_24900_15180 n1_M2_25980_15180 0.988200
R1928 n1_M2_25980_15180 n1_M2_27060_15180 0.988200
R1929 n1_M2_27060_15180 n1_M2_28140_15180 0.988200
R1930 n1_M2_28140_15180 n1_M2_29220_15180 0.988200
R1931 n1_M2_29220_15180 n1_M2_30300_15180 0.988200
R1932 n1_M2_30300_15180 n1_M2_31380_15180 0.988200
R1933 n1_M2_31380_15180 n1_M2_32460_15180 0.988200
R1934 n1_M2_32460_15180 n1_M2_33540_15180 0.988200
R1935 n1_M2_33540_15180 n1_M2_34620_15180 0.988200
R1936 n1_M2_34620_15180 n1_M2_35700_15180 0.988200
R1937 n1_M2_35700_15180 n1_M2_36780_15180 0.988200
R1938 n1_M2_36780_15180 n1_M2_37860_15180 0.988200
R1939 n1_M2_37860_15180 n1_M2_38940_15180 0.988200
R1940 n1_M2_38940_15180 n1_M2_40020_15180 0.988200
R1941 n1_M2_40020_15180 n1_M2_41100_15180 0.988200
R1942 n1_M2_41100_15180 n1_M2_42180_15180 0.988200
R1943 n1_M2_42180_15180 n1_M2_43260_15180 0.988200
R1944 n1_M2_43260_15180 n1_M2_44340_15180 0.988200
R1945 n1_M2_44340_15180 n1_M2_45420_15180 0.988200
R1946 n1_M2_45420_15180 n1_M2_46500_15180 0.988200
R1947 n1_M2_46500_15180 n1_M2_47580_15180 0.988200
R1948 n1_M2_47580_15180 n1_M2_48660_15180 0.988200
R1949 n1_M2_48660_15180 n1_M2_49740_15180 0.988200
R1950 n1_M2_49740_15180 n1_M2_50820_15180 0.988200
R1951 n1_M2_50820_15180 n1_M2_51900_15180 0.988200
R1952 n1_M2_51900_15180 n1_M2_52980_15180 0.988200
R1953 n1_M2_52980_15180 n1_M2_54060_15180 0.988200
R1954 n1_M2_54060_15180 n1_M2_55140_15180 0.988200
R1955 n1_M2_55140_15180 n1_M2_56220_15180 0.988200
R1956 n1_M2_56220_15180 n1_M2_57300_15180 0.988200
R1957 n1_M2_57300_15180 n1_M2_58380_15180 0.988200
R1958 n1_M2_58380_15180 n1_M2_59460_15180 0.988200
R1959 n1_M2_59460_15180 n1_M2_60540_15180 0.988200
R1960 n1_M2_60540_15180 n1_M2_61620_15180 0.988200
R1961 n1_M2_61620_15180 n1_M2_62700_15180 0.988200
R1962 n1_M2_62700_15180 n1_M2_63780_15180 0.988200
R1963 n1_M2_63780_15180 n1_M2_64860_15180 0.988200
R1964 n1_M2_64860_15180 n1_M2_65940_15180 0.988200
R1965 n1_M2_65940_15180 n1_M2_67020_15180 0.988200
R1966 n1_M2_67020_15180 n1_M2_68100_15180 0.988200
R1967 n1_M2_68100_15180 n1_M2_69180_15180 0.988200
R1968 n1_M2_69180_15180 n1_M2_70260_15180 0.988200
R1969 n1_M2_70260_15180 n1_M2_71340_15180 0.988200
R1970 n1_M2_71340_15180 n1_M2_72420_15180 0.988200
R1971 n1_M2_72420_15180 n1_M2_73500_15180 0.988200
R1972 n1_M2_73500_15180 n1_M2_74580_15180 0.988200
R1973 n1_M2_74580_15180 n1_M2_75660_15180 0.988200
R1974 n1_M2_75660_15180 n1_M2_76740_15180 0.988200
R1975 n1_M2_76740_15180 n1_M2_77820_15180 0.988200
R1976 n1_M2_77820_15180 n1_M2_78900_15180 0.988200
R1977 n1_M2_78900_15180 n1_M2_79980_15180 0.988200
R1978 n1_M2_79980_15180 n1_M2_81060_15180 0.988200
R1979 n1_M2_81060_15180 n1_M2_82140_15180 0.988200
R1980 n1_M2_82140_15180 n1_M2_83220_15180 0.988200
R1981 n1_M2_83220_15180 n1_M2_84300_15180 0.988200
R1982 n1_M2_84300_15180 n1_M2_85380_15180 0.988200
R1983 n1_M2_85380_15180 n1_M2_86460_15180 0.988200
R1984 n1_M2_86460_15180 n1_M2_87540_15180 0.988200
R1985 n1_M2_87540_15180 n1_M2_88620_15180 0.988200
R1986 n1_M2_88620_15180 n1_M2_89700_15180 0.988200
R1987 n1_M2_89700_15180 n1_M2_90780_15180 0.988200
R1988 n1_M2_90780_15180 n1_M2_91860_15180 0.988200
R1989 n1_M2_91860_15180 n1_M2_92940_15180 0.988200
R1990 n1_M2_92940_15180 n1_M2_94020_15180 0.988200
R1991 n1_M2_94020_15180 n1_M2_95100_15180 0.988200
R1992 n1_M2_95100_15180 n1_M2_96180_15180 0.988200
R1993 n1_M2_96180_15180 n1_M2_97260_15180 0.988200
R1994 n1_M2_97260_15180 n1_M2_98340_15180 0.988200
R1995 n1_M2_98340_15180 n1_M2_99420_15180 0.988200
R1996 n1_M2_99420_15180 n1_M2_100500_15180 0.988200
R1997 n1_M2_100500_15180 n1_M2_101580_15180 0.988200
R1998 n1_M2_101580_15180 n1_M2_102660_15180 0.988200
R1999 n1_M2_102660_15180 n1_M2_103740_15180 0.988200
R2000 n1_M2_103740_15180 n1_M2_104820_15180 0.988200
R2001 n1_M2_104820_15180 n1_M2_105900_15180 0.988200
R2002 n1_M2_105900_15180 n1_M2_106980_15180 0.988200
R2003 n1_M2_106980_15180 n1_M2_108060_15180 0.988200
R2004 n1_M2_108060_15180 n1_M2_109140_15180 0.988200
R2005 n1_M2_109140_15180 n1_M2_110220_15180 0.988200
R2006 n1_M2_110220_15180 n1_M2_111300_15180 0.988200
R2007 n1_M2_111300_15180 n1_M2_112380_15180 0.988200
R2008 n1_M2_112380_15180 n1_M2_113460_15180 0.988200
R2009 n1_M2_113460_15180 n1_M2_114540_15180 0.988200
R2010 n1_M2_114540_15180 n1_M2_115620_15180 0.988200
R2011 n1_M2_115620_15180 n1_M2_116700_15180 0.988200
R2012 n1_M2_116700_15180 n1_M2_117780_15180 0.988200
R2013 n1_M2_117780_15180 n1_M2_118860_15180 0.988200
R2014 n1_M2_118860_15180 n1_M2_119940_15180 0.988200
R2015 n1_M2_119940_15180 n1_M2_121020_15180 0.988200
R2016 n1_M2_121020_15180 n1_M2_122100_15180 0.988200
R2017 n1_M2_122100_15180 n1_M2_123180_15180 0.988200
R2018 n1_M2_123180_15180 n1_M2_124260_15180 0.988200
R2019 n1_M2_124260_15180 n1_M2_125340_15180 0.988200
R2020 n1_M2_125340_15180 n1_M2_126420_15180 0.988200
R2021 n1_M2_126420_15180 n1_M2_127500_15180 0.988200
R2022 n1_M2_127500_15180 n1_M2_128580_15180 0.988200
R2023 n1_M2_128580_15180 n1_M2_129660_15180 0.988200
R2024 n1_M2_129660_15180 n1_M2_130740_15180 0.988200
R2025 n1_M2_130740_15180 n1_M2_131820_15180 0.988200
R2026 n1_M2_131820_15180 n1_M2_132900_15180 0.988200
R2027 n1_M2_132900_15180 n1_M2_133980_15180 0.988200
R2028 n1_M2_133980_15180 n1_M2_135060_15180 0.988200
R2029 n1_M2_135060_15180 n1_M2_136140_15180 0.988200
R2030 n1_M2_136140_15180 n1_M2_137220_15180 0.988200
R2031 n1_M2_137220_15180 n1_M2_138300_15180 0.988200
R2032 n1_M2_138300_15180 n1_M2_139380_15180 0.988200
R2033 n1_M2_139380_15180 n1_M2_140460_15180 0.988200
R2034 n1_M2_140460_15180 n1_M2_141540_15180 0.988200
R2035 n1_M2_141540_15180 n1_M2_142620_15180 0.988200
R2036 n1_M2_142620_15180 n1_M2_143700_15180 0.988200
R2037 n1_M2_143700_15180 n1_M2_144780_15180 0.988200
R2038 n1_M2_144780_15180 n1_M2_145860_15180 0.988200
R2039 n1_M2_145860_15180 n1_M2_146940_15180 0.988200
R2040 n1_M2_60_16260 n1_M2_1140_16260 0.988200
R2041 n1_M2_1140_16260 n1_M2_2220_16260 0.988200
R2042 n1_M2_2220_16260 n1_M2_3300_16260 0.988200
R2043 n1_M2_3300_16260 n1_M2_4380_16260 0.988200
R2044 n1_M2_4380_16260 n1_M2_5460_16260 0.988200
R2045 n1_M2_5460_16260 n1_M2_6540_16260 0.988200
R2046 n1_M2_6540_16260 n1_M2_7620_16260 0.988200
R2047 n1_M2_7620_16260 n1_M2_8700_16260 0.988200
R2048 n1_M2_8700_16260 n1_M2_9780_16260 0.988200
R2049 n1_M2_9780_16260 n1_M2_10860_16260 0.988200
R2050 n1_M2_10860_16260 n1_M2_11940_16260 0.988200
R2051 n1_M2_11940_16260 n1_M2_13020_16260 0.988200
R2052 n1_M2_13020_16260 n1_M2_14100_16260 0.988200
R2053 n1_M2_14100_16260 n1_M2_15180_16260 0.988200
R2054 n1_M2_15180_16260 n1_M2_16260_16260 0.988200
R2055 n1_M2_16260_16260 n1_M2_17340_16260 0.988200
R2056 n1_M2_17340_16260 n1_M2_18420_16260 0.988200
R2057 n1_M2_18420_16260 n1_M2_19500_16260 0.988200
R2058 n1_M2_19500_16260 n1_M2_20580_16260 0.988200
R2059 n1_M2_20580_16260 n1_M2_21660_16260 0.988200
R2060 n1_M2_21660_16260 n1_M2_22740_16260 0.988200
R2061 n1_M2_22740_16260 n1_M2_23820_16260 0.988200
R2062 n1_M2_23820_16260 n1_M2_24900_16260 0.988200
R2063 n1_M2_24900_16260 n1_M2_25980_16260 0.988200
R2064 n1_M2_25980_16260 n1_M2_27060_16260 0.988200
R2065 n1_M2_27060_16260 n1_M2_28140_16260 0.988200
R2066 n1_M2_28140_16260 n1_M2_29220_16260 0.988200
R2067 n1_M2_29220_16260 n1_M2_30300_16260 0.988200
R2068 n1_M2_30300_16260 n1_M2_31380_16260 0.988200
R2069 n1_M2_31380_16260 n1_M2_32460_16260 0.988200
R2070 n1_M2_32460_16260 n1_M2_33540_16260 0.988200
R2071 n1_M2_33540_16260 n1_M2_34620_16260 0.988200
R2072 n1_M2_34620_16260 n1_M2_35700_16260 0.988200
R2073 n1_M2_35700_16260 n1_M2_36780_16260 0.988200
R2074 n1_M2_36780_16260 n1_M2_37860_16260 0.988200
R2075 n1_M2_37860_16260 n1_M2_38940_16260 0.988200
R2076 n1_M2_38940_16260 n1_M2_40020_16260 0.988200
R2077 n1_M2_40020_16260 n1_M2_41100_16260 0.988200
R2078 n1_M2_41100_16260 n1_M2_42180_16260 0.988200
R2079 n1_M2_42180_16260 n1_M2_43260_16260 0.988200
R2080 n1_M2_43260_16260 n1_M2_44340_16260 0.988200
R2081 n1_M2_44340_16260 n1_M2_45420_16260 0.988200
R2082 n1_M2_45420_16260 n1_M2_46500_16260 0.988200
R2083 n1_M2_46500_16260 n1_M2_47580_16260 0.988200
R2084 n1_M2_47580_16260 n1_M2_48660_16260 0.988200
R2085 n1_M2_48660_16260 n1_M2_49740_16260 0.988200
R2086 n1_M2_49740_16260 n1_M2_50820_16260 0.988200
R2087 n1_M2_50820_16260 n1_M2_51900_16260 0.988200
R2088 n1_M2_51900_16260 n1_M2_52980_16260 0.988200
R2089 n1_M2_52980_16260 n1_M2_54060_16260 0.988200
R2090 n1_M2_54060_16260 n1_M2_55140_16260 0.988200
R2091 n1_M2_55140_16260 n1_M2_56220_16260 0.988200
R2092 n1_M2_56220_16260 n1_M2_57300_16260 0.988200
R2093 n1_M2_57300_16260 n1_M2_58380_16260 0.988200
R2094 n1_M2_58380_16260 n1_M2_59460_16260 0.988200
R2095 n1_M2_59460_16260 n1_M2_60540_16260 0.988200
R2096 n1_M2_60540_16260 n1_M2_61620_16260 0.988200
R2097 n1_M2_61620_16260 n1_M2_62700_16260 0.988200
R2098 n1_M2_62700_16260 n1_M2_63780_16260 0.988200
R2099 n1_M2_63780_16260 n1_M2_64860_16260 0.988200
R2100 n1_M2_64860_16260 n1_M2_65940_16260 0.988200
R2101 n1_M2_65940_16260 n1_M2_67020_16260 0.988200
R2102 n1_M2_67020_16260 n1_M2_68100_16260 0.988200
R2103 n1_M2_68100_16260 n1_M2_69180_16260 0.988200
R2104 n1_M2_69180_16260 n1_M2_70260_16260 0.988200
R2105 n1_M2_70260_16260 n1_M2_71340_16260 0.988200
R2106 n1_M2_71340_16260 n1_M2_72420_16260 0.988200
R2107 n1_M2_72420_16260 n1_M2_73500_16260 0.988200
R2108 n1_M2_73500_16260 n1_M2_74580_16260 0.988200
R2109 n1_M2_74580_16260 n1_M2_75660_16260 0.988200
R2110 n1_M2_75660_16260 n1_M2_76740_16260 0.988200
R2111 n1_M2_76740_16260 n1_M2_77820_16260 0.988200
R2112 n1_M2_77820_16260 n1_M2_78900_16260 0.988200
R2113 n1_M2_78900_16260 n1_M2_79980_16260 0.988200
R2114 n1_M2_79980_16260 n1_M2_81060_16260 0.988200
R2115 n1_M2_81060_16260 n1_M2_82140_16260 0.988200
R2116 n1_M2_82140_16260 n1_M2_83220_16260 0.988200
R2117 n1_M2_83220_16260 n1_M2_84300_16260 0.988200
R2118 n1_M2_84300_16260 n1_M2_85380_16260 0.988200
R2119 n1_M2_85380_16260 n1_M2_86460_16260 0.988200
R2120 n1_M2_86460_16260 n1_M2_87540_16260 0.988200
R2121 n1_M2_87540_16260 n1_M2_88620_16260 0.988200
R2122 n1_M2_88620_16260 n1_M2_89700_16260 0.988200
R2123 n1_M2_89700_16260 n1_M2_90780_16260 0.988200
R2124 n1_M2_90780_16260 n1_M2_91860_16260 0.988200
R2125 n1_M2_91860_16260 n1_M2_92940_16260 0.988200
R2126 n1_M2_92940_16260 n1_M2_94020_16260 0.988200
R2127 n1_M2_94020_16260 n1_M2_95100_16260 0.988200
R2128 n1_M2_95100_16260 n1_M2_96180_16260 0.988200
R2129 n1_M2_96180_16260 n1_M2_97260_16260 0.988200
R2130 n1_M2_97260_16260 n1_M2_98340_16260 0.988200
R2131 n1_M2_98340_16260 n1_M2_99420_16260 0.988200
R2132 n1_M2_99420_16260 n1_M2_100500_16260 0.988200
R2133 n1_M2_100500_16260 n1_M2_101580_16260 0.988200
R2134 n1_M2_101580_16260 n1_M2_102660_16260 0.988200
R2135 n1_M2_102660_16260 n1_M2_103740_16260 0.988200
R2136 n1_M2_103740_16260 n1_M2_104820_16260 0.988200
R2137 n1_M2_104820_16260 n1_M2_105900_16260 0.988200
R2138 n1_M2_105900_16260 n1_M2_106980_16260 0.988200
R2139 n1_M2_106980_16260 n1_M2_108060_16260 0.988200
R2140 n1_M2_108060_16260 n1_M2_109140_16260 0.988200
R2141 n1_M2_109140_16260 n1_M2_110220_16260 0.988200
R2142 n1_M2_110220_16260 n1_M2_111300_16260 0.988200
R2143 n1_M2_111300_16260 n1_M2_112380_16260 0.988200
R2144 n1_M2_112380_16260 n1_M2_113460_16260 0.988200
R2145 n1_M2_113460_16260 n1_M2_114540_16260 0.988200
R2146 n1_M2_114540_16260 n1_M2_115620_16260 0.988200
R2147 n1_M2_115620_16260 n1_M2_116700_16260 0.988200
R2148 n1_M2_116700_16260 n1_M2_117780_16260 0.988200
R2149 n1_M2_117780_16260 n1_M2_118860_16260 0.988200
R2150 n1_M2_118860_16260 n1_M2_119940_16260 0.988200
R2151 n1_M2_119940_16260 n1_M2_121020_16260 0.988200
R2152 n1_M2_121020_16260 n1_M2_122100_16260 0.988200
R2153 n1_M2_122100_16260 n1_M2_123180_16260 0.988200
R2154 n1_M2_123180_16260 n1_M2_124260_16260 0.988200
R2155 n1_M2_124260_16260 n1_M2_125340_16260 0.988200
R2156 n1_M2_125340_16260 n1_M2_126420_16260 0.988200
R2157 n1_M2_126420_16260 n1_M2_127500_16260 0.988200
R2158 n1_M2_127500_16260 n1_M2_128580_16260 0.988200
R2159 n1_M2_128580_16260 n1_M2_129660_16260 0.988200
R2160 n1_M2_129660_16260 n1_M2_130740_16260 0.988200
R2161 n1_M2_130740_16260 n1_M2_131820_16260 0.988200
R2162 n1_M2_131820_16260 n1_M2_132900_16260 0.988200
R2163 n1_M2_132900_16260 n1_M2_133980_16260 0.988200
R2164 n1_M2_133980_16260 n1_M2_135060_16260 0.988200
R2165 n1_M2_135060_16260 n1_M2_136140_16260 0.988200
R2166 n1_M2_136140_16260 n1_M2_137220_16260 0.988200
R2167 n1_M2_137220_16260 n1_M2_138300_16260 0.988200
R2168 n1_M2_138300_16260 n1_M2_139380_16260 0.988200
R2169 n1_M2_139380_16260 n1_M2_140460_16260 0.988200
R2170 n1_M2_140460_16260 n1_M2_141540_16260 0.988200
R2171 n1_M2_141540_16260 n1_M2_142620_16260 0.988200
R2172 n1_M2_142620_16260 n1_M2_143700_16260 0.988200
R2173 n1_M2_143700_16260 n1_M2_144780_16260 0.988200
R2174 n1_M2_144780_16260 n1_M2_145860_16260 0.988200
R2175 n1_M2_145860_16260 n1_M2_146940_16260 0.988200
R2176 n1_M2_60_17340 n1_M2_1140_17340 0.988200
R2177 n1_M2_1140_17340 n1_M2_2220_17340 0.988200
R2178 n1_M2_2220_17340 n1_M2_3300_17340 0.988200
R2179 n1_M2_3300_17340 n1_M2_4380_17340 0.988200
R2180 n1_M2_4380_17340 n1_M2_5460_17340 0.988200
R2181 n1_M2_5460_17340 n1_M2_6540_17340 0.988200
R2182 n1_M2_6540_17340 n1_M2_7620_17340 0.988200
R2183 n1_M2_7620_17340 n1_M2_8700_17340 0.988200
R2184 n1_M2_8700_17340 n1_M2_9780_17340 0.988200
R2185 n1_M2_9780_17340 n1_M2_10860_17340 0.988200
R2186 n1_M2_10860_17340 n1_M2_11940_17340 0.988200
R2187 n1_M2_11940_17340 n1_M2_13020_17340 0.988200
R2188 n1_M2_13020_17340 n1_M2_14100_17340 0.988200
R2189 n1_M2_14100_17340 n1_M2_15180_17340 0.988200
R2190 n1_M2_15180_17340 n1_M2_16260_17340 0.988200
R2191 n1_M2_16260_17340 n1_M2_17340_17340 0.988200
R2192 n1_M2_17340_17340 n1_M2_18420_17340 0.988200
R2193 n1_M2_18420_17340 n1_M2_19500_17340 0.988200
R2194 n1_M2_19500_17340 n1_M2_20580_17340 0.988200
R2195 n1_M2_20580_17340 n1_M2_21660_17340 0.988200
R2196 n1_M2_21660_17340 n1_M2_22740_17340 0.988200
R2197 n1_M2_22740_17340 n1_M2_23820_17340 0.988200
R2198 n1_M2_23820_17340 n1_M2_24900_17340 0.988200
R2199 n1_M2_24900_17340 n1_M2_25980_17340 0.988200
R2200 n1_M2_25980_17340 n1_M2_27060_17340 0.988200
R2201 n1_M2_27060_17340 n1_M2_28140_17340 0.988200
R2202 n1_M2_28140_17340 n1_M2_29220_17340 0.988200
R2203 n1_M2_29220_17340 n1_M2_30300_17340 0.988200
R2204 n1_M2_30300_17340 n1_M2_31380_17340 0.988200
R2205 n1_M2_31380_17340 n1_M2_32460_17340 0.988200
R2206 n1_M2_32460_17340 n1_M2_33540_17340 0.988200
R2207 n1_M2_33540_17340 n1_M2_34620_17340 0.988200
R2208 n1_M2_34620_17340 n1_M2_35700_17340 0.988200
R2209 n1_M2_35700_17340 n1_M2_36780_17340 0.988200
R2210 n1_M2_36780_17340 n1_M2_37860_17340 0.988200
R2211 n1_M2_37860_17340 n1_M2_38940_17340 0.988200
R2212 n1_M2_38940_17340 n1_M2_40020_17340 0.988200
R2213 n1_M2_40020_17340 n1_M2_41100_17340 0.988200
R2214 n1_M2_41100_17340 n1_M2_42180_17340 0.988200
R2215 n1_M2_42180_17340 n1_M2_43260_17340 0.988200
R2216 n1_M2_43260_17340 n1_M2_44340_17340 0.988200
R2217 n1_M2_44340_17340 n1_M2_45420_17340 0.988200
R2218 n1_M2_45420_17340 n1_M2_46500_17340 0.988200
R2219 n1_M2_46500_17340 n1_M2_47580_17340 0.988200
R2220 n1_M2_47580_17340 n1_M2_48660_17340 0.988200
R2221 n1_M2_48660_17340 n1_M2_49740_17340 0.988200
R2222 n1_M2_49740_17340 n1_M2_50820_17340 0.988200
R2223 n1_M2_50820_17340 n1_M2_51900_17340 0.988200
R2224 n1_M2_51900_17340 n1_M2_52980_17340 0.988200
R2225 n1_M2_52980_17340 n1_M2_54060_17340 0.988200
R2226 n1_M2_54060_17340 n1_M2_55140_17340 0.988200
R2227 n1_M2_55140_17340 n1_M2_56220_17340 0.988200
R2228 n1_M2_56220_17340 n1_M2_57300_17340 0.988200
R2229 n1_M2_57300_17340 n1_M2_58380_17340 0.988200
R2230 n1_M2_58380_17340 n1_M2_59460_17340 0.988200
R2231 n1_M2_59460_17340 n1_M2_60540_17340 0.988200
R2232 n1_M2_60540_17340 n1_M2_61620_17340 0.988200
R2233 n1_M2_61620_17340 n1_M2_62700_17340 0.988200
R2234 n1_M2_62700_17340 n1_M2_63780_17340 0.988200
R2235 n1_M2_63780_17340 n1_M2_64860_17340 0.988200
R2236 n1_M2_64860_17340 n1_M2_65940_17340 0.988200
R2237 n1_M2_65940_17340 n1_M2_67020_17340 0.988200
R2238 n1_M2_67020_17340 n1_M2_68100_17340 0.988200
R2239 n1_M2_68100_17340 n1_M2_69180_17340 0.988200
R2240 n1_M2_69180_17340 n1_M2_70260_17340 0.988200
R2241 n1_M2_70260_17340 n1_M2_71340_17340 0.988200
R2242 n1_M2_71340_17340 n1_M2_72420_17340 0.988200
R2243 n1_M2_72420_17340 n1_M2_73500_17340 0.988200
R2244 n1_M2_73500_17340 n1_M2_74580_17340 0.988200
R2245 n1_M2_74580_17340 n1_M2_75660_17340 0.988200
R2246 n1_M2_75660_17340 n1_M2_76740_17340 0.988200
R2247 n1_M2_76740_17340 n1_M2_77820_17340 0.988200
R2248 n1_M2_77820_17340 n1_M2_78900_17340 0.988200
R2249 n1_M2_78900_17340 n1_M2_79980_17340 0.988200
R2250 n1_M2_79980_17340 n1_M2_81060_17340 0.988200
R2251 n1_M2_81060_17340 n1_M2_82140_17340 0.988200
R2252 n1_M2_82140_17340 n1_M2_83220_17340 0.988200
R2253 n1_M2_83220_17340 n1_M2_84300_17340 0.988200
R2254 n1_M2_84300_17340 n1_M2_85380_17340 0.988200
R2255 n1_M2_85380_17340 n1_M2_86460_17340 0.988200
R2256 n1_M2_86460_17340 n1_M2_87540_17340 0.988200
R2257 n1_M2_87540_17340 n1_M2_88620_17340 0.988200
R2258 n1_M2_88620_17340 n1_M2_89700_17340 0.988200
R2259 n1_M2_89700_17340 n1_M2_90780_17340 0.988200
R2260 n1_M2_90780_17340 n1_M2_91860_17340 0.988200
R2261 n1_M2_91860_17340 n1_M2_92940_17340 0.988200
R2262 n1_M2_92940_17340 n1_M2_94020_17340 0.988200
R2263 n1_M2_94020_17340 n1_M2_95100_17340 0.988200
R2264 n1_M2_95100_17340 n1_M2_96180_17340 0.988200
R2265 n1_M2_96180_17340 n1_M2_97260_17340 0.988200
R2266 n1_M2_97260_17340 n1_M2_98340_17340 0.988200
R2267 n1_M2_98340_17340 n1_M2_99420_17340 0.988200
R2268 n1_M2_99420_17340 n1_M2_100500_17340 0.988200
R2269 n1_M2_100500_17340 n1_M2_101580_17340 0.988200
R2270 n1_M2_101580_17340 n1_M2_102660_17340 0.988200
R2271 n1_M2_102660_17340 n1_M2_103740_17340 0.988200
R2272 n1_M2_103740_17340 n1_M2_104820_17340 0.988200
R2273 n1_M2_104820_17340 n1_M2_105900_17340 0.988200
R2274 n1_M2_105900_17340 n1_M2_106980_17340 0.988200
R2275 n1_M2_106980_17340 n1_M2_108060_17340 0.988200
R2276 n1_M2_108060_17340 n1_M2_109140_17340 0.988200
R2277 n1_M2_109140_17340 n1_M2_110220_17340 0.988200
R2278 n1_M2_110220_17340 n1_M2_111300_17340 0.988200
R2279 n1_M2_111300_17340 n1_M2_112380_17340 0.988200
R2280 n1_M2_112380_17340 n1_M2_113460_17340 0.988200
R2281 n1_M2_113460_17340 n1_M2_114540_17340 0.988200
R2282 n1_M2_114540_17340 n1_M2_115620_17340 0.988200
R2283 n1_M2_115620_17340 n1_M2_116700_17340 0.988200
R2284 n1_M2_116700_17340 n1_M2_117780_17340 0.988200
R2285 n1_M2_117780_17340 n1_M2_118860_17340 0.988200
R2286 n1_M2_118860_17340 n1_M2_119940_17340 0.988200
R2287 n1_M2_119940_17340 n1_M2_121020_17340 0.988200
R2288 n1_M2_121020_17340 n1_M2_122100_17340 0.988200
R2289 n1_M2_122100_17340 n1_M2_123180_17340 0.988200
R2290 n1_M2_123180_17340 n1_M2_124260_17340 0.988200
R2291 n1_M2_124260_17340 n1_M2_125340_17340 0.988200
R2292 n1_M2_125340_17340 n1_M2_126420_17340 0.988200
R2293 n1_M2_126420_17340 n1_M2_127500_17340 0.988200
R2294 n1_M2_127500_17340 n1_M2_128580_17340 0.988200
R2295 n1_M2_128580_17340 n1_M2_129660_17340 0.988200
R2296 n1_M2_129660_17340 n1_M2_130740_17340 0.988200
R2297 n1_M2_130740_17340 n1_M2_131820_17340 0.988200
R2298 n1_M2_131820_17340 n1_M2_132900_17340 0.988200
R2299 n1_M2_132900_17340 n1_M2_133980_17340 0.988200
R2300 n1_M2_133980_17340 n1_M2_135060_17340 0.988200
R2301 n1_M2_135060_17340 n1_M2_136140_17340 0.988200
R2302 n1_M2_136140_17340 n1_M2_137220_17340 0.988200
R2303 n1_M2_137220_17340 n1_M2_138300_17340 0.988200
R2304 n1_M2_138300_17340 n1_M2_139380_17340 0.988200
R2305 n1_M2_139380_17340 n1_M2_140460_17340 0.988200
R2306 n1_M2_140460_17340 n1_M2_141540_17340 0.988200
R2307 n1_M2_141540_17340 n1_M2_142620_17340 0.988200
R2308 n1_M2_142620_17340 n1_M2_143700_17340 0.988200
R2309 n1_M2_143700_17340 n1_M2_144780_17340 0.988200
R2310 n1_M2_144780_17340 n1_M2_145860_17340 0.988200
R2311 n1_M2_145860_17340 n1_M2_146940_17340 0.988200
R2312 n1_M2_60_18420 n1_M2_1140_18420 0.988200
R2313 n1_M2_1140_18420 n1_M2_2220_18420 0.988200
R2314 n1_M2_2220_18420 n1_M2_3300_18420 0.988200
R2315 n1_M2_3300_18420 n1_M2_4380_18420 0.988200
R2316 n1_M2_4380_18420 n1_M2_5460_18420 0.988200
R2317 n1_M2_5460_18420 n1_M2_6540_18420 0.988200
R2318 n1_M2_6540_18420 n1_M2_7620_18420 0.988200
R2319 n1_M2_7620_18420 n1_M2_8700_18420 0.988200
R2320 n1_M2_8700_18420 n1_M2_9780_18420 0.988200
R2321 n1_M2_9780_18420 n1_M2_10860_18420 0.988200
R2322 n1_M2_10860_18420 n1_M2_11940_18420 0.988200
R2323 n1_M2_11940_18420 n1_M2_13020_18420 0.988200
R2324 n1_M2_13020_18420 n1_M2_14100_18420 0.988200
R2325 n1_M2_14100_18420 n1_M2_15180_18420 0.988200
R2326 n1_M2_15180_18420 n1_M2_16260_18420 0.988200
R2327 n1_M2_16260_18420 n1_M2_17340_18420 0.988200
R2328 n1_M2_17340_18420 n1_M2_18420_18420 0.988200
R2329 n1_M2_18420_18420 n1_M2_19500_18420 0.988200
R2330 n1_M2_19500_18420 n1_M2_20580_18420 0.988200
R2331 n1_M2_20580_18420 n1_M2_21660_18420 0.988200
R2332 n1_M2_21660_18420 n1_M2_22740_18420 0.988200
R2333 n1_M2_22740_18420 n1_M2_23820_18420 0.988200
R2334 n1_M2_23820_18420 n1_M2_24900_18420 0.988200
R2335 n1_M2_24900_18420 n1_M2_25980_18420 0.988200
R2336 n1_M2_25980_18420 n1_M2_27060_18420 0.988200
R2337 n1_M2_27060_18420 n1_M2_28140_18420 0.988200
R2338 n1_M2_28140_18420 n1_M2_29220_18420 0.988200
R2339 n1_M2_29220_18420 n1_M2_30300_18420 0.988200
R2340 n1_M2_30300_18420 n1_M2_31380_18420 0.988200
R2341 n1_M2_31380_18420 n1_M2_32460_18420 0.988200
R2342 n1_M2_32460_18420 n1_M2_33540_18420 0.988200
R2343 n1_M2_33540_18420 n1_M2_34620_18420 0.988200
R2344 n1_M2_34620_18420 n1_M2_35700_18420 0.988200
R2345 n1_M2_35700_18420 n1_M2_36780_18420 0.988200
R2346 n1_M2_36780_18420 n1_M2_37860_18420 0.988200
R2347 n1_M2_37860_18420 n1_M2_38940_18420 0.988200
R2348 n1_M2_38940_18420 n1_M2_40020_18420 0.988200
R2349 n1_M2_40020_18420 n1_M2_41100_18420 0.988200
R2350 n1_M2_41100_18420 n1_M2_42180_18420 0.988200
R2351 n1_M2_42180_18420 n1_M2_43260_18420 0.988200
R2352 n1_M2_43260_18420 n1_M2_44340_18420 0.988200
R2353 n1_M2_44340_18420 n1_M2_45420_18420 0.988200
R2354 n1_M2_45420_18420 n1_M2_46500_18420 0.988200
R2355 n1_M2_46500_18420 n1_M2_47580_18420 0.988200
R2356 n1_M2_47580_18420 n1_M2_48660_18420 0.988200
R2357 n1_M2_48660_18420 n1_M2_49740_18420 0.988200
R2358 n1_M2_49740_18420 n1_M2_50820_18420 0.988200
R2359 n1_M2_50820_18420 n1_M2_51900_18420 0.988200
R2360 n1_M2_51900_18420 n1_M2_52980_18420 0.988200
R2361 n1_M2_52980_18420 n1_M2_54060_18420 0.988200
R2362 n1_M2_54060_18420 n1_M2_55140_18420 0.988200
R2363 n1_M2_55140_18420 n1_M2_56220_18420 0.988200
R2364 n1_M2_56220_18420 n1_M2_57300_18420 0.988200
R2365 n1_M2_57300_18420 n1_M2_58380_18420 0.988200
R2366 n1_M2_58380_18420 n1_M2_59460_18420 0.988200
R2367 n1_M2_59460_18420 n1_M2_60540_18420 0.988200
R2368 n1_M2_60540_18420 n1_M2_61620_18420 0.988200
R2369 n1_M2_61620_18420 n1_M2_62700_18420 0.988200
R2370 n1_M2_62700_18420 n1_M2_63780_18420 0.988200
R2371 n1_M2_63780_18420 n1_M2_64860_18420 0.988200
R2372 n1_M2_64860_18420 n1_M2_65940_18420 0.988200
R2373 n1_M2_65940_18420 n1_M2_67020_18420 0.988200
R2374 n1_M2_67020_18420 n1_M2_68100_18420 0.988200
R2375 n1_M2_68100_18420 n1_M2_69180_18420 0.988200
R2376 n1_M2_69180_18420 n1_M2_70260_18420 0.988200
R2377 n1_M2_70260_18420 n1_M2_71340_18420 0.988200
R2378 n1_M2_71340_18420 n1_M2_72420_18420 0.988200
R2379 n1_M2_72420_18420 n1_M2_73500_18420 0.988200
R2380 n1_M2_73500_18420 n1_M2_74580_18420 0.988200
R2381 n1_M2_74580_18420 n1_M2_75660_18420 0.988200
R2382 n1_M2_75660_18420 n1_M2_76740_18420 0.988200
R2383 n1_M2_76740_18420 n1_M2_77820_18420 0.988200
R2384 n1_M2_77820_18420 n1_M2_78900_18420 0.988200
R2385 n1_M2_78900_18420 n1_M2_79980_18420 0.988200
R2386 n1_M2_79980_18420 n1_M2_81060_18420 0.988200
R2387 n1_M2_81060_18420 n1_M2_82140_18420 0.988200
R2388 n1_M2_82140_18420 n1_M2_83220_18420 0.988200
R2389 n1_M2_83220_18420 n1_M2_84300_18420 0.988200
R2390 n1_M2_84300_18420 n1_M2_85380_18420 0.988200
R2391 n1_M2_85380_18420 n1_M2_86460_18420 0.988200
R2392 n1_M2_86460_18420 n1_M2_87540_18420 0.988200
R2393 n1_M2_87540_18420 n1_M2_88620_18420 0.988200
R2394 n1_M2_88620_18420 n1_M2_89700_18420 0.988200
R2395 n1_M2_89700_18420 n1_M2_90780_18420 0.988200
R2396 n1_M2_90780_18420 n1_M2_91860_18420 0.988200
R2397 n1_M2_91860_18420 n1_M2_92940_18420 0.988200
R2398 n1_M2_92940_18420 n1_M2_94020_18420 0.988200
R2399 n1_M2_94020_18420 n1_M2_95100_18420 0.988200
R2400 n1_M2_95100_18420 n1_M2_96180_18420 0.988200
R2401 n1_M2_96180_18420 n1_M2_97260_18420 0.988200
R2402 n1_M2_97260_18420 n1_M2_98340_18420 0.988200
R2403 n1_M2_98340_18420 n1_M2_99420_18420 0.988200
R2404 n1_M2_99420_18420 n1_M2_100500_18420 0.988200
R2405 n1_M2_100500_18420 n1_M2_101580_18420 0.988200
R2406 n1_M2_101580_18420 n1_M2_102660_18420 0.988200
R2407 n1_M2_102660_18420 n1_M2_103740_18420 0.988200
R2408 n1_M2_103740_18420 n1_M2_104820_18420 0.988200
R2409 n1_M2_104820_18420 n1_M2_105900_18420 0.988200
R2410 n1_M2_105900_18420 n1_M2_106980_18420 0.988200
R2411 n1_M2_106980_18420 n1_M2_108060_18420 0.988200
R2412 n1_M2_108060_18420 n1_M2_109140_18420 0.988200
R2413 n1_M2_109140_18420 n1_M2_110220_18420 0.988200
R2414 n1_M2_110220_18420 n1_M2_111300_18420 0.988200
R2415 n1_M2_111300_18420 n1_M2_112380_18420 0.988200
R2416 n1_M2_112380_18420 n1_M2_113460_18420 0.988200
R2417 n1_M2_113460_18420 n1_M2_114540_18420 0.988200
R2418 n1_M2_114540_18420 n1_M2_115620_18420 0.988200
R2419 n1_M2_115620_18420 n1_M2_116700_18420 0.988200
R2420 n1_M2_116700_18420 n1_M2_117780_18420 0.988200
R2421 n1_M2_117780_18420 n1_M2_118860_18420 0.988200
R2422 n1_M2_118860_18420 n1_M2_119940_18420 0.988200
R2423 n1_M2_119940_18420 n1_M2_121020_18420 0.988200
R2424 n1_M2_121020_18420 n1_M2_122100_18420 0.988200
R2425 n1_M2_122100_18420 n1_M2_123180_18420 0.988200
R2426 n1_M2_123180_18420 n1_M2_124260_18420 0.988200
R2427 n1_M2_124260_18420 n1_M2_125340_18420 0.988200
R2428 n1_M2_125340_18420 n1_M2_126420_18420 0.988200
R2429 n1_M2_126420_18420 n1_M2_127500_18420 0.988200
R2430 n1_M2_127500_18420 n1_M2_128580_18420 0.988200
R2431 n1_M2_128580_18420 n1_M2_129660_18420 0.988200
R2432 n1_M2_129660_18420 n1_M2_130740_18420 0.988200
R2433 n1_M2_130740_18420 n1_M2_131820_18420 0.988200
R2434 n1_M2_131820_18420 n1_M2_132900_18420 0.988200
R2435 n1_M2_132900_18420 n1_M2_133980_18420 0.988200
R2436 n1_M2_133980_18420 n1_M2_135060_18420 0.988200
R2437 n1_M2_135060_18420 n1_M2_136140_18420 0.988200
R2438 n1_M2_136140_18420 n1_M2_137220_18420 0.988200
R2439 n1_M2_137220_18420 n1_M2_138300_18420 0.988200
R2440 n1_M2_138300_18420 n1_M2_139380_18420 0.988200
R2441 n1_M2_139380_18420 n1_M2_140460_18420 0.988200
R2442 n1_M2_140460_18420 n1_M2_141540_18420 0.988200
R2443 n1_M2_141540_18420 n1_M2_142620_18420 0.988200
R2444 n1_M2_142620_18420 n1_M2_143700_18420 0.988200
R2445 n1_M2_143700_18420 n1_M2_144780_18420 0.988200
R2446 n1_M2_144780_18420 n1_M2_145860_18420 0.988200
R2447 n1_M2_145860_18420 n1_M2_146940_18420 0.988200
R2448 n1_M2_60_19500 n1_M2_1140_19500 0.988200
R2449 n1_M2_1140_19500 n1_M2_2220_19500 0.988200
R2450 n1_M2_2220_19500 n1_M2_3300_19500 0.988200
R2451 n1_M2_3300_19500 n1_M2_4380_19500 0.988200
R2452 n1_M2_4380_19500 n1_M2_5460_19500 0.988200
R2453 n1_M2_5460_19500 n1_M2_6540_19500 0.988200
R2454 n1_M2_6540_19500 n1_M2_7620_19500 0.988200
R2455 n1_M2_7620_19500 n1_M2_8700_19500 0.988200
R2456 n1_M2_8700_19500 n1_M2_9780_19500 0.988200
R2457 n1_M2_9780_19500 n1_M2_10860_19500 0.988200
R2458 n1_M2_10860_19500 n1_M2_11940_19500 0.988200
R2459 n1_M2_11940_19500 n1_M2_13020_19500 0.988200
R2460 n1_M2_13020_19500 n1_M2_14100_19500 0.988200
R2461 n1_M2_14100_19500 n1_M2_15180_19500 0.988200
R2462 n1_M2_15180_19500 n1_M2_16260_19500 0.988200
R2463 n1_M2_16260_19500 n1_M2_17340_19500 0.988200
R2464 n1_M2_17340_19500 n1_M2_18420_19500 0.988200
R2465 n1_M2_18420_19500 n1_M2_19500_19500 0.988200
R2466 n1_M2_19500_19500 n1_M2_20580_19500 0.988200
R2467 n1_M2_20580_19500 n1_M2_21660_19500 0.988200
R2468 n1_M2_21660_19500 n1_M2_22740_19500 0.988200
R2469 n1_M2_22740_19500 n1_M2_23820_19500 0.988200
R2470 n1_M2_23820_19500 n1_M2_24900_19500 0.988200
R2471 n1_M2_24900_19500 n1_M2_25980_19500 0.988200
R2472 n1_M2_25980_19500 n1_M2_27060_19500 0.988200
R2473 n1_M2_27060_19500 n1_M2_28140_19500 0.988200
R2474 n1_M2_28140_19500 n1_M2_29220_19500 0.988200
R2475 n1_M2_29220_19500 n1_M2_30300_19500 0.988200
R2476 n1_M2_30300_19500 n1_M2_31380_19500 0.988200
R2477 n1_M2_31380_19500 n1_M2_32460_19500 0.988200
R2478 n1_M2_32460_19500 n1_M2_33540_19500 0.988200
R2479 n1_M2_33540_19500 n1_M2_34620_19500 0.988200
R2480 n1_M2_34620_19500 n1_M2_35700_19500 0.988200
R2481 n1_M2_35700_19500 n1_M2_36780_19500 0.988200
R2482 n1_M2_36780_19500 n1_M2_37860_19500 0.988200
R2483 n1_M2_37860_19500 n1_M2_38940_19500 0.988200
R2484 n1_M2_38940_19500 n1_M2_40020_19500 0.988200
R2485 n1_M2_40020_19500 n1_M2_41100_19500 0.988200
R2486 n1_M2_41100_19500 n1_M2_42180_19500 0.988200
R2487 n1_M2_42180_19500 n1_M2_43260_19500 0.988200
R2488 n1_M2_43260_19500 n1_M2_44340_19500 0.988200
R2489 n1_M2_44340_19500 n1_M2_45420_19500 0.988200
R2490 n1_M2_45420_19500 n1_M2_46500_19500 0.988200
R2491 n1_M2_46500_19500 n1_M2_47580_19500 0.988200
R2492 n1_M2_47580_19500 n1_M2_48660_19500 0.988200
R2493 n1_M2_48660_19500 n1_M2_49740_19500 0.988200
R2494 n1_M2_49740_19500 n1_M2_50820_19500 0.988200
R2495 n1_M2_50820_19500 n1_M2_51900_19500 0.988200
R2496 n1_M2_51900_19500 n1_M2_52980_19500 0.988200
R2497 n1_M2_52980_19500 n1_M2_54060_19500 0.988200
R2498 n1_M2_54060_19500 n1_M2_55140_19500 0.988200
R2499 n1_M2_55140_19500 n1_M2_56220_19500 0.988200
R2500 n1_M2_56220_19500 n1_M2_57300_19500 0.988200
R2501 n1_M2_57300_19500 n1_M2_58380_19500 0.988200
R2502 n1_M2_58380_19500 n1_M2_59460_19500 0.988200
R2503 n1_M2_59460_19500 n1_M2_60540_19500 0.988200
R2504 n1_M2_60540_19500 n1_M2_61620_19500 0.988200
R2505 n1_M2_61620_19500 n1_M2_62700_19500 0.988200
R2506 n1_M2_62700_19500 n1_M2_63780_19500 0.988200
R2507 n1_M2_63780_19500 n1_M2_64860_19500 0.988200
R2508 n1_M2_64860_19500 n1_M2_65940_19500 0.988200
R2509 n1_M2_65940_19500 n1_M2_67020_19500 0.988200
R2510 n1_M2_67020_19500 n1_M2_68100_19500 0.988200
R2511 n1_M2_68100_19500 n1_M2_69180_19500 0.988200
R2512 n1_M2_69180_19500 n1_M2_70260_19500 0.988200
R2513 n1_M2_70260_19500 n1_M2_71340_19500 0.988200
R2514 n1_M2_71340_19500 n1_M2_72420_19500 0.988200
R2515 n1_M2_72420_19500 n1_M2_73500_19500 0.988200
R2516 n1_M2_73500_19500 n1_M2_74580_19500 0.988200
R2517 n1_M2_74580_19500 n1_M2_75660_19500 0.988200
R2518 n1_M2_75660_19500 n1_M2_76740_19500 0.988200
R2519 n1_M2_76740_19500 n1_M2_77820_19500 0.988200
R2520 n1_M2_77820_19500 n1_M2_78900_19500 0.988200
R2521 n1_M2_78900_19500 n1_M2_79980_19500 0.988200
R2522 n1_M2_79980_19500 n1_M2_81060_19500 0.988200
R2523 n1_M2_81060_19500 n1_M2_82140_19500 0.988200
R2524 n1_M2_82140_19500 n1_M2_83220_19500 0.988200
R2525 n1_M2_83220_19500 n1_M2_84300_19500 0.988200
R2526 n1_M2_84300_19500 n1_M2_85380_19500 0.988200
R2527 n1_M2_85380_19500 n1_M2_86460_19500 0.988200
R2528 n1_M2_86460_19500 n1_M2_87540_19500 0.988200
R2529 n1_M2_87540_19500 n1_M2_88620_19500 0.988200
R2530 n1_M2_88620_19500 n1_M2_89700_19500 0.988200
R2531 n1_M2_89700_19500 n1_M2_90780_19500 0.988200
R2532 n1_M2_90780_19500 n1_M2_91860_19500 0.988200
R2533 n1_M2_91860_19500 n1_M2_92940_19500 0.988200
R2534 n1_M2_92940_19500 n1_M2_94020_19500 0.988200
R2535 n1_M2_94020_19500 n1_M2_95100_19500 0.988200
R2536 n1_M2_95100_19500 n1_M2_96180_19500 0.988200
R2537 n1_M2_96180_19500 n1_M2_97260_19500 0.988200
R2538 n1_M2_97260_19500 n1_M2_98340_19500 0.988200
R2539 n1_M2_98340_19500 n1_M2_99420_19500 0.988200
R2540 n1_M2_99420_19500 n1_M2_100500_19500 0.988200
R2541 n1_M2_100500_19500 n1_M2_101580_19500 0.988200
R2542 n1_M2_101580_19500 n1_M2_102660_19500 0.988200
R2543 n1_M2_102660_19500 n1_M2_103740_19500 0.988200
R2544 n1_M2_103740_19500 n1_M2_104820_19500 0.988200
R2545 n1_M2_104820_19500 n1_M2_105900_19500 0.988200
R2546 n1_M2_105900_19500 n1_M2_106980_19500 0.988200
R2547 n1_M2_106980_19500 n1_M2_108060_19500 0.988200
R2548 n1_M2_108060_19500 n1_M2_109140_19500 0.988200
R2549 n1_M2_109140_19500 n1_M2_110220_19500 0.988200
R2550 n1_M2_110220_19500 n1_M2_111300_19500 0.988200
R2551 n1_M2_111300_19500 n1_M2_112380_19500 0.988200
R2552 n1_M2_112380_19500 n1_M2_113460_19500 0.988200
R2553 n1_M2_113460_19500 n1_M2_114540_19500 0.988200
R2554 n1_M2_114540_19500 n1_M2_115620_19500 0.988200
R2555 n1_M2_115620_19500 n1_M2_116700_19500 0.988200
R2556 n1_M2_116700_19500 n1_M2_117780_19500 0.988200
R2557 n1_M2_117780_19500 n1_M2_118860_19500 0.988200
R2558 n1_M2_118860_19500 n1_M2_119940_19500 0.988200
R2559 n1_M2_119940_19500 n1_M2_121020_19500 0.988200
R2560 n1_M2_121020_19500 n1_M2_122100_19500 0.988200
R2561 n1_M2_122100_19500 n1_M2_123180_19500 0.988200
R2562 n1_M2_123180_19500 n1_M2_124260_19500 0.988200
R2563 n1_M2_124260_19500 n1_M2_125340_19500 0.988200
R2564 n1_M2_125340_19500 n1_M2_126420_19500 0.988200
R2565 n1_M2_126420_19500 n1_M2_127500_19500 0.988200
R2566 n1_M2_127500_19500 n1_M2_128580_19500 0.988200
R2567 n1_M2_128580_19500 n1_M2_129660_19500 0.988200
R2568 n1_M2_129660_19500 n1_M2_130740_19500 0.988200
R2569 n1_M2_130740_19500 n1_M2_131820_19500 0.988200
R2570 n1_M2_131820_19500 n1_M2_132900_19500 0.988200
R2571 n1_M2_132900_19500 n1_M2_133980_19500 0.988200
R2572 n1_M2_133980_19500 n1_M2_135060_19500 0.988200
R2573 n1_M2_135060_19500 n1_M2_136140_19500 0.988200
R2574 n1_M2_136140_19500 n1_M2_137220_19500 0.988200
R2575 n1_M2_137220_19500 n1_M2_138300_19500 0.988200
R2576 n1_M2_138300_19500 n1_M2_139380_19500 0.988200
R2577 n1_M2_139380_19500 n1_M2_140460_19500 0.988200
R2578 n1_M2_140460_19500 n1_M2_141540_19500 0.988200
R2579 n1_M2_141540_19500 n1_M2_142620_19500 0.988200
R2580 n1_M2_142620_19500 n1_M2_143700_19500 0.988200
R2581 n1_M2_143700_19500 n1_M2_144780_19500 0.988200
R2582 n1_M2_144780_19500 n1_M2_145860_19500 0.988200
R2583 n1_M2_145860_19500 n1_M2_146940_19500 0.988200
R2584 n1_M2_60_20580 n1_M2_1140_20580 0.988200
R2585 n1_M2_1140_20580 n1_M2_2220_20580 0.988200
R2586 n1_M2_2220_20580 n1_M2_3300_20580 0.988200
R2587 n1_M2_3300_20580 n1_M2_4380_20580 0.988200
R2588 n1_M2_4380_20580 n1_M2_5460_20580 0.988200
R2589 n1_M2_5460_20580 n1_M2_6540_20580 0.988200
R2590 n1_M2_6540_20580 n1_M2_7620_20580 0.988200
R2591 n1_M2_7620_20580 n1_M2_8700_20580 0.988200
R2592 n1_M2_8700_20580 n1_M2_9780_20580 0.988200
R2593 n1_M2_9780_20580 n1_M2_10860_20580 0.988200
R2594 n1_M2_10860_20580 n1_M2_11940_20580 0.988200
R2595 n1_M2_11940_20580 n1_M2_13020_20580 0.988200
R2596 n1_M2_13020_20580 n1_M2_14100_20580 0.988200
R2597 n1_M2_14100_20580 n1_M2_15180_20580 0.988200
R2598 n1_M2_15180_20580 n1_M2_16260_20580 0.988200
R2599 n1_M2_16260_20580 n1_M2_17340_20580 0.988200
R2600 n1_M2_17340_20580 n1_M2_18420_20580 0.988200
R2601 n1_M2_18420_20580 n1_M2_19500_20580 0.988200
R2602 n1_M2_19500_20580 n1_M2_20580_20580 0.988200
R2603 n1_M2_20580_20580 n1_M2_21660_20580 0.988200
R2604 n1_M2_21660_20580 n1_M2_22740_20580 0.988200
R2605 n1_M2_22740_20580 n1_M2_23820_20580 0.988200
R2606 n1_M2_23820_20580 n1_M2_24900_20580 0.988200
R2607 n1_M2_24900_20580 n1_M2_25980_20580 0.988200
R2608 n1_M2_25980_20580 n1_M2_27060_20580 0.988200
R2609 n1_M2_27060_20580 n1_M2_28140_20580 0.988200
R2610 n1_M2_28140_20580 n1_M2_29220_20580 0.988200
R2611 n1_M2_29220_20580 n1_M2_30300_20580 0.988200
R2612 n1_M2_30300_20580 n1_M2_31380_20580 0.988200
R2613 n1_M2_31380_20580 n1_M2_32460_20580 0.988200
R2614 n1_M2_32460_20580 n1_M2_33540_20580 0.988200
R2615 n1_M2_33540_20580 n1_M2_34620_20580 0.988200
R2616 n1_M2_34620_20580 n1_M2_35700_20580 0.988200
R2617 n1_M2_35700_20580 n1_M2_36780_20580 0.988200
R2618 n1_M2_36780_20580 n1_M2_37860_20580 0.988200
R2619 n1_M2_37860_20580 n1_M2_38940_20580 0.988200
R2620 n1_M2_38940_20580 n1_M2_40020_20580 0.988200
R2621 n1_M2_40020_20580 n1_M2_41100_20580 0.988200
R2622 n1_M2_41100_20580 n1_M2_42180_20580 0.988200
R2623 n1_M2_42180_20580 n1_M2_43260_20580 0.988200
R2624 n1_M2_43260_20580 n1_M2_44340_20580 0.988200
R2625 n1_M2_44340_20580 n1_M2_45420_20580 0.988200
R2626 n1_M2_45420_20580 n1_M2_46500_20580 0.988200
R2627 n1_M2_46500_20580 n1_M2_47580_20580 0.988200
R2628 n1_M2_47580_20580 n1_M2_48660_20580 0.988200
R2629 n1_M2_48660_20580 n1_M2_49740_20580 0.988200
R2630 n1_M2_49740_20580 n1_M2_50820_20580 0.988200
R2631 n1_M2_50820_20580 n1_M2_51900_20580 0.988200
R2632 n1_M2_51900_20580 n1_M2_52980_20580 0.988200
R2633 n1_M2_52980_20580 n1_M2_54060_20580 0.988200
R2634 n1_M2_54060_20580 n1_M2_55140_20580 0.988200
R2635 n1_M2_55140_20580 n1_M2_56220_20580 0.988200
R2636 n1_M2_56220_20580 n1_M2_57300_20580 0.988200
R2637 n1_M2_57300_20580 n1_M2_58380_20580 0.988200
R2638 n1_M2_58380_20580 n1_M2_59460_20580 0.988200
R2639 n1_M2_59460_20580 n1_M2_60540_20580 0.988200
R2640 n1_M2_60540_20580 n1_M2_61620_20580 0.988200
R2641 n1_M2_61620_20580 n1_M2_62700_20580 0.988200
R2642 n1_M2_62700_20580 n1_M2_63780_20580 0.988200
R2643 n1_M2_63780_20580 n1_M2_64860_20580 0.988200
R2644 n1_M2_64860_20580 n1_M2_65940_20580 0.988200
R2645 n1_M2_65940_20580 n1_M2_67020_20580 0.988200
R2646 n1_M2_67020_20580 n1_M2_68100_20580 0.988200
R2647 n1_M2_68100_20580 n1_M2_69180_20580 0.988200
R2648 n1_M2_69180_20580 n1_M2_70260_20580 0.988200
R2649 n1_M2_70260_20580 n1_M2_71340_20580 0.988200
R2650 n1_M2_71340_20580 n1_M2_72420_20580 0.988200
R2651 n1_M2_72420_20580 n1_M2_73500_20580 0.988200
R2652 n1_M2_73500_20580 n1_M2_74580_20580 0.988200
R2653 n1_M2_74580_20580 n1_M2_75660_20580 0.988200
R2654 n1_M2_75660_20580 n1_M2_76740_20580 0.988200
R2655 n1_M2_76740_20580 n1_M2_77820_20580 0.988200
R2656 n1_M2_77820_20580 n1_M2_78900_20580 0.988200
R2657 n1_M2_78900_20580 n1_M2_79980_20580 0.988200
R2658 n1_M2_79980_20580 n1_M2_81060_20580 0.988200
R2659 n1_M2_81060_20580 n1_M2_82140_20580 0.988200
R2660 n1_M2_82140_20580 n1_M2_83220_20580 0.988200
R2661 n1_M2_83220_20580 n1_M2_84300_20580 0.988200
R2662 n1_M2_84300_20580 n1_M2_85380_20580 0.988200
R2663 n1_M2_85380_20580 n1_M2_86460_20580 0.988200
R2664 n1_M2_86460_20580 n1_M2_87540_20580 0.988200
R2665 n1_M2_87540_20580 n1_M2_88620_20580 0.988200
R2666 n1_M2_88620_20580 n1_M2_89700_20580 0.988200
R2667 n1_M2_89700_20580 n1_M2_90780_20580 0.988200
R2668 n1_M2_90780_20580 n1_M2_91860_20580 0.988200
R2669 n1_M2_91860_20580 n1_M2_92940_20580 0.988200
R2670 n1_M2_92940_20580 n1_M2_94020_20580 0.988200
R2671 n1_M2_94020_20580 n1_M2_95100_20580 0.988200
R2672 n1_M2_95100_20580 n1_M2_96180_20580 0.988200
R2673 n1_M2_96180_20580 n1_M2_97260_20580 0.988200
R2674 n1_M2_97260_20580 n1_M2_98340_20580 0.988200
R2675 n1_M2_98340_20580 n1_M2_99420_20580 0.988200
R2676 n1_M2_99420_20580 n1_M2_100500_20580 0.988200
R2677 n1_M2_100500_20580 n1_M2_101580_20580 0.988200
R2678 n1_M2_101580_20580 n1_M2_102660_20580 0.988200
R2679 n1_M2_102660_20580 n1_M2_103740_20580 0.988200
R2680 n1_M2_103740_20580 n1_M2_104820_20580 0.988200
R2681 n1_M2_104820_20580 n1_M2_105900_20580 0.988200
R2682 n1_M2_105900_20580 n1_M2_106980_20580 0.988200
R2683 n1_M2_106980_20580 n1_M2_108060_20580 0.988200
R2684 n1_M2_108060_20580 n1_M2_109140_20580 0.988200
R2685 n1_M2_109140_20580 n1_M2_110220_20580 0.988200
R2686 n1_M2_110220_20580 n1_M2_111300_20580 0.988200
R2687 n1_M2_111300_20580 n1_M2_112380_20580 0.988200
R2688 n1_M2_112380_20580 n1_M2_113460_20580 0.988200
R2689 n1_M2_113460_20580 n1_M2_114540_20580 0.988200
R2690 n1_M2_114540_20580 n1_M2_115620_20580 0.988200
R2691 n1_M2_115620_20580 n1_M2_116700_20580 0.988200
R2692 n1_M2_116700_20580 n1_M2_117780_20580 0.988200
R2693 n1_M2_117780_20580 n1_M2_118860_20580 0.988200
R2694 n1_M2_118860_20580 n1_M2_119940_20580 0.988200
R2695 n1_M2_119940_20580 n1_M2_121020_20580 0.988200
R2696 n1_M2_121020_20580 n1_M2_122100_20580 0.988200
R2697 n1_M2_122100_20580 n1_M2_123180_20580 0.988200
R2698 n1_M2_123180_20580 n1_M2_124260_20580 0.988200
R2699 n1_M2_124260_20580 n1_M2_125340_20580 0.988200
R2700 n1_M2_125340_20580 n1_M2_126420_20580 0.988200
R2701 n1_M2_126420_20580 n1_M2_127500_20580 0.988200
R2702 n1_M2_127500_20580 n1_M2_128580_20580 0.988200
R2703 n1_M2_128580_20580 n1_M2_129660_20580 0.988200
R2704 n1_M2_129660_20580 n1_M2_130740_20580 0.988200
R2705 n1_M2_130740_20580 n1_M2_131820_20580 0.988200
R2706 n1_M2_131820_20580 n1_M2_132900_20580 0.988200
R2707 n1_M2_132900_20580 n1_M2_133980_20580 0.988200
R2708 n1_M2_133980_20580 n1_M2_135060_20580 0.988200
R2709 n1_M2_135060_20580 n1_M2_136140_20580 0.988200
R2710 n1_M2_136140_20580 n1_M2_137220_20580 0.988200
R2711 n1_M2_137220_20580 n1_M2_138300_20580 0.988200
R2712 n1_M2_138300_20580 n1_M2_139380_20580 0.988200
R2713 n1_M2_139380_20580 n1_M2_140460_20580 0.988200
R2714 n1_M2_140460_20580 n1_M2_141540_20580 0.988200
R2715 n1_M2_141540_20580 n1_M2_142620_20580 0.988200
R2716 n1_M2_142620_20580 n1_M2_143700_20580 0.988200
R2717 n1_M2_143700_20580 n1_M2_144780_20580 0.988200
R2718 n1_M2_144780_20580 n1_M2_145860_20580 0.988200
R2719 n1_M2_145860_20580 n1_M2_146940_20580 0.988200
R2720 n1_M2_60_21660 n1_M2_1140_21660 0.988200
R2721 n1_M2_1140_21660 n1_M2_2220_21660 0.988200
R2722 n1_M2_2220_21660 n1_M2_3300_21660 0.988200
R2723 n1_M2_3300_21660 n1_M2_4380_21660 0.988200
R2724 n1_M2_4380_21660 n1_M2_5460_21660 0.988200
R2725 n1_M2_5460_21660 n1_M2_6540_21660 0.988200
R2726 n1_M2_6540_21660 n1_M2_7620_21660 0.988200
R2727 n1_M2_7620_21660 n1_M2_8700_21660 0.988200
R2728 n1_M2_8700_21660 n1_M2_9780_21660 0.988200
R2729 n1_M2_9780_21660 n1_M2_10860_21660 0.988200
R2730 n1_M2_10860_21660 n1_M2_11940_21660 0.988200
R2731 n1_M2_11940_21660 n1_M2_13020_21660 0.988200
R2732 n1_M2_13020_21660 n1_M2_14100_21660 0.988200
R2733 n1_M2_14100_21660 n1_M2_15180_21660 0.988200
R2734 n1_M2_15180_21660 n1_M2_16260_21660 0.988200
R2735 n1_M2_16260_21660 n1_M2_17340_21660 0.988200
R2736 n1_M2_17340_21660 n1_M2_18420_21660 0.988200
R2737 n1_M2_18420_21660 n1_M2_19500_21660 0.988200
R2738 n1_M2_19500_21660 n1_M2_20580_21660 0.988200
R2739 n1_M2_20580_21660 n1_M2_21660_21660 0.988200
R2740 n1_M2_21660_21660 n1_M2_22740_21660 0.988200
R2741 n1_M2_22740_21660 n1_M2_23820_21660 0.988200
R2742 n1_M2_23820_21660 n1_M2_24900_21660 0.988200
R2743 n1_M2_24900_21660 n1_M2_25980_21660 0.988200
R2744 n1_M2_25980_21660 n1_M2_27060_21660 0.988200
R2745 n1_M2_27060_21660 n1_M2_28140_21660 0.988200
R2746 n1_M2_28140_21660 n1_M2_29220_21660 0.988200
R2747 n1_M2_29220_21660 n1_M2_30300_21660 0.988200
R2748 n1_M2_30300_21660 n1_M2_31380_21660 0.988200
R2749 n1_M2_31380_21660 n1_M2_32460_21660 0.988200
R2750 n1_M2_32460_21660 n1_M2_33540_21660 0.988200
R2751 n1_M2_33540_21660 n1_M2_34620_21660 0.988200
R2752 n1_M2_34620_21660 n1_M2_35700_21660 0.988200
R2753 n1_M2_35700_21660 n1_M2_36780_21660 0.988200
R2754 n1_M2_36780_21660 n1_M2_37860_21660 0.988200
R2755 n1_M2_37860_21660 n1_M2_38940_21660 0.988200
R2756 n1_M2_38940_21660 n1_M2_40020_21660 0.988200
R2757 n1_M2_40020_21660 n1_M2_41100_21660 0.988200
R2758 n1_M2_41100_21660 n1_M2_42180_21660 0.988200
R2759 n1_M2_42180_21660 n1_M2_43260_21660 0.988200
R2760 n1_M2_43260_21660 n1_M2_44340_21660 0.988200
R2761 n1_M2_44340_21660 n1_M2_45420_21660 0.988200
R2762 n1_M2_45420_21660 n1_M2_46500_21660 0.988200
R2763 n1_M2_46500_21660 n1_M2_47580_21660 0.988200
R2764 n1_M2_47580_21660 n1_M2_48660_21660 0.988200
R2765 n1_M2_48660_21660 n1_M2_49740_21660 0.988200
R2766 n1_M2_49740_21660 n1_M2_50820_21660 0.988200
R2767 n1_M2_50820_21660 n1_M2_51900_21660 0.988200
R2768 n1_M2_51900_21660 n1_M2_52980_21660 0.988200
R2769 n1_M2_52980_21660 n1_M2_54060_21660 0.988200
R2770 n1_M2_54060_21660 n1_M2_55140_21660 0.988200
R2771 n1_M2_55140_21660 n1_M2_56220_21660 0.988200
R2772 n1_M2_56220_21660 n1_M2_57300_21660 0.988200
R2773 n1_M2_57300_21660 n1_M2_58380_21660 0.988200
R2774 n1_M2_58380_21660 n1_M2_59460_21660 0.988200
R2775 n1_M2_59460_21660 n1_M2_60540_21660 0.988200
R2776 n1_M2_60540_21660 n1_M2_61620_21660 0.988200
R2777 n1_M2_61620_21660 n1_M2_62700_21660 0.988200
R2778 n1_M2_62700_21660 n1_M2_63780_21660 0.988200
R2779 n1_M2_63780_21660 n1_M2_64860_21660 0.988200
R2780 n1_M2_64860_21660 n1_M2_65940_21660 0.988200
R2781 n1_M2_65940_21660 n1_M2_67020_21660 0.988200
R2782 n1_M2_67020_21660 n1_M2_68100_21660 0.988200
R2783 n1_M2_68100_21660 n1_M2_69180_21660 0.988200
R2784 n1_M2_69180_21660 n1_M2_70260_21660 0.988200
R2785 n1_M2_70260_21660 n1_M2_71340_21660 0.988200
R2786 n1_M2_71340_21660 n1_M2_72420_21660 0.988200
R2787 n1_M2_72420_21660 n1_M2_73500_21660 0.988200
R2788 n1_M2_73500_21660 n1_M2_74580_21660 0.988200
R2789 n1_M2_74580_21660 n1_M2_75660_21660 0.988200
R2790 n1_M2_75660_21660 n1_M2_76740_21660 0.988200
R2791 n1_M2_76740_21660 n1_M2_77820_21660 0.988200
R2792 n1_M2_77820_21660 n1_M2_78900_21660 0.988200
R2793 n1_M2_78900_21660 n1_M2_79980_21660 0.988200
R2794 n1_M2_79980_21660 n1_M2_81060_21660 0.988200
R2795 n1_M2_81060_21660 n1_M2_82140_21660 0.988200
R2796 n1_M2_82140_21660 n1_M2_83220_21660 0.988200
R2797 n1_M2_83220_21660 n1_M2_84300_21660 0.988200
R2798 n1_M2_84300_21660 n1_M2_85380_21660 0.988200
R2799 n1_M2_85380_21660 n1_M2_86460_21660 0.988200
R2800 n1_M2_86460_21660 n1_M2_87540_21660 0.988200
R2801 n1_M2_87540_21660 n1_M2_88620_21660 0.988200
R2802 n1_M2_88620_21660 n1_M2_89700_21660 0.988200
R2803 n1_M2_89700_21660 n1_M2_90780_21660 0.988200
R2804 n1_M2_90780_21660 n1_M2_91860_21660 0.988200
R2805 n1_M2_91860_21660 n1_M2_92940_21660 0.988200
R2806 n1_M2_92940_21660 n1_M2_94020_21660 0.988200
R2807 n1_M2_94020_21660 n1_M2_95100_21660 0.988200
R2808 n1_M2_95100_21660 n1_M2_96180_21660 0.988200
R2809 n1_M2_96180_21660 n1_M2_97260_21660 0.988200
R2810 n1_M2_97260_21660 n1_M2_98340_21660 0.988200
R2811 n1_M2_98340_21660 n1_M2_99420_21660 0.988200
R2812 n1_M2_99420_21660 n1_M2_100500_21660 0.988200
R2813 n1_M2_100500_21660 n1_M2_101580_21660 0.988200
R2814 n1_M2_101580_21660 n1_M2_102660_21660 0.988200
R2815 n1_M2_102660_21660 n1_M2_103740_21660 0.988200
R2816 n1_M2_103740_21660 n1_M2_104820_21660 0.988200
R2817 n1_M2_104820_21660 n1_M2_105900_21660 0.988200
R2818 n1_M2_105900_21660 n1_M2_106980_21660 0.988200
R2819 n1_M2_106980_21660 n1_M2_108060_21660 0.988200
R2820 n1_M2_108060_21660 n1_M2_109140_21660 0.988200
R2821 n1_M2_109140_21660 n1_M2_110220_21660 0.988200
R2822 n1_M2_110220_21660 n1_M2_111300_21660 0.988200
R2823 n1_M2_111300_21660 n1_M2_112380_21660 0.988200
R2824 n1_M2_112380_21660 n1_M2_113460_21660 0.988200
R2825 n1_M2_113460_21660 n1_M2_114540_21660 0.988200
R2826 n1_M2_114540_21660 n1_M2_115620_21660 0.988200
R2827 n1_M2_115620_21660 n1_M2_116700_21660 0.988200
R2828 n1_M2_116700_21660 n1_M2_117780_21660 0.988200
R2829 n1_M2_117780_21660 n1_M2_118860_21660 0.988200
R2830 n1_M2_118860_21660 n1_M2_119940_21660 0.988200
R2831 n1_M2_119940_21660 n1_M2_121020_21660 0.988200
R2832 n1_M2_121020_21660 n1_M2_122100_21660 0.988200
R2833 n1_M2_122100_21660 n1_M2_123180_21660 0.988200
R2834 n1_M2_123180_21660 n1_M2_124260_21660 0.988200
R2835 n1_M2_124260_21660 n1_M2_125340_21660 0.988200
R2836 n1_M2_125340_21660 n1_M2_126420_21660 0.988200
R2837 n1_M2_126420_21660 n1_M2_127500_21660 0.988200
R2838 n1_M2_127500_21660 n1_M2_128580_21660 0.988200
R2839 n1_M2_128580_21660 n1_M2_129660_21660 0.988200
R2840 n1_M2_129660_21660 n1_M2_130740_21660 0.988200
R2841 n1_M2_130740_21660 n1_M2_131820_21660 0.988200
R2842 n1_M2_131820_21660 n1_M2_132900_21660 0.988200
R2843 n1_M2_132900_21660 n1_M2_133980_21660 0.988200
R2844 n1_M2_133980_21660 n1_M2_135060_21660 0.988200
R2845 n1_M2_135060_21660 n1_M2_136140_21660 0.988200
R2846 n1_M2_136140_21660 n1_M2_137220_21660 0.988200
R2847 n1_M2_137220_21660 n1_M2_138300_21660 0.988200
R2848 n1_M2_138300_21660 n1_M2_139380_21660 0.988200
R2849 n1_M2_139380_21660 n1_M2_140460_21660 0.988200
R2850 n1_M2_140460_21660 n1_M2_141540_21660 0.988200
R2851 n1_M2_141540_21660 n1_M2_142620_21660 0.988200
R2852 n1_M2_142620_21660 n1_M2_143700_21660 0.988200
R2853 n1_M2_143700_21660 n1_M2_144780_21660 0.988200
R2854 n1_M2_144780_21660 n1_M2_145860_21660 0.988200
R2855 n1_M2_145860_21660 n1_M2_146940_21660 0.988200
R2856 n1_M2_60_22740 n1_M2_1140_22740 0.988200
R2857 n1_M2_1140_22740 n1_M2_2220_22740 0.988200
R2858 n1_M2_2220_22740 n1_M2_3300_22740 0.988200
R2859 n1_M2_3300_22740 n1_M2_4380_22740 0.988200
R2860 n1_M2_4380_22740 n1_M2_5460_22740 0.988200
R2861 n1_M2_5460_22740 n1_M2_6540_22740 0.988200
R2862 n1_M2_6540_22740 n1_M2_7620_22740 0.988200
R2863 n1_M2_7620_22740 n1_M2_8700_22740 0.988200
R2864 n1_M2_8700_22740 n1_M2_9780_22740 0.988200
R2865 n1_M2_9780_22740 n1_M2_10860_22740 0.988200
R2866 n1_M2_10860_22740 n1_M2_11940_22740 0.988200
R2867 n1_M2_11940_22740 n1_M2_13020_22740 0.988200
R2868 n1_M2_13020_22740 n1_M2_14100_22740 0.988200
R2869 n1_M2_14100_22740 n1_M2_15180_22740 0.988200
R2870 n1_M2_15180_22740 n1_M2_16260_22740 0.988200
R2871 n1_M2_16260_22740 n1_M2_17340_22740 0.988200
R2872 n1_M2_17340_22740 n1_M2_18420_22740 0.988200
R2873 n1_M2_18420_22740 n1_M2_19500_22740 0.988200
R2874 n1_M2_19500_22740 n1_M2_20580_22740 0.988200
R2875 n1_M2_20580_22740 n1_M2_21660_22740 0.988200
R2876 n1_M2_21660_22740 n1_M2_22740_22740 0.988200
R2877 n1_M2_22740_22740 n1_M2_23820_22740 0.988200
R2878 n1_M2_23820_22740 n1_M2_24900_22740 0.988200
R2879 n1_M2_24900_22740 n1_M2_25980_22740 0.988200
R2880 n1_M2_25980_22740 n1_M2_27060_22740 0.988200
R2881 n1_M2_27060_22740 n1_M2_28140_22740 0.988200
R2882 n1_M2_28140_22740 n1_M2_29220_22740 0.988200
R2883 n1_M2_29220_22740 n1_M2_30300_22740 0.988200
R2884 n1_M2_30300_22740 n1_M2_31380_22740 0.988200
R2885 n1_M2_31380_22740 n1_M2_32460_22740 0.988200
R2886 n1_M2_32460_22740 n1_M2_33540_22740 0.988200
R2887 n1_M2_33540_22740 n1_M2_34620_22740 0.988200
R2888 n1_M2_34620_22740 n1_M2_35700_22740 0.988200
R2889 n1_M2_35700_22740 n1_M2_36780_22740 0.988200
R2890 n1_M2_36780_22740 n1_M2_37860_22740 0.988200
R2891 n1_M2_37860_22740 n1_M2_38940_22740 0.988200
R2892 n1_M2_38940_22740 n1_M2_40020_22740 0.988200
R2893 n1_M2_40020_22740 n1_M2_41100_22740 0.988200
R2894 n1_M2_41100_22740 n1_M2_42180_22740 0.988200
R2895 n1_M2_42180_22740 n1_M2_43260_22740 0.988200
R2896 n1_M2_43260_22740 n1_M2_44340_22740 0.988200
R2897 n1_M2_44340_22740 n1_M2_45420_22740 0.988200
R2898 n1_M2_45420_22740 n1_M2_46500_22740 0.988200
R2899 n1_M2_46500_22740 n1_M2_47580_22740 0.988200
R2900 n1_M2_47580_22740 n1_M2_48660_22740 0.988200
R2901 n1_M2_48660_22740 n1_M2_49740_22740 0.988200
R2902 n1_M2_49740_22740 n1_M2_50820_22740 0.988200
R2903 n1_M2_50820_22740 n1_M2_51900_22740 0.988200
R2904 n1_M2_51900_22740 n1_M2_52980_22740 0.988200
R2905 n1_M2_52980_22740 n1_M2_54060_22740 0.988200
R2906 n1_M2_54060_22740 n1_M2_55140_22740 0.988200
R2907 n1_M2_55140_22740 n1_M2_56220_22740 0.988200
R2908 n1_M2_56220_22740 n1_M2_57300_22740 0.988200
R2909 n1_M2_57300_22740 n1_M2_58380_22740 0.988200
R2910 n1_M2_58380_22740 n1_M2_59460_22740 0.988200
R2911 n1_M2_59460_22740 n1_M2_60540_22740 0.988200
R2912 n1_M2_60540_22740 n1_M2_61620_22740 0.988200
R2913 n1_M2_61620_22740 n1_M2_62700_22740 0.988200
R2914 n1_M2_62700_22740 n1_M2_63780_22740 0.988200
R2915 n1_M2_63780_22740 n1_M2_64860_22740 0.988200
R2916 n1_M2_64860_22740 n1_M2_65940_22740 0.988200
R2917 n1_M2_65940_22740 n1_M2_67020_22740 0.988200
R2918 n1_M2_67020_22740 n1_M2_68100_22740 0.988200
R2919 n1_M2_68100_22740 n1_M2_69180_22740 0.988200
R2920 n1_M2_69180_22740 n1_M2_70260_22740 0.988200
R2921 n1_M2_70260_22740 n1_M2_71340_22740 0.988200
R2922 n1_M2_71340_22740 n1_M2_72420_22740 0.988200
R2923 n1_M2_72420_22740 n1_M2_73500_22740 0.988200
R2924 n1_M2_73500_22740 n1_M2_74580_22740 0.988200
R2925 n1_M2_74580_22740 n1_M2_75660_22740 0.988200
R2926 n1_M2_75660_22740 n1_M2_76740_22740 0.988200
R2927 n1_M2_76740_22740 n1_M2_77820_22740 0.988200
R2928 n1_M2_77820_22740 n1_M2_78900_22740 0.988200
R2929 n1_M2_78900_22740 n1_M2_79980_22740 0.988200
R2930 n1_M2_79980_22740 n1_M2_81060_22740 0.988200
R2931 n1_M2_81060_22740 n1_M2_82140_22740 0.988200
R2932 n1_M2_82140_22740 n1_M2_83220_22740 0.988200
R2933 n1_M2_83220_22740 n1_M2_84300_22740 0.988200
R2934 n1_M2_84300_22740 n1_M2_85380_22740 0.988200
R2935 n1_M2_85380_22740 n1_M2_86460_22740 0.988200
R2936 n1_M2_86460_22740 n1_M2_87540_22740 0.988200
R2937 n1_M2_87540_22740 n1_M2_88620_22740 0.988200
R2938 n1_M2_88620_22740 n1_M2_89700_22740 0.988200
R2939 n1_M2_89700_22740 n1_M2_90780_22740 0.988200
R2940 n1_M2_90780_22740 n1_M2_91860_22740 0.988200
R2941 n1_M2_91860_22740 n1_M2_92940_22740 0.988200
R2942 n1_M2_92940_22740 n1_M2_94020_22740 0.988200
R2943 n1_M2_94020_22740 n1_M2_95100_22740 0.988200
R2944 n1_M2_95100_22740 n1_M2_96180_22740 0.988200
R2945 n1_M2_96180_22740 n1_M2_97260_22740 0.988200
R2946 n1_M2_97260_22740 n1_M2_98340_22740 0.988200
R2947 n1_M2_98340_22740 n1_M2_99420_22740 0.988200
R2948 n1_M2_99420_22740 n1_M2_100500_22740 0.988200
R2949 n1_M2_100500_22740 n1_M2_101580_22740 0.988200
R2950 n1_M2_101580_22740 n1_M2_102660_22740 0.988200
R2951 n1_M2_102660_22740 n1_M2_103740_22740 0.988200
R2952 n1_M2_103740_22740 n1_M2_104820_22740 0.988200
R2953 n1_M2_104820_22740 n1_M2_105900_22740 0.988200
R2954 n1_M2_105900_22740 n1_M2_106980_22740 0.988200
R2955 n1_M2_106980_22740 n1_M2_108060_22740 0.988200
R2956 n1_M2_108060_22740 n1_M2_109140_22740 0.988200
R2957 n1_M2_109140_22740 n1_M2_110220_22740 0.988200
R2958 n1_M2_110220_22740 n1_M2_111300_22740 0.988200
R2959 n1_M2_111300_22740 n1_M2_112380_22740 0.988200
R2960 n1_M2_112380_22740 n1_M2_113460_22740 0.988200
R2961 n1_M2_113460_22740 n1_M2_114540_22740 0.988200
R2962 n1_M2_114540_22740 n1_M2_115620_22740 0.988200
R2963 n1_M2_115620_22740 n1_M2_116700_22740 0.988200
R2964 n1_M2_116700_22740 n1_M2_117780_22740 0.988200
R2965 n1_M2_117780_22740 n1_M2_118860_22740 0.988200
R2966 n1_M2_118860_22740 n1_M2_119940_22740 0.988200
R2967 n1_M2_119940_22740 n1_M2_121020_22740 0.988200
R2968 n1_M2_121020_22740 n1_M2_122100_22740 0.988200
R2969 n1_M2_122100_22740 n1_M2_123180_22740 0.988200
R2970 n1_M2_123180_22740 n1_M2_124260_22740 0.988200
R2971 n1_M2_124260_22740 n1_M2_125340_22740 0.988200
R2972 n1_M2_125340_22740 n1_M2_126420_22740 0.988200
R2973 n1_M2_126420_22740 n1_M2_127500_22740 0.988200
R2974 n1_M2_127500_22740 n1_M2_128580_22740 0.988200
R2975 n1_M2_128580_22740 n1_M2_129660_22740 0.988200
R2976 n1_M2_129660_22740 n1_M2_130740_22740 0.988200
R2977 n1_M2_130740_22740 n1_M2_131820_22740 0.988200
R2978 n1_M2_131820_22740 n1_M2_132900_22740 0.988200
R2979 n1_M2_132900_22740 n1_M2_133980_22740 0.988200
R2980 n1_M2_133980_22740 n1_M2_135060_22740 0.988200
R2981 n1_M2_135060_22740 n1_M2_136140_22740 0.988200
R2982 n1_M2_136140_22740 n1_M2_137220_22740 0.988200
R2983 n1_M2_137220_22740 n1_M2_138300_22740 0.988200
R2984 n1_M2_138300_22740 n1_M2_139380_22740 0.988200
R2985 n1_M2_139380_22740 n1_M2_140460_22740 0.988200
R2986 n1_M2_140460_22740 n1_M2_141540_22740 0.988200
R2987 n1_M2_141540_22740 n1_M2_142620_22740 0.988200
R2988 n1_M2_142620_22740 n1_M2_143700_22740 0.988200
R2989 n1_M2_143700_22740 n1_M2_144780_22740 0.988200
R2990 n1_M2_144780_22740 n1_M2_145860_22740 0.988200
R2991 n1_M2_145860_22740 n1_M2_146940_22740 0.988200
R2992 n1_M2_60_23820 n1_M2_1140_23820 0.988200
R2993 n1_M2_1140_23820 n1_M2_2220_23820 0.988200
R2994 n1_M2_2220_23820 n1_M2_3300_23820 0.988200
R2995 n1_M2_3300_23820 n1_M2_4380_23820 0.988200
R2996 n1_M2_4380_23820 n1_M2_5460_23820 0.988200
R2997 n1_M2_5460_23820 n1_M2_6540_23820 0.988200
R2998 n1_M2_6540_23820 n1_M2_7620_23820 0.988200
R2999 n1_M2_7620_23820 n1_M2_8700_23820 0.988200
R3000 n1_M2_8700_23820 n1_M2_9780_23820 0.988200
R3001 n1_M2_9780_23820 n1_M2_10860_23820 0.988200
R3002 n1_M2_10860_23820 n1_M2_11940_23820 0.988200
R3003 n1_M2_11940_23820 n1_M2_13020_23820 0.988200
R3004 n1_M2_13020_23820 n1_M2_14100_23820 0.988200
R3005 n1_M2_14100_23820 n1_M2_15180_23820 0.988200
R3006 n1_M2_15180_23820 n1_M2_16260_23820 0.988200
R3007 n1_M2_16260_23820 n1_M2_17340_23820 0.988200
R3008 n1_M2_17340_23820 n1_M2_18420_23820 0.988200
R3009 n1_M2_18420_23820 n1_M2_19500_23820 0.988200
R3010 n1_M2_19500_23820 n1_M2_20580_23820 0.988200
R3011 n1_M2_20580_23820 n1_M2_21660_23820 0.988200
R3012 n1_M2_21660_23820 n1_M2_22740_23820 0.988200
R3013 n1_M2_22740_23820 n1_M2_23820_23820 0.988200
R3014 n1_M2_23820_23820 n1_M2_24900_23820 0.988200
R3015 n1_M2_24900_23820 n1_M2_25980_23820 0.988200
R3016 n1_M2_25980_23820 n1_M2_27060_23820 0.988200
R3017 n1_M2_27060_23820 n1_M2_28140_23820 0.988200
R3018 n1_M2_28140_23820 n1_M2_29220_23820 0.988200
R3019 n1_M2_29220_23820 n1_M2_30300_23820 0.988200
R3020 n1_M2_30300_23820 n1_M2_31380_23820 0.988200
R3021 n1_M2_31380_23820 n1_M2_32460_23820 0.988200
R3022 n1_M2_32460_23820 n1_M2_33540_23820 0.988200
R3023 n1_M2_33540_23820 n1_M2_34620_23820 0.988200
R3024 n1_M2_34620_23820 n1_M2_35700_23820 0.988200
R3025 n1_M2_35700_23820 n1_M2_36780_23820 0.988200
R3026 n1_M2_36780_23820 n1_M2_37860_23820 0.988200
R3027 n1_M2_37860_23820 n1_M2_38940_23820 0.988200
R3028 n1_M2_38940_23820 n1_M2_40020_23820 0.988200
R3029 n1_M2_40020_23820 n1_M2_41100_23820 0.988200
R3030 n1_M2_41100_23820 n1_M2_42180_23820 0.988200
R3031 n1_M2_42180_23820 n1_M2_43260_23820 0.988200
R3032 n1_M2_43260_23820 n1_M2_44340_23820 0.988200
R3033 n1_M2_44340_23820 n1_M2_45420_23820 0.988200
R3034 n1_M2_45420_23820 n1_M2_46500_23820 0.988200
R3035 n1_M2_46500_23820 n1_M2_47580_23820 0.988200
R3036 n1_M2_47580_23820 n1_M2_48660_23820 0.988200
R3037 n1_M2_48660_23820 n1_M2_49740_23820 0.988200
R3038 n1_M2_49740_23820 n1_M2_50820_23820 0.988200
R3039 n1_M2_50820_23820 n1_M2_51900_23820 0.988200
R3040 n1_M2_51900_23820 n1_M2_52980_23820 0.988200
R3041 n1_M2_52980_23820 n1_M2_54060_23820 0.988200
R3042 n1_M2_54060_23820 n1_M2_55140_23820 0.988200
R3043 n1_M2_55140_23820 n1_M2_56220_23820 0.988200
R3044 n1_M2_56220_23820 n1_M2_57300_23820 0.988200
R3045 n1_M2_57300_23820 n1_M2_58380_23820 0.988200
R3046 n1_M2_58380_23820 n1_M2_59460_23820 0.988200
R3047 n1_M2_59460_23820 n1_M2_60540_23820 0.988200
R3048 n1_M2_60540_23820 n1_M2_61620_23820 0.988200
R3049 n1_M2_61620_23820 n1_M2_62700_23820 0.988200
R3050 n1_M2_62700_23820 n1_M2_63780_23820 0.988200
R3051 n1_M2_63780_23820 n1_M2_64860_23820 0.988200
R3052 n1_M2_64860_23820 n1_M2_65940_23820 0.988200
R3053 n1_M2_65940_23820 n1_M2_67020_23820 0.988200
R3054 n1_M2_67020_23820 n1_M2_68100_23820 0.988200
R3055 n1_M2_68100_23820 n1_M2_69180_23820 0.988200
R3056 n1_M2_69180_23820 n1_M2_70260_23820 0.988200
R3057 n1_M2_70260_23820 n1_M2_71340_23820 0.988200
R3058 n1_M2_71340_23820 n1_M2_72420_23820 0.988200
R3059 n1_M2_72420_23820 n1_M2_73500_23820 0.988200
R3060 n1_M2_73500_23820 n1_M2_74580_23820 0.988200
R3061 n1_M2_74580_23820 n1_M2_75660_23820 0.988200
R3062 n1_M2_75660_23820 n1_M2_76740_23820 0.988200
R3063 n1_M2_76740_23820 n1_M2_77820_23820 0.988200
R3064 n1_M2_77820_23820 n1_M2_78900_23820 0.988200
R3065 n1_M2_78900_23820 n1_M2_79980_23820 0.988200
R3066 n1_M2_79980_23820 n1_M2_81060_23820 0.988200
R3067 n1_M2_81060_23820 n1_M2_82140_23820 0.988200
R3068 n1_M2_82140_23820 n1_M2_83220_23820 0.988200
R3069 n1_M2_83220_23820 n1_M2_84300_23820 0.988200
R3070 n1_M2_84300_23820 n1_M2_85380_23820 0.988200
R3071 n1_M2_85380_23820 n1_M2_86460_23820 0.988200
R3072 n1_M2_86460_23820 n1_M2_87540_23820 0.988200
R3073 n1_M2_87540_23820 n1_M2_88620_23820 0.988200
R3074 n1_M2_88620_23820 n1_M2_89700_23820 0.988200
R3075 n1_M2_89700_23820 n1_M2_90780_23820 0.988200
R3076 n1_M2_90780_23820 n1_M2_91860_23820 0.988200
R3077 n1_M2_91860_23820 n1_M2_92940_23820 0.988200
R3078 n1_M2_92940_23820 n1_M2_94020_23820 0.988200
R3079 n1_M2_94020_23820 n1_M2_95100_23820 0.988200
R3080 n1_M2_95100_23820 n1_M2_96180_23820 0.988200
R3081 n1_M2_96180_23820 n1_M2_97260_23820 0.988200
R3082 n1_M2_97260_23820 n1_M2_98340_23820 0.988200
R3083 n1_M2_98340_23820 n1_M2_99420_23820 0.988200
R3084 n1_M2_99420_23820 n1_M2_100500_23820 0.988200
R3085 n1_M2_100500_23820 n1_M2_101580_23820 0.988200
R3086 n1_M2_101580_23820 n1_M2_102660_23820 0.988200
R3087 n1_M2_102660_23820 n1_M2_103740_23820 0.988200
R3088 n1_M2_103740_23820 n1_M2_104820_23820 0.988200
R3089 n1_M2_104820_23820 n1_M2_105900_23820 0.988200
R3090 n1_M2_105900_23820 n1_M2_106980_23820 0.988200
R3091 n1_M2_106980_23820 n1_M2_108060_23820 0.988200
R3092 n1_M2_108060_23820 n1_M2_109140_23820 0.988200
R3093 n1_M2_109140_23820 n1_M2_110220_23820 0.988200
R3094 n1_M2_110220_23820 n1_M2_111300_23820 0.988200
R3095 n1_M2_111300_23820 n1_M2_112380_23820 0.988200
R3096 n1_M2_112380_23820 n1_M2_113460_23820 0.988200
R3097 n1_M2_113460_23820 n1_M2_114540_23820 0.988200
R3098 n1_M2_114540_23820 n1_M2_115620_23820 0.988200
R3099 n1_M2_115620_23820 n1_M2_116700_23820 0.988200
R3100 n1_M2_116700_23820 n1_M2_117780_23820 0.988200
R3101 n1_M2_117780_23820 n1_M2_118860_23820 0.988200
R3102 n1_M2_118860_23820 n1_M2_119940_23820 0.988200
R3103 n1_M2_119940_23820 n1_M2_121020_23820 0.988200
R3104 n1_M2_121020_23820 n1_M2_122100_23820 0.988200
R3105 n1_M2_122100_23820 n1_M2_123180_23820 0.988200
R3106 n1_M2_123180_23820 n1_M2_124260_23820 0.988200
R3107 n1_M2_124260_23820 n1_M2_125340_23820 0.988200
R3108 n1_M2_125340_23820 n1_M2_126420_23820 0.988200
R3109 n1_M2_126420_23820 n1_M2_127500_23820 0.988200
R3110 n1_M2_127500_23820 n1_M2_128580_23820 0.988200
R3111 n1_M2_128580_23820 n1_M2_129660_23820 0.988200
R3112 n1_M2_129660_23820 n1_M2_130740_23820 0.988200
R3113 n1_M2_130740_23820 n1_M2_131820_23820 0.988200
R3114 n1_M2_131820_23820 n1_M2_132900_23820 0.988200
R3115 n1_M2_132900_23820 n1_M2_133980_23820 0.988200
R3116 n1_M2_133980_23820 n1_M2_135060_23820 0.988200
R3117 n1_M2_135060_23820 n1_M2_136140_23820 0.988200
R3118 n1_M2_136140_23820 n1_M2_137220_23820 0.988200
R3119 n1_M2_137220_23820 n1_M2_138300_23820 0.988200
R3120 n1_M2_138300_23820 n1_M2_139380_23820 0.988200
R3121 n1_M2_139380_23820 n1_M2_140460_23820 0.988200
R3122 n1_M2_140460_23820 n1_M2_141540_23820 0.988200
R3123 n1_M2_141540_23820 n1_M2_142620_23820 0.988200
R3124 n1_M2_142620_23820 n1_M2_143700_23820 0.988200
R3125 n1_M2_143700_23820 n1_M2_144780_23820 0.988200
R3126 n1_M2_144780_23820 n1_M2_145860_23820 0.988200
R3127 n1_M2_145860_23820 n1_M2_146940_23820 0.988200
R3128 n1_M2_60_24900 n1_M2_1140_24900 0.988200
R3129 n1_M2_1140_24900 n1_M2_2220_24900 0.988200
R3130 n1_M2_2220_24900 n1_M2_3300_24900 0.988200
R3131 n1_M2_3300_24900 n1_M2_4380_24900 0.988200
R3132 n1_M2_4380_24900 n1_M2_5460_24900 0.988200
R3133 n1_M2_5460_24900 n1_M2_6540_24900 0.988200
R3134 n1_M2_6540_24900 n1_M2_7620_24900 0.988200
R3135 n1_M2_7620_24900 n1_M2_8700_24900 0.988200
R3136 n1_M2_8700_24900 n1_M2_9780_24900 0.988200
R3137 n1_M2_9780_24900 n1_M2_10860_24900 0.988200
R3138 n1_M2_10860_24900 n1_M2_11940_24900 0.988200
R3139 n1_M2_11940_24900 n1_M2_13020_24900 0.988200
R3140 n1_M2_13020_24900 n1_M2_14100_24900 0.988200
R3141 n1_M2_14100_24900 n1_M2_15180_24900 0.988200
R3142 n1_M2_15180_24900 n1_M2_16260_24900 0.988200
R3143 n1_M2_16260_24900 n1_M2_17340_24900 0.988200
R3144 n1_M2_17340_24900 n1_M2_18420_24900 0.988200
R3145 n1_M2_18420_24900 n1_M2_19500_24900 0.988200
R3146 n1_M2_19500_24900 n1_M2_20580_24900 0.988200
R3147 n1_M2_20580_24900 n1_M2_21660_24900 0.988200
R3148 n1_M2_21660_24900 n1_M2_22740_24900 0.988200
R3149 n1_M2_22740_24900 n1_M2_23820_24900 0.988200
R3150 n1_M2_23820_24900 n1_M2_24900_24900 0.988200
R3151 n1_M2_24900_24900 n1_M2_25980_24900 0.988200
R3152 n1_M2_25980_24900 n1_M2_27060_24900 0.988200
R3153 n1_M2_27060_24900 n1_M2_28140_24900 0.988200
R3154 n1_M2_28140_24900 n1_M2_29220_24900 0.988200
R3155 n1_M2_29220_24900 n1_M2_30300_24900 0.988200
R3156 n1_M2_30300_24900 n1_M2_31380_24900 0.988200
R3157 n1_M2_31380_24900 n1_M2_32460_24900 0.988200
R3158 n1_M2_32460_24900 n1_M2_33540_24900 0.988200
R3159 n1_M2_33540_24900 n1_M2_34620_24900 0.988200
R3160 n1_M2_34620_24900 n1_M2_35700_24900 0.988200
R3161 n1_M2_35700_24900 n1_M2_36780_24900 0.988200
R3162 n1_M2_36780_24900 n1_M2_37860_24900 0.988200
R3163 n1_M2_37860_24900 n1_M2_38940_24900 0.988200
R3164 n1_M2_38940_24900 n1_M2_40020_24900 0.988200
R3165 n1_M2_40020_24900 n1_M2_41100_24900 0.988200
R3166 n1_M2_41100_24900 n1_M2_42180_24900 0.988200
R3167 n1_M2_42180_24900 n1_M2_43260_24900 0.988200
R3168 n1_M2_43260_24900 n1_M2_44340_24900 0.988200
R3169 n1_M2_44340_24900 n1_M2_45420_24900 0.988200
R3170 n1_M2_45420_24900 n1_M2_46500_24900 0.988200
R3171 n1_M2_46500_24900 n1_M2_47580_24900 0.988200
R3172 n1_M2_47580_24900 n1_M2_48660_24900 0.988200
R3173 n1_M2_48660_24900 n1_M2_49740_24900 0.988200
R3174 n1_M2_49740_24900 n1_M2_50820_24900 0.988200
R3175 n1_M2_50820_24900 n1_M2_51900_24900 0.988200
R3176 n1_M2_51900_24900 n1_M2_52980_24900 0.988200
R3177 n1_M2_52980_24900 n1_M2_54060_24900 0.988200
R3178 n1_M2_54060_24900 n1_M2_55140_24900 0.988200
R3179 n1_M2_55140_24900 n1_M2_56220_24900 0.988200
R3180 n1_M2_56220_24900 n1_M2_57300_24900 0.988200
R3181 n1_M2_57300_24900 n1_M2_58380_24900 0.988200
R3182 n1_M2_58380_24900 n1_M2_59460_24900 0.988200
R3183 n1_M2_59460_24900 n1_M2_60540_24900 0.988200
R3184 n1_M2_60540_24900 n1_M2_61620_24900 0.988200
R3185 n1_M2_61620_24900 n1_M2_62700_24900 0.988200
R3186 n1_M2_62700_24900 n1_M2_63780_24900 0.988200
R3187 n1_M2_63780_24900 n1_M2_64860_24900 0.988200
R3188 n1_M2_64860_24900 n1_M2_65940_24900 0.988200
R3189 n1_M2_65940_24900 n1_M2_67020_24900 0.988200
R3190 n1_M2_67020_24900 n1_M2_68100_24900 0.988200
R3191 n1_M2_68100_24900 n1_M2_69180_24900 0.988200
R3192 n1_M2_69180_24900 n1_M2_70260_24900 0.988200
R3193 n1_M2_70260_24900 n1_M2_71340_24900 0.988200
R3194 n1_M2_71340_24900 n1_M2_72420_24900 0.988200
R3195 n1_M2_72420_24900 n1_M2_73500_24900 0.988200
R3196 n1_M2_73500_24900 n1_M2_74580_24900 0.988200
R3197 n1_M2_74580_24900 n1_M2_75660_24900 0.988200
R3198 n1_M2_75660_24900 n1_M2_76740_24900 0.988200
R3199 n1_M2_76740_24900 n1_M2_77820_24900 0.988200
R3200 n1_M2_77820_24900 n1_M2_78900_24900 0.988200
R3201 n1_M2_78900_24900 n1_M2_79980_24900 0.988200
R3202 n1_M2_79980_24900 n1_M2_81060_24900 0.988200
R3203 n1_M2_81060_24900 n1_M2_82140_24900 0.988200
R3204 n1_M2_82140_24900 n1_M2_83220_24900 0.988200
R3205 n1_M2_83220_24900 n1_M2_84300_24900 0.988200
R3206 n1_M2_84300_24900 n1_M2_85380_24900 0.988200
R3207 n1_M2_85380_24900 n1_M2_86460_24900 0.988200
R3208 n1_M2_86460_24900 n1_M2_87540_24900 0.988200
R3209 n1_M2_87540_24900 n1_M2_88620_24900 0.988200
R3210 n1_M2_88620_24900 n1_M2_89700_24900 0.988200
R3211 n1_M2_89700_24900 n1_M2_90780_24900 0.988200
R3212 n1_M2_90780_24900 n1_M2_91860_24900 0.988200
R3213 n1_M2_91860_24900 n1_M2_92940_24900 0.988200
R3214 n1_M2_92940_24900 n1_M2_94020_24900 0.988200
R3215 n1_M2_94020_24900 n1_M2_95100_24900 0.988200
R3216 n1_M2_95100_24900 n1_M2_96180_24900 0.988200
R3217 n1_M2_96180_24900 n1_M2_97260_24900 0.988200
R3218 n1_M2_97260_24900 n1_M2_98340_24900 0.988200
R3219 n1_M2_98340_24900 n1_M2_99420_24900 0.988200
R3220 n1_M2_99420_24900 n1_M2_100500_24900 0.988200
R3221 n1_M2_100500_24900 n1_M2_101580_24900 0.988200
R3222 n1_M2_101580_24900 n1_M2_102660_24900 0.988200
R3223 n1_M2_102660_24900 n1_M2_103740_24900 0.988200
R3224 n1_M2_103740_24900 n1_M2_104820_24900 0.988200
R3225 n1_M2_104820_24900 n1_M2_105900_24900 0.988200
R3226 n1_M2_105900_24900 n1_M2_106980_24900 0.988200
R3227 n1_M2_106980_24900 n1_M2_108060_24900 0.988200
R3228 n1_M2_108060_24900 n1_M2_109140_24900 0.988200
R3229 n1_M2_109140_24900 n1_M2_110220_24900 0.988200
R3230 n1_M2_110220_24900 n1_M2_111300_24900 0.988200
R3231 n1_M2_111300_24900 n1_M2_112380_24900 0.988200
R3232 n1_M2_112380_24900 n1_M2_113460_24900 0.988200
R3233 n1_M2_113460_24900 n1_M2_114540_24900 0.988200
R3234 n1_M2_114540_24900 n1_M2_115620_24900 0.988200
R3235 n1_M2_115620_24900 n1_M2_116700_24900 0.988200
R3236 n1_M2_116700_24900 n1_M2_117780_24900 0.988200
R3237 n1_M2_117780_24900 n1_M2_118860_24900 0.988200
R3238 n1_M2_118860_24900 n1_M2_119940_24900 0.988200
R3239 n1_M2_119940_24900 n1_M2_121020_24900 0.988200
R3240 n1_M2_121020_24900 n1_M2_122100_24900 0.988200
R3241 n1_M2_122100_24900 n1_M2_123180_24900 0.988200
R3242 n1_M2_123180_24900 n1_M2_124260_24900 0.988200
R3243 n1_M2_124260_24900 n1_M2_125340_24900 0.988200
R3244 n1_M2_125340_24900 n1_M2_126420_24900 0.988200
R3245 n1_M2_126420_24900 n1_M2_127500_24900 0.988200
R3246 n1_M2_127500_24900 n1_M2_128580_24900 0.988200
R3247 n1_M2_128580_24900 n1_M2_129660_24900 0.988200
R3248 n1_M2_129660_24900 n1_M2_130740_24900 0.988200
R3249 n1_M2_130740_24900 n1_M2_131820_24900 0.988200
R3250 n1_M2_131820_24900 n1_M2_132900_24900 0.988200
R3251 n1_M2_132900_24900 n1_M2_133980_24900 0.988200
R3252 n1_M2_133980_24900 n1_M2_135060_24900 0.988200
R3253 n1_M2_135060_24900 n1_M2_136140_24900 0.988200
R3254 n1_M2_136140_24900 n1_M2_137220_24900 0.988200
R3255 n1_M2_137220_24900 n1_M2_138300_24900 0.988200
R3256 n1_M2_138300_24900 n1_M2_139380_24900 0.988200
R3257 n1_M2_139380_24900 n1_M2_140460_24900 0.988200
R3258 n1_M2_140460_24900 n1_M2_141540_24900 0.988200
R3259 n1_M2_141540_24900 n1_M2_142620_24900 0.988200
R3260 n1_M2_142620_24900 n1_M2_143700_24900 0.988200
R3261 n1_M2_143700_24900 n1_M2_144780_24900 0.988200
R3262 n1_M2_144780_24900 n1_M2_145860_24900 0.988200
R3263 n1_M2_145860_24900 n1_M2_146940_24900 0.988200
R3264 n1_M2_60_25980 n1_M2_1140_25980 0.988200
R3265 n1_M2_1140_25980 n1_M2_2220_25980 0.988200
R3266 n1_M2_2220_25980 n1_M2_3300_25980 0.988200
R3267 n1_M2_3300_25980 n1_M2_4380_25980 0.988200
R3268 n1_M2_4380_25980 n1_M2_5460_25980 0.988200
R3269 n1_M2_5460_25980 n1_M2_6540_25980 0.988200
R3270 n1_M2_6540_25980 n1_M2_7620_25980 0.988200
R3271 n1_M2_7620_25980 n1_M2_8700_25980 0.988200
R3272 n1_M2_8700_25980 n1_M2_9780_25980 0.988200
R3273 n1_M2_9780_25980 n1_M2_10860_25980 0.988200
R3274 n1_M2_10860_25980 n1_M2_11940_25980 0.988200
R3275 n1_M2_11940_25980 n1_M2_13020_25980 0.988200
R3276 n1_M2_13020_25980 n1_M2_14100_25980 0.988200
R3277 n1_M2_14100_25980 n1_M2_15180_25980 0.988200
R3278 n1_M2_15180_25980 n1_M2_16260_25980 0.988200
R3279 n1_M2_16260_25980 n1_M2_17340_25980 0.988200
R3280 n1_M2_17340_25980 n1_M2_18420_25980 0.988200
R3281 n1_M2_18420_25980 n1_M2_19500_25980 0.988200
R3282 n1_M2_19500_25980 n1_M2_20580_25980 0.988200
R3283 n1_M2_20580_25980 n1_M2_21660_25980 0.988200
R3284 n1_M2_21660_25980 n1_M2_22740_25980 0.988200
R3285 n1_M2_22740_25980 n1_M2_23820_25980 0.988200
R3286 n1_M2_23820_25980 n1_M2_24900_25980 0.988200
R3287 n1_M2_24900_25980 n1_M2_25980_25980 0.988200
R3288 n1_M2_25980_25980 n1_M2_27060_25980 0.988200
R3289 n1_M2_27060_25980 n1_M2_28140_25980 0.988200
R3290 n1_M2_28140_25980 n1_M2_29220_25980 0.988200
R3291 n1_M2_29220_25980 n1_M2_30300_25980 0.988200
R3292 n1_M2_30300_25980 n1_M2_31380_25980 0.988200
R3293 n1_M2_31380_25980 n1_M2_32460_25980 0.988200
R3294 n1_M2_32460_25980 n1_M2_33540_25980 0.988200
R3295 n1_M2_33540_25980 n1_M2_34620_25980 0.988200
R3296 n1_M2_34620_25980 n1_M2_35700_25980 0.988200
R3297 n1_M2_35700_25980 n1_M2_36780_25980 0.988200
R3298 n1_M2_36780_25980 n1_M2_37860_25980 0.988200
R3299 n1_M2_37860_25980 n1_M2_38940_25980 0.988200
R3300 n1_M2_38940_25980 n1_M2_40020_25980 0.988200
R3301 n1_M2_40020_25980 n1_M2_41100_25980 0.988200
R3302 n1_M2_41100_25980 n1_M2_42180_25980 0.988200
R3303 n1_M2_42180_25980 n1_M2_43260_25980 0.988200
R3304 n1_M2_43260_25980 n1_M2_44340_25980 0.988200
R3305 n1_M2_44340_25980 n1_M2_45420_25980 0.988200
R3306 n1_M2_45420_25980 n1_M2_46500_25980 0.988200
R3307 n1_M2_46500_25980 n1_M2_47580_25980 0.988200
R3308 n1_M2_47580_25980 n1_M2_48660_25980 0.988200
R3309 n1_M2_48660_25980 n1_M2_49740_25980 0.988200
R3310 n1_M2_49740_25980 n1_M2_50820_25980 0.988200
R3311 n1_M2_50820_25980 n1_M2_51900_25980 0.988200
R3312 n1_M2_51900_25980 n1_M2_52980_25980 0.988200
R3313 n1_M2_52980_25980 n1_M2_54060_25980 0.988200
R3314 n1_M2_54060_25980 n1_M2_55140_25980 0.988200
R3315 n1_M2_55140_25980 n1_M2_56220_25980 0.988200
R3316 n1_M2_56220_25980 n1_M2_57300_25980 0.988200
R3317 n1_M2_57300_25980 n1_M2_58380_25980 0.988200
R3318 n1_M2_58380_25980 n1_M2_59460_25980 0.988200
R3319 n1_M2_59460_25980 n1_M2_60540_25980 0.988200
R3320 n1_M2_60540_25980 n1_M2_61620_25980 0.988200
R3321 n1_M2_61620_25980 n1_M2_62700_25980 0.988200
R3322 n1_M2_62700_25980 n1_M2_63780_25980 0.988200
R3323 n1_M2_63780_25980 n1_M2_64860_25980 0.988200
R3324 n1_M2_64860_25980 n1_M2_65940_25980 0.988200
R3325 n1_M2_65940_25980 n1_M2_67020_25980 0.988200
R3326 n1_M2_67020_25980 n1_M2_68100_25980 0.988200
R3327 n1_M2_68100_25980 n1_M2_69180_25980 0.988200
R3328 n1_M2_69180_25980 n1_M2_70260_25980 0.988200
R3329 n1_M2_70260_25980 n1_M2_71340_25980 0.988200
R3330 n1_M2_71340_25980 n1_M2_72420_25980 0.988200
R3331 n1_M2_72420_25980 n1_M2_73500_25980 0.988200
R3332 n1_M2_73500_25980 n1_M2_74580_25980 0.988200
R3333 n1_M2_74580_25980 n1_M2_75660_25980 0.988200
R3334 n1_M2_75660_25980 n1_M2_76740_25980 0.988200
R3335 n1_M2_76740_25980 n1_M2_77820_25980 0.988200
R3336 n1_M2_77820_25980 n1_M2_78900_25980 0.988200
R3337 n1_M2_78900_25980 n1_M2_79980_25980 0.988200
R3338 n1_M2_79980_25980 n1_M2_81060_25980 0.988200
R3339 n1_M2_81060_25980 n1_M2_82140_25980 0.988200
R3340 n1_M2_82140_25980 n1_M2_83220_25980 0.988200
R3341 n1_M2_83220_25980 n1_M2_84300_25980 0.988200
R3342 n1_M2_84300_25980 n1_M2_85380_25980 0.988200
R3343 n1_M2_85380_25980 n1_M2_86460_25980 0.988200
R3344 n1_M2_86460_25980 n1_M2_87540_25980 0.988200
R3345 n1_M2_87540_25980 n1_M2_88620_25980 0.988200
R3346 n1_M2_88620_25980 n1_M2_89700_25980 0.988200
R3347 n1_M2_89700_25980 n1_M2_90780_25980 0.988200
R3348 n1_M2_90780_25980 n1_M2_91860_25980 0.988200
R3349 n1_M2_91860_25980 n1_M2_92940_25980 0.988200
R3350 n1_M2_92940_25980 n1_M2_94020_25980 0.988200
R3351 n1_M2_94020_25980 n1_M2_95100_25980 0.988200
R3352 n1_M2_95100_25980 n1_M2_96180_25980 0.988200
R3353 n1_M2_96180_25980 n1_M2_97260_25980 0.988200
R3354 n1_M2_97260_25980 n1_M2_98340_25980 0.988200
R3355 n1_M2_98340_25980 n1_M2_99420_25980 0.988200
R3356 n1_M2_99420_25980 n1_M2_100500_25980 0.988200
R3357 n1_M2_100500_25980 n1_M2_101580_25980 0.988200
R3358 n1_M2_101580_25980 n1_M2_102660_25980 0.988200
R3359 n1_M2_102660_25980 n1_M2_103740_25980 0.988200
R3360 n1_M2_103740_25980 n1_M2_104820_25980 0.988200
R3361 n1_M2_104820_25980 n1_M2_105900_25980 0.988200
R3362 n1_M2_105900_25980 n1_M2_106980_25980 0.988200
R3363 n1_M2_106980_25980 n1_M2_108060_25980 0.988200
R3364 n1_M2_108060_25980 n1_M2_109140_25980 0.988200
R3365 n1_M2_109140_25980 n1_M2_110220_25980 0.988200
R3366 n1_M2_110220_25980 n1_M2_111300_25980 0.988200
R3367 n1_M2_111300_25980 n1_M2_112380_25980 0.988200
R3368 n1_M2_112380_25980 n1_M2_113460_25980 0.988200
R3369 n1_M2_113460_25980 n1_M2_114540_25980 0.988200
R3370 n1_M2_114540_25980 n1_M2_115620_25980 0.988200
R3371 n1_M2_115620_25980 n1_M2_116700_25980 0.988200
R3372 n1_M2_116700_25980 n1_M2_117780_25980 0.988200
R3373 n1_M2_117780_25980 n1_M2_118860_25980 0.988200
R3374 n1_M2_118860_25980 n1_M2_119940_25980 0.988200
R3375 n1_M2_119940_25980 n1_M2_121020_25980 0.988200
R3376 n1_M2_121020_25980 n1_M2_122100_25980 0.988200
R3377 n1_M2_122100_25980 n1_M2_123180_25980 0.988200
R3378 n1_M2_123180_25980 n1_M2_124260_25980 0.988200
R3379 n1_M2_124260_25980 n1_M2_125340_25980 0.988200
R3380 n1_M2_125340_25980 n1_M2_126420_25980 0.988200
R3381 n1_M2_126420_25980 n1_M2_127500_25980 0.988200
R3382 n1_M2_127500_25980 n1_M2_128580_25980 0.988200
R3383 n1_M2_128580_25980 n1_M2_129660_25980 0.988200
R3384 n1_M2_129660_25980 n1_M2_130740_25980 0.988200
R3385 n1_M2_130740_25980 n1_M2_131820_25980 0.988200
R3386 n1_M2_131820_25980 n1_M2_132900_25980 0.988200
R3387 n1_M2_132900_25980 n1_M2_133980_25980 0.988200
R3388 n1_M2_133980_25980 n1_M2_135060_25980 0.988200
R3389 n1_M2_135060_25980 n1_M2_136140_25980 0.988200
R3390 n1_M2_136140_25980 n1_M2_137220_25980 0.988200
R3391 n1_M2_137220_25980 n1_M2_138300_25980 0.988200
R3392 n1_M2_138300_25980 n1_M2_139380_25980 0.988200
R3393 n1_M2_139380_25980 n1_M2_140460_25980 0.988200
R3394 n1_M2_140460_25980 n1_M2_141540_25980 0.988200
R3395 n1_M2_141540_25980 n1_M2_142620_25980 0.988200
R3396 n1_M2_142620_25980 n1_M2_143700_25980 0.988200
R3397 n1_M2_143700_25980 n1_M2_144780_25980 0.988200
R3398 n1_M2_144780_25980 n1_M2_145860_25980 0.988200
R3399 n1_M2_145860_25980 n1_M2_146940_25980 0.988200
R3400 n1_M2_60_27060 n1_M2_1140_27060 0.988200
R3401 n1_M2_1140_27060 n1_M2_2220_27060 0.988200
R3402 n1_M2_2220_27060 n1_M2_3300_27060 0.988200
R3403 n1_M2_3300_27060 n1_M2_4380_27060 0.988200
R3404 n1_M2_4380_27060 n1_M2_5460_27060 0.988200
R3405 n1_M2_5460_27060 n1_M2_6540_27060 0.988200
R3406 n1_M2_6540_27060 n1_M2_7620_27060 0.988200
R3407 n1_M2_7620_27060 n1_M2_8700_27060 0.988200
R3408 n1_M2_8700_27060 n1_M2_9780_27060 0.988200
R3409 n1_M2_9780_27060 n1_M2_10860_27060 0.988200
R3410 n1_M2_10860_27060 n1_M2_11940_27060 0.988200
R3411 n1_M2_11940_27060 n1_M2_13020_27060 0.988200
R3412 n1_M2_13020_27060 n1_M2_14100_27060 0.988200
R3413 n1_M2_14100_27060 n1_M2_15180_27060 0.988200
R3414 n1_M2_15180_27060 n1_M2_16260_27060 0.988200
R3415 n1_M2_16260_27060 n1_M2_17340_27060 0.988200
R3416 n1_M2_17340_27060 n1_M2_18420_27060 0.988200
R3417 n1_M2_18420_27060 n1_M2_19500_27060 0.988200
R3418 n1_M2_19500_27060 n1_M2_20580_27060 0.988200
R3419 n1_M2_20580_27060 n1_M2_21660_27060 0.988200
R3420 n1_M2_21660_27060 n1_M2_22740_27060 0.988200
R3421 n1_M2_22740_27060 n1_M2_23820_27060 0.988200
R3422 n1_M2_23820_27060 n1_M2_24900_27060 0.988200
R3423 n1_M2_24900_27060 n1_M2_25980_27060 0.988200
R3424 n1_M2_25980_27060 n1_M2_27060_27060 0.988200
R3425 n1_M2_27060_27060 n1_M2_28140_27060 0.988200
R3426 n1_M2_28140_27060 n1_M2_29220_27060 0.988200
R3427 n1_M2_29220_27060 n1_M2_30300_27060 0.988200
R3428 n1_M2_30300_27060 n1_M2_31380_27060 0.988200
R3429 n1_M2_31380_27060 n1_M2_32460_27060 0.988200
R3430 n1_M2_32460_27060 n1_M2_33540_27060 0.988200
R3431 n1_M2_33540_27060 n1_M2_34620_27060 0.988200
R3432 n1_M2_34620_27060 n1_M2_35700_27060 0.988200
R3433 n1_M2_35700_27060 n1_M2_36780_27060 0.988200
R3434 n1_M2_36780_27060 n1_M2_37860_27060 0.988200
R3435 n1_M2_37860_27060 n1_M2_38940_27060 0.988200
R3436 n1_M2_38940_27060 n1_M2_40020_27060 0.988200
R3437 n1_M2_40020_27060 n1_M2_41100_27060 0.988200
R3438 n1_M2_41100_27060 n1_M2_42180_27060 0.988200
R3439 n1_M2_42180_27060 n1_M2_43260_27060 0.988200
R3440 n1_M2_43260_27060 n1_M2_44340_27060 0.988200
R3441 n1_M2_44340_27060 n1_M2_45420_27060 0.988200
R3442 n1_M2_45420_27060 n1_M2_46500_27060 0.988200
R3443 n1_M2_46500_27060 n1_M2_47580_27060 0.988200
R3444 n1_M2_47580_27060 n1_M2_48660_27060 0.988200
R3445 n1_M2_48660_27060 n1_M2_49740_27060 0.988200
R3446 n1_M2_49740_27060 n1_M2_50820_27060 0.988200
R3447 n1_M2_50820_27060 n1_M2_51900_27060 0.988200
R3448 n1_M2_51900_27060 n1_M2_52980_27060 0.988200
R3449 n1_M2_52980_27060 n1_M2_54060_27060 0.988200
R3450 n1_M2_54060_27060 n1_M2_55140_27060 0.988200
R3451 n1_M2_55140_27060 n1_M2_56220_27060 0.988200
R3452 n1_M2_56220_27060 n1_M2_57300_27060 0.988200
R3453 n1_M2_57300_27060 n1_M2_58380_27060 0.988200
R3454 n1_M2_58380_27060 n1_M2_59460_27060 0.988200
R3455 n1_M2_59460_27060 n1_M2_60540_27060 0.988200
R3456 n1_M2_60540_27060 n1_M2_61620_27060 0.988200
R3457 n1_M2_61620_27060 n1_M2_62700_27060 0.988200
R3458 n1_M2_62700_27060 n1_M2_63780_27060 0.988200
R3459 n1_M2_63780_27060 n1_M2_64860_27060 0.988200
R3460 n1_M2_64860_27060 n1_M2_65940_27060 0.988200
R3461 n1_M2_65940_27060 n1_M2_67020_27060 0.988200
R3462 n1_M2_67020_27060 n1_M2_68100_27060 0.988200
R3463 n1_M2_68100_27060 n1_M2_69180_27060 0.988200
R3464 n1_M2_69180_27060 n1_M2_70260_27060 0.988200
R3465 n1_M2_70260_27060 n1_M2_71340_27060 0.988200
R3466 n1_M2_71340_27060 n1_M2_72420_27060 0.988200
R3467 n1_M2_72420_27060 n1_M2_73500_27060 0.988200
R3468 n1_M2_73500_27060 n1_M2_74580_27060 0.988200
R3469 n1_M2_74580_27060 n1_M2_75660_27060 0.988200
R3470 n1_M2_75660_27060 n1_M2_76740_27060 0.988200
R3471 n1_M2_76740_27060 n1_M2_77820_27060 0.988200
R3472 n1_M2_77820_27060 n1_M2_78900_27060 0.988200
R3473 n1_M2_78900_27060 n1_M2_79980_27060 0.988200
R3474 n1_M2_79980_27060 n1_M2_81060_27060 0.988200
R3475 n1_M2_81060_27060 n1_M2_82140_27060 0.988200
R3476 n1_M2_82140_27060 n1_M2_83220_27060 0.988200
R3477 n1_M2_83220_27060 n1_M2_84300_27060 0.988200
R3478 n1_M2_84300_27060 n1_M2_85380_27060 0.988200
R3479 n1_M2_85380_27060 n1_M2_86460_27060 0.988200
R3480 n1_M2_86460_27060 n1_M2_87540_27060 0.988200
R3481 n1_M2_87540_27060 n1_M2_88620_27060 0.988200
R3482 n1_M2_88620_27060 n1_M2_89700_27060 0.988200
R3483 n1_M2_89700_27060 n1_M2_90780_27060 0.988200
R3484 n1_M2_90780_27060 n1_M2_91860_27060 0.988200
R3485 n1_M2_91860_27060 n1_M2_92940_27060 0.988200
R3486 n1_M2_92940_27060 n1_M2_94020_27060 0.988200
R3487 n1_M2_94020_27060 n1_M2_95100_27060 0.988200
R3488 n1_M2_95100_27060 n1_M2_96180_27060 0.988200
R3489 n1_M2_96180_27060 n1_M2_97260_27060 0.988200
R3490 n1_M2_97260_27060 n1_M2_98340_27060 0.988200
R3491 n1_M2_98340_27060 n1_M2_99420_27060 0.988200
R3492 n1_M2_99420_27060 n1_M2_100500_27060 0.988200
R3493 n1_M2_100500_27060 n1_M2_101580_27060 0.988200
R3494 n1_M2_101580_27060 n1_M2_102660_27060 0.988200
R3495 n1_M2_102660_27060 n1_M2_103740_27060 0.988200
R3496 n1_M2_103740_27060 n1_M2_104820_27060 0.988200
R3497 n1_M2_104820_27060 n1_M2_105900_27060 0.988200
R3498 n1_M2_105900_27060 n1_M2_106980_27060 0.988200
R3499 n1_M2_106980_27060 n1_M2_108060_27060 0.988200
R3500 n1_M2_108060_27060 n1_M2_109140_27060 0.988200
R3501 n1_M2_109140_27060 n1_M2_110220_27060 0.988200
R3502 n1_M2_110220_27060 n1_M2_111300_27060 0.988200
R3503 n1_M2_111300_27060 n1_M2_112380_27060 0.988200
R3504 n1_M2_112380_27060 n1_M2_113460_27060 0.988200
R3505 n1_M2_113460_27060 n1_M2_114540_27060 0.988200
R3506 n1_M2_114540_27060 n1_M2_115620_27060 0.988200
R3507 n1_M2_115620_27060 n1_M2_116700_27060 0.988200
R3508 n1_M2_116700_27060 n1_M2_117780_27060 0.988200
R3509 n1_M2_117780_27060 n1_M2_118860_27060 0.988200
R3510 n1_M2_118860_27060 n1_M2_119940_27060 0.988200
R3511 n1_M2_119940_27060 n1_M2_121020_27060 0.988200
R3512 n1_M2_121020_27060 n1_M2_122100_27060 0.988200
R3513 n1_M2_122100_27060 n1_M2_123180_27060 0.988200
R3514 n1_M2_123180_27060 n1_M2_124260_27060 0.988200
R3515 n1_M2_124260_27060 n1_M2_125340_27060 0.988200
R3516 n1_M2_125340_27060 n1_M2_126420_27060 0.988200
R3517 n1_M2_126420_27060 n1_M2_127500_27060 0.988200
R3518 n1_M2_127500_27060 n1_M2_128580_27060 0.988200
R3519 n1_M2_128580_27060 n1_M2_129660_27060 0.988200
R3520 n1_M2_129660_27060 n1_M2_130740_27060 0.988200
R3521 n1_M2_130740_27060 n1_M2_131820_27060 0.988200
R3522 n1_M2_131820_27060 n1_M2_132900_27060 0.988200
R3523 n1_M2_132900_27060 n1_M2_133980_27060 0.988200
R3524 n1_M2_133980_27060 n1_M2_135060_27060 0.988200
R3525 n1_M2_135060_27060 n1_M2_136140_27060 0.988200
R3526 n1_M2_136140_27060 n1_M2_137220_27060 0.988200
R3527 n1_M2_137220_27060 n1_M2_138300_27060 0.988200
R3528 n1_M2_138300_27060 n1_M2_139380_27060 0.988200
R3529 n1_M2_139380_27060 n1_M2_140460_27060 0.988200
R3530 n1_M2_140460_27060 n1_M2_141540_27060 0.988200
R3531 n1_M2_141540_27060 n1_M2_142620_27060 0.988200
R3532 n1_M2_142620_27060 n1_M2_143700_27060 0.988200
R3533 n1_M2_143700_27060 n1_M2_144780_27060 0.988200
R3534 n1_M2_144780_27060 n1_M2_145860_27060 0.988200
R3535 n1_M2_145860_27060 n1_M2_146940_27060 0.988200
R3536 n1_M2_60_28140 n1_M2_1140_28140 0.988200
R3537 n1_M2_1140_28140 n1_M2_2220_28140 0.988200
R3538 n1_M2_2220_28140 n1_M2_3300_28140 0.988200
R3539 n1_M2_3300_28140 n1_M2_4380_28140 0.988200
R3540 n1_M2_4380_28140 n1_M2_5460_28140 0.988200
R3541 n1_M2_5460_28140 n1_M2_6540_28140 0.988200
R3542 n1_M2_6540_28140 n1_M2_7620_28140 0.988200
R3543 n1_M2_7620_28140 n1_M2_8700_28140 0.988200
R3544 n1_M2_8700_28140 n1_M2_9780_28140 0.988200
R3545 n1_M2_9780_28140 n1_M2_10860_28140 0.988200
R3546 n1_M2_10860_28140 n1_M2_11940_28140 0.988200
R3547 n1_M2_11940_28140 n1_M2_13020_28140 0.988200
R3548 n1_M2_13020_28140 n1_M2_14100_28140 0.988200
R3549 n1_M2_14100_28140 n1_M2_15180_28140 0.988200
R3550 n1_M2_15180_28140 n1_M2_16260_28140 0.988200
R3551 n1_M2_16260_28140 n1_M2_17340_28140 0.988200
R3552 n1_M2_17340_28140 n1_M2_18420_28140 0.988200
R3553 n1_M2_18420_28140 n1_M2_19500_28140 0.988200
R3554 n1_M2_19500_28140 n1_M2_20580_28140 0.988200
R3555 n1_M2_20580_28140 n1_M2_21660_28140 0.988200
R3556 n1_M2_21660_28140 n1_M2_22740_28140 0.988200
R3557 n1_M2_22740_28140 n1_M2_23820_28140 0.988200
R3558 n1_M2_23820_28140 n1_M2_24900_28140 0.988200
R3559 n1_M2_24900_28140 n1_M2_25980_28140 0.988200
R3560 n1_M2_25980_28140 n1_M2_27060_28140 0.988200
R3561 n1_M2_27060_28140 n1_M2_28140_28140 0.988200
R3562 n1_M2_28140_28140 n1_M2_29220_28140 0.988200
R3563 n1_M2_29220_28140 n1_M2_30300_28140 0.988200
R3564 n1_M2_30300_28140 n1_M2_31380_28140 0.988200
R3565 n1_M2_31380_28140 n1_M2_32460_28140 0.988200
R3566 n1_M2_32460_28140 n1_M2_33540_28140 0.988200
R3567 n1_M2_33540_28140 n1_M2_34620_28140 0.988200
R3568 n1_M2_34620_28140 n1_M2_35700_28140 0.988200
R3569 n1_M2_35700_28140 n1_M2_36780_28140 0.988200
R3570 n1_M2_36780_28140 n1_M2_37860_28140 0.988200
R3571 n1_M2_37860_28140 n1_M2_38940_28140 0.988200
R3572 n1_M2_38940_28140 n1_M2_40020_28140 0.988200
R3573 n1_M2_40020_28140 n1_M2_41100_28140 0.988200
R3574 n1_M2_41100_28140 n1_M2_42180_28140 0.988200
R3575 n1_M2_42180_28140 n1_M2_43260_28140 0.988200
R3576 n1_M2_43260_28140 n1_M2_44340_28140 0.988200
R3577 n1_M2_44340_28140 n1_M2_45420_28140 0.988200
R3578 n1_M2_45420_28140 n1_M2_46500_28140 0.988200
R3579 n1_M2_46500_28140 n1_M2_47580_28140 0.988200
R3580 n1_M2_47580_28140 n1_M2_48660_28140 0.988200
R3581 n1_M2_48660_28140 n1_M2_49740_28140 0.988200
R3582 n1_M2_49740_28140 n1_M2_50820_28140 0.988200
R3583 n1_M2_50820_28140 n1_M2_51900_28140 0.988200
R3584 n1_M2_51900_28140 n1_M2_52980_28140 0.988200
R3585 n1_M2_52980_28140 n1_M2_54060_28140 0.988200
R3586 n1_M2_54060_28140 n1_M2_55140_28140 0.988200
R3587 n1_M2_55140_28140 n1_M2_56220_28140 0.988200
R3588 n1_M2_56220_28140 n1_M2_57300_28140 0.988200
R3589 n1_M2_57300_28140 n1_M2_58380_28140 0.988200
R3590 n1_M2_58380_28140 n1_M2_59460_28140 0.988200
R3591 n1_M2_59460_28140 n1_M2_60540_28140 0.988200
R3592 n1_M2_60540_28140 n1_M2_61620_28140 0.988200
R3593 n1_M2_61620_28140 n1_M2_62700_28140 0.988200
R3594 n1_M2_62700_28140 n1_M2_63780_28140 0.988200
R3595 n1_M2_63780_28140 n1_M2_64860_28140 0.988200
R3596 n1_M2_64860_28140 n1_M2_65940_28140 0.988200
R3597 n1_M2_65940_28140 n1_M2_67020_28140 0.988200
R3598 n1_M2_67020_28140 n1_M2_68100_28140 0.988200
R3599 n1_M2_68100_28140 n1_M2_69180_28140 0.988200
R3600 n1_M2_69180_28140 n1_M2_70260_28140 0.988200
R3601 n1_M2_70260_28140 n1_M2_71340_28140 0.988200
R3602 n1_M2_71340_28140 n1_M2_72420_28140 0.988200
R3603 n1_M2_72420_28140 n1_M2_73500_28140 0.988200
R3604 n1_M2_73500_28140 n1_M2_74580_28140 0.988200
R3605 n1_M2_74580_28140 n1_M2_75660_28140 0.988200
R3606 n1_M2_75660_28140 n1_M2_76740_28140 0.988200
R3607 n1_M2_76740_28140 n1_M2_77820_28140 0.988200
R3608 n1_M2_77820_28140 n1_M2_78900_28140 0.988200
R3609 n1_M2_78900_28140 n1_M2_79980_28140 0.988200
R3610 n1_M2_79980_28140 n1_M2_81060_28140 0.988200
R3611 n1_M2_81060_28140 n1_M2_82140_28140 0.988200
R3612 n1_M2_82140_28140 n1_M2_83220_28140 0.988200
R3613 n1_M2_83220_28140 n1_M2_84300_28140 0.988200
R3614 n1_M2_84300_28140 n1_M2_85380_28140 0.988200
R3615 n1_M2_85380_28140 n1_M2_86460_28140 0.988200
R3616 n1_M2_86460_28140 n1_M2_87540_28140 0.988200
R3617 n1_M2_87540_28140 n1_M2_88620_28140 0.988200
R3618 n1_M2_88620_28140 n1_M2_89700_28140 0.988200
R3619 n1_M2_89700_28140 n1_M2_90780_28140 0.988200
R3620 n1_M2_90780_28140 n1_M2_91860_28140 0.988200
R3621 n1_M2_91860_28140 n1_M2_92940_28140 0.988200
R3622 n1_M2_92940_28140 n1_M2_94020_28140 0.988200
R3623 n1_M2_94020_28140 n1_M2_95100_28140 0.988200
R3624 n1_M2_95100_28140 n1_M2_96180_28140 0.988200
R3625 n1_M2_96180_28140 n1_M2_97260_28140 0.988200
R3626 n1_M2_97260_28140 n1_M2_98340_28140 0.988200
R3627 n1_M2_98340_28140 n1_M2_99420_28140 0.988200
R3628 n1_M2_99420_28140 n1_M2_100500_28140 0.988200
R3629 n1_M2_100500_28140 n1_M2_101580_28140 0.988200
R3630 n1_M2_101580_28140 n1_M2_102660_28140 0.988200
R3631 n1_M2_102660_28140 n1_M2_103740_28140 0.988200
R3632 n1_M2_103740_28140 n1_M2_104820_28140 0.988200
R3633 n1_M2_104820_28140 n1_M2_105900_28140 0.988200
R3634 n1_M2_105900_28140 n1_M2_106980_28140 0.988200
R3635 n1_M2_106980_28140 n1_M2_108060_28140 0.988200
R3636 n1_M2_108060_28140 n1_M2_109140_28140 0.988200
R3637 n1_M2_109140_28140 n1_M2_110220_28140 0.988200
R3638 n1_M2_110220_28140 n1_M2_111300_28140 0.988200
R3639 n1_M2_111300_28140 n1_M2_112380_28140 0.988200
R3640 n1_M2_112380_28140 n1_M2_113460_28140 0.988200
R3641 n1_M2_113460_28140 n1_M2_114540_28140 0.988200
R3642 n1_M2_114540_28140 n1_M2_115620_28140 0.988200
R3643 n1_M2_115620_28140 n1_M2_116700_28140 0.988200
R3644 n1_M2_116700_28140 n1_M2_117780_28140 0.988200
R3645 n1_M2_117780_28140 n1_M2_118860_28140 0.988200
R3646 n1_M2_118860_28140 n1_M2_119940_28140 0.988200
R3647 n1_M2_119940_28140 n1_M2_121020_28140 0.988200
R3648 n1_M2_121020_28140 n1_M2_122100_28140 0.988200
R3649 n1_M2_122100_28140 n1_M2_123180_28140 0.988200
R3650 n1_M2_123180_28140 n1_M2_124260_28140 0.988200
R3651 n1_M2_124260_28140 n1_M2_125340_28140 0.988200
R3652 n1_M2_125340_28140 n1_M2_126420_28140 0.988200
R3653 n1_M2_126420_28140 n1_M2_127500_28140 0.988200
R3654 n1_M2_127500_28140 n1_M2_128580_28140 0.988200
R3655 n1_M2_128580_28140 n1_M2_129660_28140 0.988200
R3656 n1_M2_129660_28140 n1_M2_130740_28140 0.988200
R3657 n1_M2_130740_28140 n1_M2_131820_28140 0.988200
R3658 n1_M2_131820_28140 n1_M2_132900_28140 0.988200
R3659 n1_M2_132900_28140 n1_M2_133980_28140 0.988200
R3660 n1_M2_133980_28140 n1_M2_135060_28140 0.988200
R3661 n1_M2_135060_28140 n1_M2_136140_28140 0.988200
R3662 n1_M2_136140_28140 n1_M2_137220_28140 0.988200
R3663 n1_M2_137220_28140 n1_M2_138300_28140 0.988200
R3664 n1_M2_138300_28140 n1_M2_139380_28140 0.988200
R3665 n1_M2_139380_28140 n1_M2_140460_28140 0.988200
R3666 n1_M2_140460_28140 n1_M2_141540_28140 0.988200
R3667 n1_M2_141540_28140 n1_M2_142620_28140 0.988200
R3668 n1_M2_142620_28140 n1_M2_143700_28140 0.988200
R3669 n1_M2_143700_28140 n1_M2_144780_28140 0.988200
R3670 n1_M2_144780_28140 n1_M2_145860_28140 0.988200
R3671 n1_M2_145860_28140 n1_M2_146940_28140 0.988200
R3672 n1_M2_60_29220 n1_M2_1140_29220 0.988200
R3673 n1_M2_1140_29220 n1_M2_2220_29220 0.988200
R3674 n1_M2_2220_29220 n1_M2_3300_29220 0.988200
R3675 n1_M2_3300_29220 n1_M2_4380_29220 0.988200
R3676 n1_M2_4380_29220 n1_M2_5460_29220 0.988200
R3677 n1_M2_5460_29220 n1_M2_6540_29220 0.988200
R3678 n1_M2_6540_29220 n1_M2_7620_29220 0.988200
R3679 n1_M2_7620_29220 n1_M2_8700_29220 0.988200
R3680 n1_M2_8700_29220 n1_M2_9780_29220 0.988200
R3681 n1_M2_9780_29220 n1_M2_10860_29220 0.988200
R3682 n1_M2_10860_29220 n1_M2_11940_29220 0.988200
R3683 n1_M2_11940_29220 n1_M2_13020_29220 0.988200
R3684 n1_M2_13020_29220 n1_M2_14100_29220 0.988200
R3685 n1_M2_14100_29220 n1_M2_15180_29220 0.988200
R3686 n1_M2_15180_29220 n1_M2_16260_29220 0.988200
R3687 n1_M2_16260_29220 n1_M2_17340_29220 0.988200
R3688 n1_M2_17340_29220 n1_M2_18420_29220 0.988200
R3689 n1_M2_18420_29220 n1_M2_19500_29220 0.988200
R3690 n1_M2_19500_29220 n1_M2_20580_29220 0.988200
R3691 n1_M2_20580_29220 n1_M2_21660_29220 0.988200
R3692 n1_M2_21660_29220 n1_M2_22740_29220 0.988200
R3693 n1_M2_22740_29220 n1_M2_23820_29220 0.988200
R3694 n1_M2_23820_29220 n1_M2_24900_29220 0.988200
R3695 n1_M2_24900_29220 n1_M2_25980_29220 0.988200
R3696 n1_M2_25980_29220 n1_M2_27060_29220 0.988200
R3697 n1_M2_27060_29220 n1_M2_28140_29220 0.988200
R3698 n1_M2_28140_29220 n1_M2_29220_29220 0.988200
R3699 n1_M2_29220_29220 n1_M2_30300_29220 0.988200
R3700 n1_M2_30300_29220 n1_M2_31380_29220 0.988200
R3701 n1_M2_31380_29220 n1_M2_32460_29220 0.988200
R3702 n1_M2_32460_29220 n1_M2_33540_29220 0.988200
R3703 n1_M2_33540_29220 n1_M2_34620_29220 0.988200
R3704 n1_M2_34620_29220 n1_M2_35700_29220 0.988200
R3705 n1_M2_35700_29220 n1_M2_36780_29220 0.988200
R3706 n1_M2_36780_29220 n1_M2_37860_29220 0.988200
R3707 n1_M2_37860_29220 n1_M2_38940_29220 0.988200
R3708 n1_M2_38940_29220 n1_M2_40020_29220 0.988200
R3709 n1_M2_40020_29220 n1_M2_41100_29220 0.988200
R3710 n1_M2_41100_29220 n1_M2_42180_29220 0.988200
R3711 n1_M2_42180_29220 n1_M2_43260_29220 0.988200
R3712 n1_M2_43260_29220 n1_M2_44340_29220 0.988200
R3713 n1_M2_44340_29220 n1_M2_45420_29220 0.988200
R3714 n1_M2_45420_29220 n1_M2_46500_29220 0.988200
R3715 n1_M2_46500_29220 n1_M2_47580_29220 0.988200
R3716 n1_M2_47580_29220 n1_M2_48660_29220 0.988200
R3717 n1_M2_48660_29220 n1_M2_49740_29220 0.988200
R3718 n1_M2_49740_29220 n1_M2_50820_29220 0.988200
R3719 n1_M2_50820_29220 n1_M2_51900_29220 0.988200
R3720 n1_M2_51900_29220 n1_M2_52980_29220 0.988200
R3721 n1_M2_52980_29220 n1_M2_54060_29220 0.988200
R3722 n1_M2_54060_29220 n1_M2_55140_29220 0.988200
R3723 n1_M2_55140_29220 n1_M2_56220_29220 0.988200
R3724 n1_M2_56220_29220 n1_M2_57300_29220 0.988200
R3725 n1_M2_57300_29220 n1_M2_58380_29220 0.988200
R3726 n1_M2_58380_29220 n1_M2_59460_29220 0.988200
R3727 n1_M2_59460_29220 n1_M2_60540_29220 0.988200
R3728 n1_M2_60540_29220 n1_M2_61620_29220 0.988200
R3729 n1_M2_61620_29220 n1_M2_62700_29220 0.988200
R3730 n1_M2_62700_29220 n1_M2_63780_29220 0.988200
R3731 n1_M2_63780_29220 n1_M2_64860_29220 0.988200
R3732 n1_M2_64860_29220 n1_M2_65940_29220 0.988200
R3733 n1_M2_65940_29220 n1_M2_67020_29220 0.988200
R3734 n1_M2_67020_29220 n1_M2_68100_29220 0.988200
R3735 n1_M2_68100_29220 n1_M2_69180_29220 0.988200
R3736 n1_M2_69180_29220 n1_M2_70260_29220 0.988200
R3737 n1_M2_70260_29220 n1_M2_71340_29220 0.988200
R3738 n1_M2_71340_29220 n1_M2_72420_29220 0.988200
R3739 n1_M2_72420_29220 n1_M2_73500_29220 0.988200
R3740 n1_M2_73500_29220 n1_M2_74580_29220 0.988200
R3741 n1_M2_74580_29220 n1_M2_75660_29220 0.988200
R3742 n1_M2_75660_29220 n1_M2_76740_29220 0.988200
R3743 n1_M2_76740_29220 n1_M2_77820_29220 0.988200
R3744 n1_M2_77820_29220 n1_M2_78900_29220 0.988200
R3745 n1_M2_78900_29220 n1_M2_79980_29220 0.988200
R3746 n1_M2_79980_29220 n1_M2_81060_29220 0.988200
R3747 n1_M2_81060_29220 n1_M2_82140_29220 0.988200
R3748 n1_M2_82140_29220 n1_M2_83220_29220 0.988200
R3749 n1_M2_83220_29220 n1_M2_84300_29220 0.988200
R3750 n1_M2_84300_29220 n1_M2_85380_29220 0.988200
R3751 n1_M2_85380_29220 n1_M2_86460_29220 0.988200
R3752 n1_M2_86460_29220 n1_M2_87540_29220 0.988200
R3753 n1_M2_87540_29220 n1_M2_88620_29220 0.988200
R3754 n1_M2_88620_29220 n1_M2_89700_29220 0.988200
R3755 n1_M2_89700_29220 n1_M2_90780_29220 0.988200
R3756 n1_M2_90780_29220 n1_M2_91860_29220 0.988200
R3757 n1_M2_91860_29220 n1_M2_92940_29220 0.988200
R3758 n1_M2_92940_29220 n1_M2_94020_29220 0.988200
R3759 n1_M2_94020_29220 n1_M2_95100_29220 0.988200
R3760 n1_M2_95100_29220 n1_M2_96180_29220 0.988200
R3761 n1_M2_96180_29220 n1_M2_97260_29220 0.988200
R3762 n1_M2_97260_29220 n1_M2_98340_29220 0.988200
R3763 n1_M2_98340_29220 n1_M2_99420_29220 0.988200
R3764 n1_M2_99420_29220 n1_M2_100500_29220 0.988200
R3765 n1_M2_100500_29220 n1_M2_101580_29220 0.988200
R3766 n1_M2_101580_29220 n1_M2_102660_29220 0.988200
R3767 n1_M2_102660_29220 n1_M2_103740_29220 0.988200
R3768 n1_M2_103740_29220 n1_M2_104820_29220 0.988200
R3769 n1_M2_104820_29220 n1_M2_105900_29220 0.988200
R3770 n1_M2_105900_29220 n1_M2_106980_29220 0.988200
R3771 n1_M2_106980_29220 n1_M2_108060_29220 0.988200
R3772 n1_M2_108060_29220 n1_M2_109140_29220 0.988200
R3773 n1_M2_109140_29220 n1_M2_110220_29220 0.988200
R3774 n1_M2_110220_29220 n1_M2_111300_29220 0.988200
R3775 n1_M2_111300_29220 n1_M2_112380_29220 0.988200
R3776 n1_M2_112380_29220 n1_M2_113460_29220 0.988200
R3777 n1_M2_113460_29220 n1_M2_114540_29220 0.988200
R3778 n1_M2_114540_29220 n1_M2_115620_29220 0.988200
R3779 n1_M2_115620_29220 n1_M2_116700_29220 0.988200
R3780 n1_M2_116700_29220 n1_M2_117780_29220 0.988200
R3781 n1_M2_117780_29220 n1_M2_118860_29220 0.988200
R3782 n1_M2_118860_29220 n1_M2_119940_29220 0.988200
R3783 n1_M2_119940_29220 n1_M2_121020_29220 0.988200
R3784 n1_M2_121020_29220 n1_M2_122100_29220 0.988200
R3785 n1_M2_122100_29220 n1_M2_123180_29220 0.988200
R3786 n1_M2_123180_29220 n1_M2_124260_29220 0.988200
R3787 n1_M2_124260_29220 n1_M2_125340_29220 0.988200
R3788 n1_M2_125340_29220 n1_M2_126420_29220 0.988200
R3789 n1_M2_126420_29220 n1_M2_127500_29220 0.988200
R3790 n1_M2_127500_29220 n1_M2_128580_29220 0.988200
R3791 n1_M2_128580_29220 n1_M2_129660_29220 0.988200
R3792 n1_M2_129660_29220 n1_M2_130740_29220 0.988200
R3793 n1_M2_130740_29220 n1_M2_131820_29220 0.988200
R3794 n1_M2_131820_29220 n1_M2_132900_29220 0.988200
R3795 n1_M2_132900_29220 n1_M2_133980_29220 0.988200
R3796 n1_M2_133980_29220 n1_M2_135060_29220 0.988200
R3797 n1_M2_135060_29220 n1_M2_136140_29220 0.988200
R3798 n1_M2_136140_29220 n1_M2_137220_29220 0.988200
R3799 n1_M2_137220_29220 n1_M2_138300_29220 0.988200
R3800 n1_M2_138300_29220 n1_M2_139380_29220 0.988200
R3801 n1_M2_139380_29220 n1_M2_140460_29220 0.988200
R3802 n1_M2_140460_29220 n1_M2_141540_29220 0.988200
R3803 n1_M2_141540_29220 n1_M2_142620_29220 0.988200
R3804 n1_M2_142620_29220 n1_M2_143700_29220 0.988200
R3805 n1_M2_143700_29220 n1_M2_144780_29220 0.988200
R3806 n1_M2_144780_29220 n1_M2_145860_29220 0.988200
R3807 n1_M2_145860_29220 n1_M2_146940_29220 0.988200
R3808 n1_M2_60_30300 n1_M2_1140_30300 0.988200
R3809 n1_M2_1140_30300 n1_M2_2220_30300 0.988200
R3810 n1_M2_2220_30300 n1_M2_3300_30300 0.988200
R3811 n1_M2_3300_30300 n1_M2_4380_30300 0.988200
R3812 n1_M2_4380_30300 n1_M2_5460_30300 0.988200
R3813 n1_M2_5460_30300 n1_M2_6540_30300 0.988200
R3814 n1_M2_6540_30300 n1_M2_7620_30300 0.988200
R3815 n1_M2_7620_30300 n1_M2_8700_30300 0.988200
R3816 n1_M2_8700_30300 n1_M2_9780_30300 0.988200
R3817 n1_M2_9780_30300 n1_M2_10860_30300 0.988200
R3818 n1_M2_10860_30300 n1_M2_11940_30300 0.988200
R3819 n1_M2_11940_30300 n1_M2_13020_30300 0.988200
R3820 n1_M2_13020_30300 n1_M2_14100_30300 0.988200
R3821 n1_M2_14100_30300 n1_M2_15180_30300 0.988200
R3822 n1_M2_15180_30300 n1_M2_16260_30300 0.988200
R3823 n1_M2_16260_30300 n1_M2_17340_30300 0.988200
R3824 n1_M2_17340_30300 n1_M2_18420_30300 0.988200
R3825 n1_M2_18420_30300 n1_M2_19500_30300 0.988200
R3826 n1_M2_19500_30300 n1_M2_20580_30300 0.988200
R3827 n1_M2_20580_30300 n1_M2_21660_30300 0.988200
R3828 n1_M2_21660_30300 n1_M2_22740_30300 0.988200
R3829 n1_M2_22740_30300 n1_M2_23820_30300 0.988200
R3830 n1_M2_23820_30300 n1_M2_24900_30300 0.988200
R3831 n1_M2_24900_30300 n1_M2_25980_30300 0.988200
R3832 n1_M2_25980_30300 n1_M2_27060_30300 0.988200
R3833 n1_M2_27060_30300 n1_M2_28140_30300 0.988200
R3834 n1_M2_28140_30300 n1_M2_29220_30300 0.988200
R3835 n1_M2_29220_30300 n1_M2_30300_30300 0.988200
R3836 n1_M2_30300_30300 n1_M2_31380_30300 0.988200
R3837 n1_M2_31380_30300 n1_M2_32460_30300 0.988200
R3838 n1_M2_32460_30300 n1_M2_33540_30300 0.988200
R3839 n1_M2_33540_30300 n1_M2_34620_30300 0.988200
R3840 n1_M2_34620_30300 n1_M2_35700_30300 0.988200
R3841 n1_M2_35700_30300 n1_M2_36780_30300 0.988200
R3842 n1_M2_36780_30300 n1_M2_37860_30300 0.988200
R3843 n1_M2_37860_30300 n1_M2_38940_30300 0.988200
R3844 n1_M2_38940_30300 n1_M2_40020_30300 0.988200
R3845 n1_M2_40020_30300 n1_M2_41100_30300 0.988200
R3846 n1_M2_41100_30300 n1_M2_42180_30300 0.988200
R3847 n1_M2_42180_30300 n1_M2_43260_30300 0.988200
R3848 n1_M2_43260_30300 n1_M2_44340_30300 0.988200
R3849 n1_M2_44340_30300 n1_M2_45420_30300 0.988200
R3850 n1_M2_45420_30300 n1_M2_46500_30300 0.988200
R3851 n1_M2_46500_30300 n1_M2_47580_30300 0.988200
R3852 n1_M2_47580_30300 n1_M2_48660_30300 0.988200
R3853 n1_M2_48660_30300 n1_M2_49740_30300 0.988200
R3854 n1_M2_49740_30300 n1_M2_50820_30300 0.988200
R3855 n1_M2_50820_30300 n1_M2_51900_30300 0.988200
R3856 n1_M2_51900_30300 n1_M2_52980_30300 0.988200
R3857 n1_M2_52980_30300 n1_M2_54060_30300 0.988200
R3858 n1_M2_54060_30300 n1_M2_55140_30300 0.988200
R3859 n1_M2_55140_30300 n1_M2_56220_30300 0.988200
R3860 n1_M2_56220_30300 n1_M2_57300_30300 0.988200
R3861 n1_M2_57300_30300 n1_M2_58380_30300 0.988200
R3862 n1_M2_58380_30300 n1_M2_59460_30300 0.988200
R3863 n1_M2_59460_30300 n1_M2_60540_30300 0.988200
R3864 n1_M2_60540_30300 n1_M2_61620_30300 0.988200
R3865 n1_M2_61620_30300 n1_M2_62700_30300 0.988200
R3866 n1_M2_62700_30300 n1_M2_63780_30300 0.988200
R3867 n1_M2_63780_30300 n1_M2_64860_30300 0.988200
R3868 n1_M2_64860_30300 n1_M2_65940_30300 0.988200
R3869 n1_M2_65940_30300 n1_M2_67020_30300 0.988200
R3870 n1_M2_67020_30300 n1_M2_68100_30300 0.988200
R3871 n1_M2_68100_30300 n1_M2_69180_30300 0.988200
R3872 n1_M2_69180_30300 n1_M2_70260_30300 0.988200
R3873 n1_M2_70260_30300 n1_M2_71340_30300 0.988200
R3874 n1_M2_71340_30300 n1_M2_72420_30300 0.988200
R3875 n1_M2_72420_30300 n1_M2_73500_30300 0.988200
R3876 n1_M2_73500_30300 n1_M2_74580_30300 0.988200
R3877 n1_M2_74580_30300 n1_M2_75660_30300 0.988200
R3878 n1_M2_75660_30300 n1_M2_76740_30300 0.988200
R3879 n1_M2_76740_30300 n1_M2_77820_30300 0.988200
R3880 n1_M2_77820_30300 n1_M2_78900_30300 0.988200
R3881 n1_M2_78900_30300 n1_M2_79980_30300 0.988200
R3882 n1_M2_79980_30300 n1_M2_81060_30300 0.988200
R3883 n1_M2_81060_30300 n1_M2_82140_30300 0.988200
R3884 n1_M2_82140_30300 n1_M2_83220_30300 0.988200
R3885 n1_M2_83220_30300 n1_M2_84300_30300 0.988200
R3886 n1_M2_84300_30300 n1_M2_85380_30300 0.988200
R3887 n1_M2_85380_30300 n1_M2_86460_30300 0.988200
R3888 n1_M2_86460_30300 n1_M2_87540_30300 0.988200
R3889 n1_M2_87540_30300 n1_M2_88620_30300 0.988200
R3890 n1_M2_88620_30300 n1_M2_89700_30300 0.988200
R3891 n1_M2_89700_30300 n1_M2_90780_30300 0.988200
R3892 n1_M2_90780_30300 n1_M2_91860_30300 0.988200
R3893 n1_M2_91860_30300 n1_M2_92940_30300 0.988200
R3894 n1_M2_92940_30300 n1_M2_94020_30300 0.988200
R3895 n1_M2_94020_30300 n1_M2_95100_30300 0.988200
R3896 n1_M2_95100_30300 n1_M2_96180_30300 0.988200
R3897 n1_M2_96180_30300 n1_M2_97260_30300 0.988200
R3898 n1_M2_97260_30300 n1_M2_98340_30300 0.988200
R3899 n1_M2_98340_30300 n1_M2_99420_30300 0.988200
R3900 n1_M2_99420_30300 n1_M2_100500_30300 0.988200
R3901 n1_M2_100500_30300 n1_M2_101580_30300 0.988200
R3902 n1_M2_101580_30300 n1_M2_102660_30300 0.988200
R3903 n1_M2_102660_30300 n1_M2_103740_30300 0.988200
R3904 n1_M2_103740_30300 n1_M2_104820_30300 0.988200
R3905 n1_M2_104820_30300 n1_M2_105900_30300 0.988200
R3906 n1_M2_105900_30300 n1_M2_106980_30300 0.988200
R3907 n1_M2_106980_30300 n1_M2_108060_30300 0.988200
R3908 n1_M2_108060_30300 n1_M2_109140_30300 0.988200
R3909 n1_M2_109140_30300 n1_M2_110220_30300 0.988200
R3910 n1_M2_110220_30300 n1_M2_111300_30300 0.988200
R3911 n1_M2_111300_30300 n1_M2_112380_30300 0.988200
R3912 n1_M2_112380_30300 n1_M2_113460_30300 0.988200
R3913 n1_M2_113460_30300 n1_M2_114540_30300 0.988200
R3914 n1_M2_114540_30300 n1_M2_115620_30300 0.988200
R3915 n1_M2_115620_30300 n1_M2_116700_30300 0.988200
R3916 n1_M2_116700_30300 n1_M2_117780_30300 0.988200
R3917 n1_M2_117780_30300 n1_M2_118860_30300 0.988200
R3918 n1_M2_118860_30300 n1_M2_119940_30300 0.988200
R3919 n1_M2_119940_30300 n1_M2_121020_30300 0.988200
R3920 n1_M2_121020_30300 n1_M2_122100_30300 0.988200
R3921 n1_M2_122100_30300 n1_M2_123180_30300 0.988200
R3922 n1_M2_123180_30300 n1_M2_124260_30300 0.988200
R3923 n1_M2_124260_30300 n1_M2_125340_30300 0.988200
R3924 n1_M2_125340_30300 n1_M2_126420_30300 0.988200
R3925 n1_M2_126420_30300 n1_M2_127500_30300 0.988200
R3926 n1_M2_127500_30300 n1_M2_128580_30300 0.988200
R3927 n1_M2_128580_30300 n1_M2_129660_30300 0.988200
R3928 n1_M2_129660_30300 n1_M2_130740_30300 0.988200
R3929 n1_M2_130740_30300 n1_M2_131820_30300 0.988200
R3930 n1_M2_131820_30300 n1_M2_132900_30300 0.988200
R3931 n1_M2_132900_30300 n1_M2_133980_30300 0.988200
R3932 n1_M2_133980_30300 n1_M2_135060_30300 0.988200
R3933 n1_M2_135060_30300 n1_M2_136140_30300 0.988200
R3934 n1_M2_136140_30300 n1_M2_137220_30300 0.988200
R3935 n1_M2_137220_30300 n1_M2_138300_30300 0.988200
R3936 n1_M2_138300_30300 n1_M2_139380_30300 0.988200
R3937 n1_M2_139380_30300 n1_M2_140460_30300 0.988200
R3938 n1_M2_140460_30300 n1_M2_141540_30300 0.988200
R3939 n1_M2_141540_30300 n1_M2_142620_30300 0.988200
R3940 n1_M2_142620_30300 n1_M2_143700_30300 0.988200
R3941 n1_M2_143700_30300 n1_M2_144780_30300 0.988200
R3942 n1_M2_144780_30300 n1_M2_145860_30300 0.988200
R3943 n1_M2_145860_30300 n1_M2_146940_30300 0.988200
R3944 n1_M2_60_31380 n1_M2_1140_31380 0.988200
R3945 n1_M2_1140_31380 n1_M2_2220_31380 0.988200
R3946 n1_M2_2220_31380 n1_M2_3300_31380 0.988200
R3947 n1_M2_3300_31380 n1_M2_4380_31380 0.988200
R3948 n1_M2_4380_31380 n1_M2_5460_31380 0.988200
R3949 n1_M2_5460_31380 n1_M2_6540_31380 0.988200
R3950 n1_M2_6540_31380 n1_M2_7620_31380 0.988200
R3951 n1_M2_7620_31380 n1_M2_8700_31380 0.988200
R3952 n1_M2_8700_31380 n1_M2_9780_31380 0.988200
R3953 n1_M2_9780_31380 n1_M2_10860_31380 0.988200
R3954 n1_M2_10860_31380 n1_M2_11940_31380 0.988200
R3955 n1_M2_11940_31380 n1_M2_13020_31380 0.988200
R3956 n1_M2_13020_31380 n1_M2_14100_31380 0.988200
R3957 n1_M2_14100_31380 n1_M2_15180_31380 0.988200
R3958 n1_M2_15180_31380 n1_M2_16260_31380 0.988200
R3959 n1_M2_16260_31380 n1_M2_17340_31380 0.988200
R3960 n1_M2_17340_31380 n1_M2_18420_31380 0.988200
R3961 n1_M2_18420_31380 n1_M2_19500_31380 0.988200
R3962 n1_M2_19500_31380 n1_M2_20580_31380 0.988200
R3963 n1_M2_20580_31380 n1_M2_21660_31380 0.988200
R3964 n1_M2_21660_31380 n1_M2_22740_31380 0.988200
R3965 n1_M2_22740_31380 n1_M2_23820_31380 0.988200
R3966 n1_M2_23820_31380 n1_M2_24900_31380 0.988200
R3967 n1_M2_24900_31380 n1_M2_25980_31380 0.988200
R3968 n1_M2_25980_31380 n1_M2_27060_31380 0.988200
R3969 n1_M2_27060_31380 n1_M2_28140_31380 0.988200
R3970 n1_M2_28140_31380 n1_M2_29220_31380 0.988200
R3971 n1_M2_29220_31380 n1_M2_30300_31380 0.988200
R3972 n1_M2_30300_31380 n1_M2_31380_31380 0.988200
R3973 n1_M2_31380_31380 n1_M2_32460_31380 0.988200
R3974 n1_M2_32460_31380 n1_M2_33540_31380 0.988200
R3975 n1_M2_33540_31380 n1_M2_34620_31380 0.988200
R3976 n1_M2_34620_31380 n1_M2_35700_31380 0.988200
R3977 n1_M2_35700_31380 n1_M2_36780_31380 0.988200
R3978 n1_M2_36780_31380 n1_M2_37860_31380 0.988200
R3979 n1_M2_37860_31380 n1_M2_38940_31380 0.988200
R3980 n1_M2_38940_31380 n1_M2_40020_31380 0.988200
R3981 n1_M2_40020_31380 n1_M2_41100_31380 0.988200
R3982 n1_M2_41100_31380 n1_M2_42180_31380 0.988200
R3983 n1_M2_42180_31380 n1_M2_43260_31380 0.988200
R3984 n1_M2_43260_31380 n1_M2_44340_31380 0.988200
R3985 n1_M2_44340_31380 n1_M2_45420_31380 0.988200
R3986 n1_M2_45420_31380 n1_M2_46500_31380 0.988200
R3987 n1_M2_46500_31380 n1_M2_47580_31380 0.988200
R3988 n1_M2_47580_31380 n1_M2_48660_31380 0.988200
R3989 n1_M2_48660_31380 n1_M2_49740_31380 0.988200
R3990 n1_M2_49740_31380 n1_M2_50820_31380 0.988200
R3991 n1_M2_50820_31380 n1_M2_51900_31380 0.988200
R3992 n1_M2_51900_31380 n1_M2_52980_31380 0.988200
R3993 n1_M2_52980_31380 n1_M2_54060_31380 0.988200
R3994 n1_M2_54060_31380 n1_M2_55140_31380 0.988200
R3995 n1_M2_55140_31380 n1_M2_56220_31380 0.988200
R3996 n1_M2_56220_31380 n1_M2_57300_31380 0.988200
R3997 n1_M2_57300_31380 n1_M2_58380_31380 0.988200
R3998 n1_M2_58380_31380 n1_M2_59460_31380 0.988200
R3999 n1_M2_59460_31380 n1_M2_60540_31380 0.988200
R4000 n1_M2_60540_31380 n1_M2_61620_31380 0.988200
R4001 n1_M2_61620_31380 n1_M2_62700_31380 0.988200
R4002 n1_M2_62700_31380 n1_M2_63780_31380 0.988200
R4003 n1_M2_63780_31380 n1_M2_64860_31380 0.988200
R4004 n1_M2_64860_31380 n1_M2_65940_31380 0.988200
R4005 n1_M2_65940_31380 n1_M2_67020_31380 0.988200
R4006 n1_M2_67020_31380 n1_M2_68100_31380 0.988200
R4007 n1_M2_68100_31380 n1_M2_69180_31380 0.988200
R4008 n1_M2_69180_31380 n1_M2_70260_31380 0.988200
R4009 n1_M2_70260_31380 n1_M2_71340_31380 0.988200
R4010 n1_M2_71340_31380 n1_M2_72420_31380 0.988200
R4011 n1_M2_72420_31380 n1_M2_73500_31380 0.988200
R4012 n1_M2_73500_31380 n1_M2_74580_31380 0.988200
R4013 n1_M2_74580_31380 n1_M2_75660_31380 0.988200
R4014 n1_M2_75660_31380 n1_M2_76740_31380 0.988200
R4015 n1_M2_76740_31380 n1_M2_77820_31380 0.988200
R4016 n1_M2_77820_31380 n1_M2_78900_31380 0.988200
R4017 n1_M2_78900_31380 n1_M2_79980_31380 0.988200
R4018 n1_M2_79980_31380 n1_M2_81060_31380 0.988200
R4019 n1_M2_81060_31380 n1_M2_82140_31380 0.988200
R4020 n1_M2_82140_31380 n1_M2_83220_31380 0.988200
R4021 n1_M2_83220_31380 n1_M2_84300_31380 0.988200
R4022 n1_M2_84300_31380 n1_M2_85380_31380 0.988200
R4023 n1_M2_85380_31380 n1_M2_86460_31380 0.988200
R4024 n1_M2_86460_31380 n1_M2_87540_31380 0.988200
R4025 n1_M2_87540_31380 n1_M2_88620_31380 0.988200
R4026 n1_M2_88620_31380 n1_M2_89700_31380 0.988200
R4027 n1_M2_89700_31380 n1_M2_90780_31380 0.988200
R4028 n1_M2_90780_31380 n1_M2_91860_31380 0.988200
R4029 n1_M2_91860_31380 n1_M2_92940_31380 0.988200
R4030 n1_M2_92940_31380 n1_M2_94020_31380 0.988200
R4031 n1_M2_94020_31380 n1_M2_95100_31380 0.988200
R4032 n1_M2_95100_31380 n1_M2_96180_31380 0.988200
R4033 n1_M2_96180_31380 n1_M2_97260_31380 0.988200
R4034 n1_M2_97260_31380 n1_M2_98340_31380 0.988200
R4035 n1_M2_98340_31380 n1_M2_99420_31380 0.988200
R4036 n1_M2_99420_31380 n1_M2_100500_31380 0.988200
R4037 n1_M2_100500_31380 n1_M2_101580_31380 0.988200
R4038 n1_M2_101580_31380 n1_M2_102660_31380 0.988200
R4039 n1_M2_102660_31380 n1_M2_103740_31380 0.988200
R4040 n1_M2_103740_31380 n1_M2_104820_31380 0.988200
R4041 n1_M2_104820_31380 n1_M2_105900_31380 0.988200
R4042 n1_M2_105900_31380 n1_M2_106980_31380 0.988200
R4043 n1_M2_106980_31380 n1_M2_108060_31380 0.988200
R4044 n1_M2_108060_31380 n1_M2_109140_31380 0.988200
R4045 n1_M2_109140_31380 n1_M2_110220_31380 0.988200
R4046 n1_M2_110220_31380 n1_M2_111300_31380 0.988200
R4047 n1_M2_111300_31380 n1_M2_112380_31380 0.988200
R4048 n1_M2_112380_31380 n1_M2_113460_31380 0.988200
R4049 n1_M2_113460_31380 n1_M2_114540_31380 0.988200
R4050 n1_M2_114540_31380 n1_M2_115620_31380 0.988200
R4051 n1_M2_115620_31380 n1_M2_116700_31380 0.988200
R4052 n1_M2_116700_31380 n1_M2_117780_31380 0.988200
R4053 n1_M2_117780_31380 n1_M2_118860_31380 0.988200
R4054 n1_M2_118860_31380 n1_M2_119940_31380 0.988200
R4055 n1_M2_119940_31380 n1_M2_121020_31380 0.988200
R4056 n1_M2_121020_31380 n1_M2_122100_31380 0.988200
R4057 n1_M2_122100_31380 n1_M2_123180_31380 0.988200
R4058 n1_M2_123180_31380 n1_M2_124260_31380 0.988200
R4059 n1_M2_124260_31380 n1_M2_125340_31380 0.988200
R4060 n1_M2_125340_31380 n1_M2_126420_31380 0.988200
R4061 n1_M2_126420_31380 n1_M2_127500_31380 0.988200
R4062 n1_M2_127500_31380 n1_M2_128580_31380 0.988200
R4063 n1_M2_128580_31380 n1_M2_129660_31380 0.988200
R4064 n1_M2_129660_31380 n1_M2_130740_31380 0.988200
R4065 n1_M2_130740_31380 n1_M2_131820_31380 0.988200
R4066 n1_M2_131820_31380 n1_M2_132900_31380 0.988200
R4067 n1_M2_132900_31380 n1_M2_133980_31380 0.988200
R4068 n1_M2_133980_31380 n1_M2_135060_31380 0.988200
R4069 n1_M2_135060_31380 n1_M2_136140_31380 0.988200
R4070 n1_M2_136140_31380 n1_M2_137220_31380 0.988200
R4071 n1_M2_137220_31380 n1_M2_138300_31380 0.988200
R4072 n1_M2_138300_31380 n1_M2_139380_31380 0.988200
R4073 n1_M2_139380_31380 n1_M2_140460_31380 0.988200
R4074 n1_M2_140460_31380 n1_M2_141540_31380 0.988200
R4075 n1_M2_141540_31380 n1_M2_142620_31380 0.988200
R4076 n1_M2_142620_31380 n1_M2_143700_31380 0.988200
R4077 n1_M2_143700_31380 n1_M2_144780_31380 0.988200
R4078 n1_M2_144780_31380 n1_M2_145860_31380 0.988200
R4079 n1_M2_145860_31380 n1_M2_146940_31380 0.988200
R4080 n1_M2_60_32460 n1_M2_1140_32460 0.988200
R4081 n1_M2_1140_32460 n1_M2_2220_32460 0.988200
R4082 n1_M2_2220_32460 n1_M2_3300_32460 0.988200
R4083 n1_M2_3300_32460 n1_M2_4380_32460 0.988200
R4084 n1_M2_4380_32460 n1_M2_5460_32460 0.988200
R4085 n1_M2_5460_32460 n1_M2_6540_32460 0.988200
R4086 n1_M2_6540_32460 n1_M2_7620_32460 0.988200
R4087 n1_M2_7620_32460 n1_M2_8700_32460 0.988200
R4088 n1_M2_8700_32460 n1_M2_9780_32460 0.988200
R4089 n1_M2_9780_32460 n1_M2_10860_32460 0.988200
R4090 n1_M2_10860_32460 n1_M2_11940_32460 0.988200
R4091 n1_M2_11940_32460 n1_M2_13020_32460 0.988200
R4092 n1_M2_13020_32460 n1_M2_14100_32460 0.988200
R4093 n1_M2_14100_32460 n1_M2_15180_32460 0.988200
R4094 n1_M2_15180_32460 n1_M2_16260_32460 0.988200
R4095 n1_M2_16260_32460 n1_M2_17340_32460 0.988200
R4096 n1_M2_17340_32460 n1_M2_18420_32460 0.988200
R4097 n1_M2_18420_32460 n1_M2_19500_32460 0.988200
R4098 n1_M2_19500_32460 n1_M2_20580_32460 0.988200
R4099 n1_M2_20580_32460 n1_M2_21660_32460 0.988200
R4100 n1_M2_21660_32460 n1_M2_22740_32460 0.988200
R4101 n1_M2_22740_32460 n1_M2_23820_32460 0.988200
R4102 n1_M2_23820_32460 n1_M2_24900_32460 0.988200
R4103 n1_M2_24900_32460 n1_M2_25980_32460 0.988200
R4104 n1_M2_25980_32460 n1_M2_27060_32460 0.988200
R4105 n1_M2_27060_32460 n1_M2_28140_32460 0.988200
R4106 n1_M2_28140_32460 n1_M2_29220_32460 0.988200
R4107 n1_M2_29220_32460 n1_M2_30300_32460 0.988200
R4108 n1_M2_30300_32460 n1_M2_31380_32460 0.988200
R4109 n1_M2_31380_32460 n1_M2_32460_32460 0.988200
R4110 n1_M2_32460_32460 n1_M2_33540_32460 0.988200
R4111 n1_M2_33540_32460 n1_M2_34620_32460 0.988200
R4112 n1_M2_34620_32460 n1_M2_35700_32460 0.988200
R4113 n1_M2_35700_32460 n1_M2_36780_32460 0.988200
R4114 n1_M2_36780_32460 n1_M2_37860_32460 0.988200
R4115 n1_M2_37860_32460 n1_M2_38940_32460 0.988200
R4116 n1_M2_38940_32460 n1_M2_40020_32460 0.988200
R4117 n1_M2_40020_32460 n1_M2_41100_32460 0.988200
R4118 n1_M2_41100_32460 n1_M2_42180_32460 0.988200
R4119 n1_M2_42180_32460 n1_M2_43260_32460 0.988200
R4120 n1_M2_43260_32460 n1_M2_44340_32460 0.988200
R4121 n1_M2_44340_32460 n1_M2_45420_32460 0.988200
R4122 n1_M2_45420_32460 n1_M2_46500_32460 0.988200
R4123 n1_M2_46500_32460 n1_M2_47580_32460 0.988200
R4124 n1_M2_47580_32460 n1_M2_48660_32460 0.988200
R4125 n1_M2_48660_32460 n1_M2_49740_32460 0.988200
R4126 n1_M2_49740_32460 n1_M2_50820_32460 0.988200
R4127 n1_M2_50820_32460 n1_M2_51900_32460 0.988200
R4128 n1_M2_51900_32460 n1_M2_52980_32460 0.988200
R4129 n1_M2_52980_32460 n1_M2_54060_32460 0.988200
R4130 n1_M2_54060_32460 n1_M2_55140_32460 0.988200
R4131 n1_M2_55140_32460 n1_M2_56220_32460 0.988200
R4132 n1_M2_56220_32460 n1_M2_57300_32460 0.988200
R4133 n1_M2_57300_32460 n1_M2_58380_32460 0.988200
R4134 n1_M2_58380_32460 n1_M2_59460_32460 0.988200
R4135 n1_M2_59460_32460 n1_M2_60540_32460 0.988200
R4136 n1_M2_60540_32460 n1_M2_61620_32460 0.988200
R4137 n1_M2_61620_32460 n1_M2_62700_32460 0.988200
R4138 n1_M2_62700_32460 n1_M2_63780_32460 0.988200
R4139 n1_M2_63780_32460 n1_M2_64860_32460 0.988200
R4140 n1_M2_64860_32460 n1_M2_65940_32460 0.988200
R4141 n1_M2_65940_32460 n1_M2_67020_32460 0.988200
R4142 n1_M2_67020_32460 n1_M2_68100_32460 0.988200
R4143 n1_M2_68100_32460 n1_M2_69180_32460 0.988200
R4144 n1_M2_69180_32460 n1_M2_70260_32460 0.988200
R4145 n1_M2_70260_32460 n1_M2_71340_32460 0.988200
R4146 n1_M2_71340_32460 n1_M2_72420_32460 0.988200
R4147 n1_M2_72420_32460 n1_M2_73500_32460 0.988200
R4148 n1_M2_73500_32460 n1_M2_74580_32460 0.988200
R4149 n1_M2_74580_32460 n1_M2_75660_32460 0.988200
R4150 n1_M2_75660_32460 n1_M2_76740_32460 0.988200
R4151 n1_M2_76740_32460 n1_M2_77820_32460 0.988200
R4152 n1_M2_77820_32460 n1_M2_78900_32460 0.988200
R4153 n1_M2_78900_32460 n1_M2_79980_32460 0.988200
R4154 n1_M2_79980_32460 n1_M2_81060_32460 0.988200
R4155 n1_M2_81060_32460 n1_M2_82140_32460 0.988200
R4156 n1_M2_82140_32460 n1_M2_83220_32460 0.988200
R4157 n1_M2_83220_32460 n1_M2_84300_32460 0.988200
R4158 n1_M2_84300_32460 n1_M2_85380_32460 0.988200
R4159 n1_M2_85380_32460 n1_M2_86460_32460 0.988200
R4160 n1_M2_86460_32460 n1_M2_87540_32460 0.988200
R4161 n1_M2_87540_32460 n1_M2_88620_32460 0.988200
R4162 n1_M2_88620_32460 n1_M2_89700_32460 0.988200
R4163 n1_M2_89700_32460 n1_M2_90780_32460 0.988200
R4164 n1_M2_90780_32460 n1_M2_91860_32460 0.988200
R4165 n1_M2_91860_32460 n1_M2_92940_32460 0.988200
R4166 n1_M2_92940_32460 n1_M2_94020_32460 0.988200
R4167 n1_M2_94020_32460 n1_M2_95100_32460 0.988200
R4168 n1_M2_95100_32460 n1_M2_96180_32460 0.988200
R4169 n1_M2_96180_32460 n1_M2_97260_32460 0.988200
R4170 n1_M2_97260_32460 n1_M2_98340_32460 0.988200
R4171 n1_M2_98340_32460 n1_M2_99420_32460 0.988200
R4172 n1_M2_99420_32460 n1_M2_100500_32460 0.988200
R4173 n1_M2_100500_32460 n1_M2_101580_32460 0.988200
R4174 n1_M2_101580_32460 n1_M2_102660_32460 0.988200
R4175 n1_M2_102660_32460 n1_M2_103740_32460 0.988200
R4176 n1_M2_103740_32460 n1_M2_104820_32460 0.988200
R4177 n1_M2_104820_32460 n1_M2_105900_32460 0.988200
R4178 n1_M2_105900_32460 n1_M2_106980_32460 0.988200
R4179 n1_M2_106980_32460 n1_M2_108060_32460 0.988200
R4180 n1_M2_108060_32460 n1_M2_109140_32460 0.988200
R4181 n1_M2_109140_32460 n1_M2_110220_32460 0.988200
R4182 n1_M2_110220_32460 n1_M2_111300_32460 0.988200
R4183 n1_M2_111300_32460 n1_M2_112380_32460 0.988200
R4184 n1_M2_112380_32460 n1_M2_113460_32460 0.988200
R4185 n1_M2_113460_32460 n1_M2_114540_32460 0.988200
R4186 n1_M2_114540_32460 n1_M2_115620_32460 0.988200
R4187 n1_M2_115620_32460 n1_M2_116700_32460 0.988200
R4188 n1_M2_116700_32460 n1_M2_117780_32460 0.988200
R4189 n1_M2_117780_32460 n1_M2_118860_32460 0.988200
R4190 n1_M2_118860_32460 n1_M2_119940_32460 0.988200
R4191 n1_M2_119940_32460 n1_M2_121020_32460 0.988200
R4192 n1_M2_121020_32460 n1_M2_122100_32460 0.988200
R4193 n1_M2_122100_32460 n1_M2_123180_32460 0.988200
R4194 n1_M2_123180_32460 n1_M2_124260_32460 0.988200
R4195 n1_M2_124260_32460 n1_M2_125340_32460 0.988200
R4196 n1_M2_125340_32460 n1_M2_126420_32460 0.988200
R4197 n1_M2_126420_32460 n1_M2_127500_32460 0.988200
R4198 n1_M2_127500_32460 n1_M2_128580_32460 0.988200
R4199 n1_M2_128580_32460 n1_M2_129660_32460 0.988200
R4200 n1_M2_129660_32460 n1_M2_130740_32460 0.988200
R4201 n1_M2_130740_32460 n1_M2_131820_32460 0.988200
R4202 n1_M2_131820_32460 n1_M2_132900_32460 0.988200
R4203 n1_M2_132900_32460 n1_M2_133980_32460 0.988200
R4204 n1_M2_133980_32460 n1_M2_135060_32460 0.988200
R4205 n1_M2_135060_32460 n1_M2_136140_32460 0.988200
R4206 n1_M2_136140_32460 n1_M2_137220_32460 0.988200
R4207 n1_M2_137220_32460 n1_M2_138300_32460 0.988200
R4208 n1_M2_138300_32460 n1_M2_139380_32460 0.988200
R4209 n1_M2_139380_32460 n1_M2_140460_32460 0.988200
R4210 n1_M2_140460_32460 n1_M2_141540_32460 0.988200
R4211 n1_M2_141540_32460 n1_M2_142620_32460 0.988200
R4212 n1_M2_142620_32460 n1_M2_143700_32460 0.988200
R4213 n1_M2_143700_32460 n1_M2_144780_32460 0.988200
R4214 n1_M2_144780_32460 n1_M2_145860_32460 0.988200
R4215 n1_M2_145860_32460 n1_M2_146940_32460 0.988200
R4216 n1_M2_60_33540 n1_M2_1140_33540 0.988200
R4217 n1_M2_1140_33540 n1_M2_2220_33540 0.988200
R4218 n1_M2_2220_33540 n1_M2_3300_33540 0.988200
R4219 n1_M2_3300_33540 n1_M2_4380_33540 0.988200
R4220 n1_M2_4380_33540 n1_M2_5460_33540 0.988200
R4221 n1_M2_5460_33540 n1_M2_6540_33540 0.988200
R4222 n1_M2_6540_33540 n1_M2_7620_33540 0.988200
R4223 n1_M2_7620_33540 n1_M2_8700_33540 0.988200
R4224 n1_M2_8700_33540 n1_M2_9780_33540 0.988200
R4225 n1_M2_9780_33540 n1_M2_10860_33540 0.988200
R4226 n1_M2_10860_33540 n1_M2_11940_33540 0.988200
R4227 n1_M2_11940_33540 n1_M2_13020_33540 0.988200
R4228 n1_M2_13020_33540 n1_M2_14100_33540 0.988200
R4229 n1_M2_14100_33540 n1_M2_15180_33540 0.988200
R4230 n1_M2_15180_33540 n1_M2_16260_33540 0.988200
R4231 n1_M2_16260_33540 n1_M2_17340_33540 0.988200
R4232 n1_M2_17340_33540 n1_M2_18420_33540 0.988200
R4233 n1_M2_18420_33540 n1_M2_19500_33540 0.988200
R4234 n1_M2_19500_33540 n1_M2_20580_33540 0.988200
R4235 n1_M2_20580_33540 n1_M2_21660_33540 0.988200
R4236 n1_M2_21660_33540 n1_M2_22740_33540 0.988200
R4237 n1_M2_22740_33540 n1_M2_23820_33540 0.988200
R4238 n1_M2_23820_33540 n1_M2_24900_33540 0.988200
R4239 n1_M2_24900_33540 n1_M2_25980_33540 0.988200
R4240 n1_M2_25980_33540 n1_M2_27060_33540 0.988200
R4241 n1_M2_27060_33540 n1_M2_28140_33540 0.988200
R4242 n1_M2_28140_33540 n1_M2_29220_33540 0.988200
R4243 n1_M2_29220_33540 n1_M2_30300_33540 0.988200
R4244 n1_M2_30300_33540 n1_M2_31380_33540 0.988200
R4245 n1_M2_31380_33540 n1_M2_32460_33540 0.988200
R4246 n1_M2_32460_33540 n1_M2_33540_33540 0.988200
R4247 n1_M2_33540_33540 n1_M2_34620_33540 0.988200
R4248 n1_M2_34620_33540 n1_M2_35700_33540 0.988200
R4249 n1_M2_35700_33540 n1_M2_36780_33540 0.988200
R4250 n1_M2_36780_33540 n1_M2_37860_33540 0.988200
R4251 n1_M2_37860_33540 n1_M2_38940_33540 0.988200
R4252 n1_M2_38940_33540 n1_M2_40020_33540 0.988200
R4253 n1_M2_40020_33540 n1_M2_41100_33540 0.988200
R4254 n1_M2_41100_33540 n1_M2_42180_33540 0.988200
R4255 n1_M2_42180_33540 n1_M2_43260_33540 0.988200
R4256 n1_M2_43260_33540 n1_M2_44340_33540 0.988200
R4257 n1_M2_44340_33540 n1_M2_45420_33540 0.988200
R4258 n1_M2_45420_33540 n1_M2_46500_33540 0.988200
R4259 n1_M2_46500_33540 n1_M2_47580_33540 0.988200
R4260 n1_M2_47580_33540 n1_M2_48660_33540 0.988200
R4261 n1_M2_48660_33540 n1_M2_49740_33540 0.988200
R4262 n1_M2_49740_33540 n1_M2_50820_33540 0.988200
R4263 n1_M2_50820_33540 n1_M2_51900_33540 0.988200
R4264 n1_M2_51900_33540 n1_M2_52980_33540 0.988200
R4265 n1_M2_52980_33540 n1_M2_54060_33540 0.988200
R4266 n1_M2_54060_33540 n1_M2_55140_33540 0.988200
R4267 n1_M2_55140_33540 n1_M2_56220_33540 0.988200
R4268 n1_M2_56220_33540 n1_M2_57300_33540 0.988200
R4269 n1_M2_57300_33540 n1_M2_58380_33540 0.988200
R4270 n1_M2_58380_33540 n1_M2_59460_33540 0.988200
R4271 n1_M2_59460_33540 n1_M2_60540_33540 0.988200
R4272 n1_M2_60540_33540 n1_M2_61620_33540 0.988200
R4273 n1_M2_61620_33540 n1_M2_62700_33540 0.988200
R4274 n1_M2_62700_33540 n1_M2_63780_33540 0.988200
R4275 n1_M2_63780_33540 n1_M2_64860_33540 0.988200
R4276 n1_M2_64860_33540 n1_M2_65940_33540 0.988200
R4277 n1_M2_65940_33540 n1_M2_67020_33540 0.988200
R4278 n1_M2_67020_33540 n1_M2_68100_33540 0.988200
R4279 n1_M2_68100_33540 n1_M2_69180_33540 0.988200
R4280 n1_M2_69180_33540 n1_M2_70260_33540 0.988200
R4281 n1_M2_70260_33540 n1_M2_71340_33540 0.988200
R4282 n1_M2_71340_33540 n1_M2_72420_33540 0.988200
R4283 n1_M2_72420_33540 n1_M2_73500_33540 0.988200
R4284 n1_M2_73500_33540 n1_M2_74580_33540 0.988200
R4285 n1_M2_74580_33540 n1_M2_75660_33540 0.988200
R4286 n1_M2_75660_33540 n1_M2_76740_33540 0.988200
R4287 n1_M2_76740_33540 n1_M2_77820_33540 0.988200
R4288 n1_M2_77820_33540 n1_M2_78900_33540 0.988200
R4289 n1_M2_78900_33540 n1_M2_79980_33540 0.988200
R4290 n1_M2_79980_33540 n1_M2_81060_33540 0.988200
R4291 n1_M2_81060_33540 n1_M2_82140_33540 0.988200
R4292 n1_M2_82140_33540 n1_M2_83220_33540 0.988200
R4293 n1_M2_83220_33540 n1_M2_84300_33540 0.988200
R4294 n1_M2_84300_33540 n1_M2_85380_33540 0.988200
R4295 n1_M2_85380_33540 n1_M2_86460_33540 0.988200
R4296 n1_M2_86460_33540 n1_M2_87540_33540 0.988200
R4297 n1_M2_87540_33540 n1_M2_88620_33540 0.988200
R4298 n1_M2_88620_33540 n1_M2_89700_33540 0.988200
R4299 n1_M2_89700_33540 n1_M2_90780_33540 0.988200
R4300 n1_M2_90780_33540 n1_M2_91860_33540 0.988200
R4301 n1_M2_91860_33540 n1_M2_92940_33540 0.988200
R4302 n1_M2_92940_33540 n1_M2_94020_33540 0.988200
R4303 n1_M2_94020_33540 n1_M2_95100_33540 0.988200
R4304 n1_M2_95100_33540 n1_M2_96180_33540 0.988200
R4305 n1_M2_96180_33540 n1_M2_97260_33540 0.988200
R4306 n1_M2_97260_33540 n1_M2_98340_33540 0.988200
R4307 n1_M2_98340_33540 n1_M2_99420_33540 0.988200
R4308 n1_M2_99420_33540 n1_M2_100500_33540 0.988200
R4309 n1_M2_100500_33540 n1_M2_101580_33540 0.988200
R4310 n1_M2_101580_33540 n1_M2_102660_33540 0.988200
R4311 n1_M2_102660_33540 n1_M2_103740_33540 0.988200
R4312 n1_M2_103740_33540 n1_M2_104820_33540 0.988200
R4313 n1_M2_104820_33540 n1_M2_105900_33540 0.988200
R4314 n1_M2_105900_33540 n1_M2_106980_33540 0.988200
R4315 n1_M2_106980_33540 n1_M2_108060_33540 0.988200
R4316 n1_M2_108060_33540 n1_M2_109140_33540 0.988200
R4317 n1_M2_109140_33540 n1_M2_110220_33540 0.988200
R4318 n1_M2_110220_33540 n1_M2_111300_33540 0.988200
R4319 n1_M2_111300_33540 n1_M2_112380_33540 0.988200
R4320 n1_M2_112380_33540 n1_M2_113460_33540 0.988200
R4321 n1_M2_113460_33540 n1_M2_114540_33540 0.988200
R4322 n1_M2_114540_33540 n1_M2_115620_33540 0.988200
R4323 n1_M2_115620_33540 n1_M2_116700_33540 0.988200
R4324 n1_M2_116700_33540 n1_M2_117780_33540 0.988200
R4325 n1_M2_117780_33540 n1_M2_118860_33540 0.988200
R4326 n1_M2_118860_33540 n1_M2_119940_33540 0.988200
R4327 n1_M2_119940_33540 n1_M2_121020_33540 0.988200
R4328 n1_M2_121020_33540 n1_M2_122100_33540 0.988200
R4329 n1_M2_122100_33540 n1_M2_123180_33540 0.988200
R4330 n1_M2_123180_33540 n1_M2_124260_33540 0.988200
R4331 n1_M2_124260_33540 n1_M2_125340_33540 0.988200
R4332 n1_M2_125340_33540 n1_M2_126420_33540 0.988200
R4333 n1_M2_126420_33540 n1_M2_127500_33540 0.988200
R4334 n1_M2_127500_33540 n1_M2_128580_33540 0.988200
R4335 n1_M2_128580_33540 n1_M2_129660_33540 0.988200
R4336 n1_M2_129660_33540 n1_M2_130740_33540 0.988200
R4337 n1_M2_130740_33540 n1_M2_131820_33540 0.988200
R4338 n1_M2_131820_33540 n1_M2_132900_33540 0.988200
R4339 n1_M2_132900_33540 n1_M2_133980_33540 0.988200
R4340 n1_M2_133980_33540 n1_M2_135060_33540 0.988200
R4341 n1_M2_135060_33540 n1_M2_136140_33540 0.988200
R4342 n1_M2_136140_33540 n1_M2_137220_33540 0.988200
R4343 n1_M2_137220_33540 n1_M2_138300_33540 0.988200
R4344 n1_M2_138300_33540 n1_M2_139380_33540 0.988200
R4345 n1_M2_139380_33540 n1_M2_140460_33540 0.988200
R4346 n1_M2_140460_33540 n1_M2_141540_33540 0.988200
R4347 n1_M2_141540_33540 n1_M2_142620_33540 0.988200
R4348 n1_M2_142620_33540 n1_M2_143700_33540 0.988200
R4349 n1_M2_143700_33540 n1_M2_144780_33540 0.988200
R4350 n1_M2_144780_33540 n1_M2_145860_33540 0.988200
R4351 n1_M2_145860_33540 n1_M2_146940_33540 0.988200
R4352 n1_M2_60_34620 n1_M2_1140_34620 0.988200
R4353 n1_M2_1140_34620 n1_M2_2220_34620 0.988200
R4354 n1_M2_2220_34620 n1_M2_3300_34620 0.988200
R4355 n1_M2_3300_34620 n1_M2_4380_34620 0.988200
R4356 n1_M2_4380_34620 n1_M2_5460_34620 0.988200
R4357 n1_M2_5460_34620 n1_M2_6540_34620 0.988200
R4358 n1_M2_6540_34620 n1_M2_7620_34620 0.988200
R4359 n1_M2_7620_34620 n1_M2_8700_34620 0.988200
R4360 n1_M2_8700_34620 n1_M2_9780_34620 0.988200
R4361 n1_M2_9780_34620 n1_M2_10860_34620 0.988200
R4362 n1_M2_10860_34620 n1_M2_11940_34620 0.988200
R4363 n1_M2_11940_34620 n1_M2_13020_34620 0.988200
R4364 n1_M2_13020_34620 n1_M2_14100_34620 0.988200
R4365 n1_M2_14100_34620 n1_M2_15180_34620 0.988200
R4366 n1_M2_15180_34620 n1_M2_16260_34620 0.988200
R4367 n1_M2_16260_34620 n1_M2_17340_34620 0.988200
R4368 n1_M2_17340_34620 n1_M2_18420_34620 0.988200
R4369 n1_M2_18420_34620 n1_M2_19500_34620 0.988200
R4370 n1_M2_19500_34620 n1_M2_20580_34620 0.988200
R4371 n1_M2_20580_34620 n1_M2_21660_34620 0.988200
R4372 n1_M2_21660_34620 n1_M2_22740_34620 0.988200
R4373 n1_M2_22740_34620 n1_M2_23820_34620 0.988200
R4374 n1_M2_23820_34620 n1_M2_24900_34620 0.988200
R4375 n1_M2_24900_34620 n1_M2_25980_34620 0.988200
R4376 n1_M2_25980_34620 n1_M2_27060_34620 0.988200
R4377 n1_M2_27060_34620 n1_M2_28140_34620 0.988200
R4378 n1_M2_28140_34620 n1_M2_29220_34620 0.988200
R4379 n1_M2_29220_34620 n1_M2_30300_34620 0.988200
R4380 n1_M2_30300_34620 n1_M2_31380_34620 0.988200
R4381 n1_M2_31380_34620 n1_M2_32460_34620 0.988200
R4382 n1_M2_32460_34620 n1_M2_33540_34620 0.988200
R4383 n1_M2_33540_34620 n1_M2_34620_34620 0.988200
R4384 n1_M2_34620_34620 n1_M2_35700_34620 0.988200
R4385 n1_M2_35700_34620 n1_M2_36780_34620 0.988200
R4386 n1_M2_36780_34620 n1_M2_37860_34620 0.988200
R4387 n1_M2_37860_34620 n1_M2_38940_34620 0.988200
R4388 n1_M2_38940_34620 n1_M2_40020_34620 0.988200
R4389 n1_M2_40020_34620 n1_M2_41100_34620 0.988200
R4390 n1_M2_41100_34620 n1_M2_42180_34620 0.988200
R4391 n1_M2_42180_34620 n1_M2_43260_34620 0.988200
R4392 n1_M2_43260_34620 n1_M2_44340_34620 0.988200
R4393 n1_M2_44340_34620 n1_M2_45420_34620 0.988200
R4394 n1_M2_45420_34620 n1_M2_46500_34620 0.988200
R4395 n1_M2_46500_34620 n1_M2_47580_34620 0.988200
R4396 n1_M2_47580_34620 n1_M2_48660_34620 0.988200
R4397 n1_M2_48660_34620 n1_M2_49740_34620 0.988200
R4398 n1_M2_49740_34620 n1_M2_50820_34620 0.988200
R4399 n1_M2_50820_34620 n1_M2_51900_34620 0.988200
R4400 n1_M2_51900_34620 n1_M2_52980_34620 0.988200
R4401 n1_M2_52980_34620 n1_M2_54060_34620 0.988200
R4402 n1_M2_54060_34620 n1_M2_55140_34620 0.988200
R4403 n1_M2_55140_34620 n1_M2_56220_34620 0.988200
R4404 n1_M2_56220_34620 n1_M2_57300_34620 0.988200
R4405 n1_M2_57300_34620 n1_M2_58380_34620 0.988200
R4406 n1_M2_58380_34620 n1_M2_59460_34620 0.988200
R4407 n1_M2_59460_34620 n1_M2_60540_34620 0.988200
R4408 n1_M2_60540_34620 n1_M2_61620_34620 0.988200
R4409 n1_M2_61620_34620 n1_M2_62700_34620 0.988200
R4410 n1_M2_62700_34620 n1_M2_63780_34620 0.988200
R4411 n1_M2_63780_34620 n1_M2_64860_34620 0.988200
R4412 n1_M2_64860_34620 n1_M2_65940_34620 0.988200
R4413 n1_M2_65940_34620 n1_M2_67020_34620 0.988200
R4414 n1_M2_67020_34620 n1_M2_68100_34620 0.988200
R4415 n1_M2_68100_34620 n1_M2_69180_34620 0.988200
R4416 n1_M2_69180_34620 n1_M2_70260_34620 0.988200
R4417 n1_M2_70260_34620 n1_M2_71340_34620 0.988200
R4418 n1_M2_71340_34620 n1_M2_72420_34620 0.988200
R4419 n1_M2_72420_34620 n1_M2_73500_34620 0.988200
R4420 n1_M2_73500_34620 n1_M2_74580_34620 0.988200
R4421 n1_M2_74580_34620 n1_M2_75660_34620 0.988200
R4422 n1_M2_75660_34620 n1_M2_76740_34620 0.988200
R4423 n1_M2_76740_34620 n1_M2_77820_34620 0.988200
R4424 n1_M2_77820_34620 n1_M2_78900_34620 0.988200
R4425 n1_M2_78900_34620 n1_M2_79980_34620 0.988200
R4426 n1_M2_79980_34620 n1_M2_81060_34620 0.988200
R4427 n1_M2_81060_34620 n1_M2_82140_34620 0.988200
R4428 n1_M2_82140_34620 n1_M2_83220_34620 0.988200
R4429 n1_M2_83220_34620 n1_M2_84300_34620 0.988200
R4430 n1_M2_84300_34620 n1_M2_85380_34620 0.988200
R4431 n1_M2_85380_34620 n1_M2_86460_34620 0.988200
R4432 n1_M2_86460_34620 n1_M2_87540_34620 0.988200
R4433 n1_M2_87540_34620 n1_M2_88620_34620 0.988200
R4434 n1_M2_88620_34620 n1_M2_89700_34620 0.988200
R4435 n1_M2_89700_34620 n1_M2_90780_34620 0.988200
R4436 n1_M2_90780_34620 n1_M2_91860_34620 0.988200
R4437 n1_M2_91860_34620 n1_M2_92940_34620 0.988200
R4438 n1_M2_92940_34620 n1_M2_94020_34620 0.988200
R4439 n1_M2_94020_34620 n1_M2_95100_34620 0.988200
R4440 n1_M2_95100_34620 n1_M2_96180_34620 0.988200
R4441 n1_M2_96180_34620 n1_M2_97260_34620 0.988200
R4442 n1_M2_97260_34620 n1_M2_98340_34620 0.988200
R4443 n1_M2_98340_34620 n1_M2_99420_34620 0.988200
R4444 n1_M2_99420_34620 n1_M2_100500_34620 0.988200
R4445 n1_M2_100500_34620 n1_M2_101580_34620 0.988200
R4446 n1_M2_101580_34620 n1_M2_102660_34620 0.988200
R4447 n1_M2_102660_34620 n1_M2_103740_34620 0.988200
R4448 n1_M2_103740_34620 n1_M2_104820_34620 0.988200
R4449 n1_M2_104820_34620 n1_M2_105900_34620 0.988200
R4450 n1_M2_105900_34620 n1_M2_106980_34620 0.988200
R4451 n1_M2_106980_34620 n1_M2_108060_34620 0.988200
R4452 n1_M2_108060_34620 n1_M2_109140_34620 0.988200
R4453 n1_M2_109140_34620 n1_M2_110220_34620 0.988200
R4454 n1_M2_110220_34620 n1_M2_111300_34620 0.988200
R4455 n1_M2_111300_34620 n1_M2_112380_34620 0.988200
R4456 n1_M2_112380_34620 n1_M2_113460_34620 0.988200
R4457 n1_M2_113460_34620 n1_M2_114540_34620 0.988200
R4458 n1_M2_114540_34620 n1_M2_115620_34620 0.988200
R4459 n1_M2_115620_34620 n1_M2_116700_34620 0.988200
R4460 n1_M2_116700_34620 n1_M2_117780_34620 0.988200
R4461 n1_M2_117780_34620 n1_M2_118860_34620 0.988200
R4462 n1_M2_118860_34620 n1_M2_119940_34620 0.988200
R4463 n1_M2_119940_34620 n1_M2_121020_34620 0.988200
R4464 n1_M2_121020_34620 n1_M2_122100_34620 0.988200
R4465 n1_M2_122100_34620 n1_M2_123180_34620 0.988200
R4466 n1_M2_123180_34620 n1_M2_124260_34620 0.988200
R4467 n1_M2_124260_34620 n1_M2_125340_34620 0.988200
R4468 n1_M2_125340_34620 n1_M2_126420_34620 0.988200
R4469 n1_M2_126420_34620 n1_M2_127500_34620 0.988200
R4470 n1_M2_127500_34620 n1_M2_128580_34620 0.988200
R4471 n1_M2_128580_34620 n1_M2_129660_34620 0.988200
R4472 n1_M2_129660_34620 n1_M2_130740_34620 0.988200
R4473 n1_M2_130740_34620 n1_M2_131820_34620 0.988200
R4474 n1_M2_131820_34620 n1_M2_132900_34620 0.988200
R4475 n1_M2_132900_34620 n1_M2_133980_34620 0.988200
R4476 n1_M2_133980_34620 n1_M2_135060_34620 0.988200
R4477 n1_M2_135060_34620 n1_M2_136140_34620 0.988200
R4478 n1_M2_136140_34620 n1_M2_137220_34620 0.988200
R4479 n1_M2_137220_34620 n1_M2_138300_34620 0.988200
R4480 n1_M2_138300_34620 n1_M2_139380_34620 0.988200
R4481 n1_M2_139380_34620 n1_M2_140460_34620 0.988200
R4482 n1_M2_140460_34620 n1_M2_141540_34620 0.988200
R4483 n1_M2_141540_34620 n1_M2_142620_34620 0.988200
R4484 n1_M2_142620_34620 n1_M2_143700_34620 0.988200
R4485 n1_M2_143700_34620 n1_M2_144780_34620 0.988200
R4486 n1_M2_144780_34620 n1_M2_145860_34620 0.988200
R4487 n1_M2_145860_34620 n1_M2_146940_34620 0.988200
R4488 n1_M2_60_35700 n1_M2_1140_35700 0.988200
R4489 n1_M2_1140_35700 n1_M2_2220_35700 0.988200
R4490 n1_M2_2220_35700 n1_M2_3300_35700 0.988200
R4491 n1_M2_3300_35700 n1_M2_4380_35700 0.988200
R4492 n1_M2_4380_35700 n1_M2_5460_35700 0.988200
R4493 n1_M2_5460_35700 n1_M2_6540_35700 0.988200
R4494 n1_M2_6540_35700 n1_M2_7620_35700 0.988200
R4495 n1_M2_7620_35700 n1_M2_8700_35700 0.988200
R4496 n1_M2_8700_35700 n1_M2_9780_35700 0.988200
R4497 n1_M2_9780_35700 n1_M2_10860_35700 0.988200
R4498 n1_M2_10860_35700 n1_M2_11940_35700 0.988200
R4499 n1_M2_11940_35700 n1_M2_13020_35700 0.988200
R4500 n1_M2_13020_35700 n1_M2_14100_35700 0.988200
R4501 n1_M2_14100_35700 n1_M2_15180_35700 0.988200
R4502 n1_M2_15180_35700 n1_M2_16260_35700 0.988200
R4503 n1_M2_16260_35700 n1_M2_17340_35700 0.988200
R4504 n1_M2_17340_35700 n1_M2_18420_35700 0.988200
R4505 n1_M2_18420_35700 n1_M2_19500_35700 0.988200
R4506 n1_M2_19500_35700 n1_M2_20580_35700 0.988200
R4507 n1_M2_20580_35700 n1_M2_21660_35700 0.988200
R4508 n1_M2_21660_35700 n1_M2_22740_35700 0.988200
R4509 n1_M2_22740_35700 n1_M2_23820_35700 0.988200
R4510 n1_M2_23820_35700 n1_M2_24900_35700 0.988200
R4511 n1_M2_24900_35700 n1_M2_25980_35700 0.988200
R4512 n1_M2_25980_35700 n1_M2_27060_35700 0.988200
R4513 n1_M2_27060_35700 n1_M2_28140_35700 0.988200
R4514 n1_M2_28140_35700 n1_M2_29220_35700 0.988200
R4515 n1_M2_29220_35700 n1_M2_30300_35700 0.988200
R4516 n1_M2_30300_35700 n1_M2_31380_35700 0.988200
R4517 n1_M2_31380_35700 n1_M2_32460_35700 0.988200
R4518 n1_M2_32460_35700 n1_M2_33540_35700 0.988200
R4519 n1_M2_33540_35700 n1_M2_34620_35700 0.988200
R4520 n1_M2_34620_35700 n1_M2_35700_35700 0.988200
R4521 n1_M2_35700_35700 n1_M2_36780_35700 0.988200
R4522 n1_M2_36780_35700 n1_M2_37860_35700 0.988200
R4523 n1_M2_37860_35700 n1_M2_38940_35700 0.988200
R4524 n1_M2_38940_35700 n1_M2_40020_35700 0.988200
R4525 n1_M2_40020_35700 n1_M2_41100_35700 0.988200
R4526 n1_M2_41100_35700 n1_M2_42180_35700 0.988200
R4527 n1_M2_42180_35700 n1_M2_43260_35700 0.988200
R4528 n1_M2_43260_35700 n1_M2_44340_35700 0.988200
R4529 n1_M2_44340_35700 n1_M2_45420_35700 0.988200
R4530 n1_M2_45420_35700 n1_M2_46500_35700 0.988200
R4531 n1_M2_46500_35700 n1_M2_47580_35700 0.988200
R4532 n1_M2_47580_35700 n1_M2_48660_35700 0.988200
R4533 n1_M2_48660_35700 n1_M2_49740_35700 0.988200
R4534 n1_M2_49740_35700 n1_M2_50820_35700 0.988200
R4535 n1_M2_50820_35700 n1_M2_51900_35700 0.988200
R4536 n1_M2_51900_35700 n1_M2_52980_35700 0.988200
R4537 n1_M2_52980_35700 n1_M2_54060_35700 0.988200
R4538 n1_M2_54060_35700 n1_M2_55140_35700 0.988200
R4539 n1_M2_55140_35700 n1_M2_56220_35700 0.988200
R4540 n1_M2_56220_35700 n1_M2_57300_35700 0.988200
R4541 n1_M2_57300_35700 n1_M2_58380_35700 0.988200
R4542 n1_M2_58380_35700 n1_M2_59460_35700 0.988200
R4543 n1_M2_59460_35700 n1_M2_60540_35700 0.988200
R4544 n1_M2_60540_35700 n1_M2_61620_35700 0.988200
R4545 n1_M2_61620_35700 n1_M2_62700_35700 0.988200
R4546 n1_M2_62700_35700 n1_M2_63780_35700 0.988200
R4547 n1_M2_63780_35700 n1_M2_64860_35700 0.988200
R4548 n1_M2_64860_35700 n1_M2_65940_35700 0.988200
R4549 n1_M2_65940_35700 n1_M2_67020_35700 0.988200
R4550 n1_M2_67020_35700 n1_M2_68100_35700 0.988200
R4551 n1_M2_68100_35700 n1_M2_69180_35700 0.988200
R4552 n1_M2_69180_35700 n1_M2_70260_35700 0.988200
R4553 n1_M2_70260_35700 n1_M2_71340_35700 0.988200
R4554 n1_M2_71340_35700 n1_M2_72420_35700 0.988200
R4555 n1_M2_72420_35700 n1_M2_73500_35700 0.988200
R4556 n1_M2_73500_35700 n1_M2_74580_35700 0.988200
R4557 n1_M2_74580_35700 n1_M2_75660_35700 0.988200
R4558 n1_M2_75660_35700 n1_M2_76740_35700 0.988200
R4559 n1_M2_76740_35700 n1_M2_77820_35700 0.988200
R4560 n1_M2_77820_35700 n1_M2_78900_35700 0.988200
R4561 n1_M2_78900_35700 n1_M2_79980_35700 0.988200
R4562 n1_M2_79980_35700 n1_M2_81060_35700 0.988200
R4563 n1_M2_81060_35700 n1_M2_82140_35700 0.988200
R4564 n1_M2_82140_35700 n1_M2_83220_35700 0.988200
R4565 n1_M2_83220_35700 n1_M2_84300_35700 0.988200
R4566 n1_M2_84300_35700 n1_M2_85380_35700 0.988200
R4567 n1_M2_85380_35700 n1_M2_86460_35700 0.988200
R4568 n1_M2_86460_35700 n1_M2_87540_35700 0.988200
R4569 n1_M2_87540_35700 n1_M2_88620_35700 0.988200
R4570 n1_M2_88620_35700 n1_M2_89700_35700 0.988200
R4571 n1_M2_89700_35700 n1_M2_90780_35700 0.988200
R4572 n1_M2_90780_35700 n1_M2_91860_35700 0.988200
R4573 n1_M2_91860_35700 n1_M2_92940_35700 0.988200
R4574 n1_M2_92940_35700 n1_M2_94020_35700 0.988200
R4575 n1_M2_94020_35700 n1_M2_95100_35700 0.988200
R4576 n1_M2_95100_35700 n1_M2_96180_35700 0.988200
R4577 n1_M2_96180_35700 n1_M2_97260_35700 0.988200
R4578 n1_M2_97260_35700 n1_M2_98340_35700 0.988200
R4579 n1_M2_98340_35700 n1_M2_99420_35700 0.988200
R4580 n1_M2_99420_35700 n1_M2_100500_35700 0.988200
R4581 n1_M2_100500_35700 n1_M2_101580_35700 0.988200
R4582 n1_M2_101580_35700 n1_M2_102660_35700 0.988200
R4583 n1_M2_102660_35700 n1_M2_103740_35700 0.988200
R4584 n1_M2_103740_35700 n1_M2_104820_35700 0.988200
R4585 n1_M2_104820_35700 n1_M2_105900_35700 0.988200
R4586 n1_M2_105900_35700 n1_M2_106980_35700 0.988200
R4587 n1_M2_106980_35700 n1_M2_108060_35700 0.988200
R4588 n1_M2_108060_35700 n1_M2_109140_35700 0.988200
R4589 n1_M2_109140_35700 n1_M2_110220_35700 0.988200
R4590 n1_M2_110220_35700 n1_M2_111300_35700 0.988200
R4591 n1_M2_111300_35700 n1_M2_112380_35700 0.988200
R4592 n1_M2_112380_35700 n1_M2_113460_35700 0.988200
R4593 n1_M2_113460_35700 n1_M2_114540_35700 0.988200
R4594 n1_M2_114540_35700 n1_M2_115620_35700 0.988200
R4595 n1_M2_115620_35700 n1_M2_116700_35700 0.988200
R4596 n1_M2_116700_35700 n1_M2_117780_35700 0.988200
R4597 n1_M2_117780_35700 n1_M2_118860_35700 0.988200
R4598 n1_M2_118860_35700 n1_M2_119940_35700 0.988200
R4599 n1_M2_119940_35700 n1_M2_121020_35700 0.988200
R4600 n1_M2_121020_35700 n1_M2_122100_35700 0.988200
R4601 n1_M2_122100_35700 n1_M2_123180_35700 0.988200
R4602 n1_M2_123180_35700 n1_M2_124260_35700 0.988200
R4603 n1_M2_124260_35700 n1_M2_125340_35700 0.988200
R4604 n1_M2_125340_35700 n1_M2_126420_35700 0.988200
R4605 n1_M2_126420_35700 n1_M2_127500_35700 0.988200
R4606 n1_M2_127500_35700 n1_M2_128580_35700 0.988200
R4607 n1_M2_128580_35700 n1_M2_129660_35700 0.988200
R4608 n1_M2_129660_35700 n1_M2_130740_35700 0.988200
R4609 n1_M2_130740_35700 n1_M2_131820_35700 0.988200
R4610 n1_M2_131820_35700 n1_M2_132900_35700 0.988200
R4611 n1_M2_132900_35700 n1_M2_133980_35700 0.988200
R4612 n1_M2_133980_35700 n1_M2_135060_35700 0.988200
R4613 n1_M2_135060_35700 n1_M2_136140_35700 0.988200
R4614 n1_M2_136140_35700 n1_M2_137220_35700 0.988200
R4615 n1_M2_137220_35700 n1_M2_138300_35700 0.988200
R4616 n1_M2_138300_35700 n1_M2_139380_35700 0.988200
R4617 n1_M2_139380_35700 n1_M2_140460_35700 0.988200
R4618 n1_M2_140460_35700 n1_M2_141540_35700 0.988200
R4619 n1_M2_141540_35700 n1_M2_142620_35700 0.988200
R4620 n1_M2_142620_35700 n1_M2_143700_35700 0.988200
R4621 n1_M2_143700_35700 n1_M2_144780_35700 0.988200
R4622 n1_M2_144780_35700 n1_M2_145860_35700 0.988200
R4623 n1_M2_145860_35700 n1_M2_146940_35700 0.988200
R4624 n1_M2_60_36780 n1_M2_1140_36780 0.988200
R4625 n1_M2_1140_36780 n1_M2_2220_36780 0.988200
R4626 n1_M2_2220_36780 n1_M2_3300_36780 0.988200
R4627 n1_M2_3300_36780 n1_M2_4380_36780 0.988200
R4628 n1_M2_4380_36780 n1_M2_5460_36780 0.988200
R4629 n1_M2_5460_36780 n1_M2_6540_36780 0.988200
R4630 n1_M2_6540_36780 n1_M2_7620_36780 0.988200
R4631 n1_M2_7620_36780 n1_M2_8700_36780 0.988200
R4632 n1_M2_8700_36780 n1_M2_9780_36780 0.988200
R4633 n1_M2_9780_36780 n1_M2_10860_36780 0.988200
R4634 n1_M2_10860_36780 n1_M2_11940_36780 0.988200
R4635 n1_M2_11940_36780 n1_M2_13020_36780 0.988200
R4636 n1_M2_13020_36780 n1_M2_14100_36780 0.988200
R4637 n1_M2_14100_36780 n1_M2_15180_36780 0.988200
R4638 n1_M2_15180_36780 n1_M2_16260_36780 0.988200
R4639 n1_M2_16260_36780 n1_M2_17340_36780 0.988200
R4640 n1_M2_17340_36780 n1_M2_18420_36780 0.988200
R4641 n1_M2_18420_36780 n1_M2_19500_36780 0.988200
R4642 n1_M2_19500_36780 n1_M2_20580_36780 0.988200
R4643 n1_M2_20580_36780 n1_M2_21660_36780 0.988200
R4644 n1_M2_21660_36780 n1_M2_22740_36780 0.988200
R4645 n1_M2_22740_36780 n1_M2_23820_36780 0.988200
R4646 n1_M2_23820_36780 n1_M2_24900_36780 0.988200
R4647 n1_M2_24900_36780 n1_M2_25980_36780 0.988200
R4648 n1_M2_25980_36780 n1_M2_27060_36780 0.988200
R4649 n1_M2_27060_36780 n1_M2_28140_36780 0.988200
R4650 n1_M2_28140_36780 n1_M2_29220_36780 0.988200
R4651 n1_M2_29220_36780 n1_M2_30300_36780 0.988200
R4652 n1_M2_30300_36780 n1_M2_31380_36780 0.988200
R4653 n1_M2_31380_36780 n1_M2_32460_36780 0.988200
R4654 n1_M2_32460_36780 n1_M2_33540_36780 0.988200
R4655 n1_M2_33540_36780 n1_M2_34620_36780 0.988200
R4656 n1_M2_34620_36780 n1_M2_35700_36780 0.988200
R4657 n1_M2_35700_36780 n1_M2_36780_36780 0.988200
R4658 n1_M2_36780_36780 n1_M2_37860_36780 0.988200
R4659 n1_M2_37860_36780 n1_M2_38940_36780 0.988200
R4660 n1_M2_38940_36780 n1_M2_40020_36780 0.988200
R4661 n1_M2_40020_36780 n1_M2_41100_36780 0.988200
R4662 n1_M2_41100_36780 n1_M2_42180_36780 0.988200
R4663 n1_M2_42180_36780 n1_M2_43260_36780 0.988200
R4664 n1_M2_43260_36780 n1_M2_44340_36780 0.988200
R4665 n1_M2_44340_36780 n1_M2_45420_36780 0.988200
R4666 n1_M2_45420_36780 n1_M2_46500_36780 0.988200
R4667 n1_M2_46500_36780 n1_M2_47580_36780 0.988200
R4668 n1_M2_47580_36780 n1_M2_48660_36780 0.988200
R4669 n1_M2_48660_36780 n1_M2_49740_36780 0.988200
R4670 n1_M2_49740_36780 n1_M2_50820_36780 0.988200
R4671 n1_M2_50820_36780 n1_M2_51900_36780 0.988200
R4672 n1_M2_51900_36780 n1_M2_52980_36780 0.988200
R4673 n1_M2_52980_36780 n1_M2_54060_36780 0.988200
R4674 n1_M2_54060_36780 n1_M2_55140_36780 0.988200
R4675 n1_M2_55140_36780 n1_M2_56220_36780 0.988200
R4676 n1_M2_56220_36780 n1_M2_57300_36780 0.988200
R4677 n1_M2_57300_36780 n1_M2_58380_36780 0.988200
R4678 n1_M2_58380_36780 n1_M2_59460_36780 0.988200
R4679 n1_M2_59460_36780 n1_M2_60540_36780 0.988200
R4680 n1_M2_60540_36780 n1_M2_61620_36780 0.988200
R4681 n1_M2_61620_36780 n1_M2_62700_36780 0.988200
R4682 n1_M2_62700_36780 n1_M2_63780_36780 0.988200
R4683 n1_M2_63780_36780 n1_M2_64860_36780 0.988200
R4684 n1_M2_64860_36780 n1_M2_65940_36780 0.988200
R4685 n1_M2_65940_36780 n1_M2_67020_36780 0.988200
R4686 n1_M2_67020_36780 n1_M2_68100_36780 0.988200
R4687 n1_M2_68100_36780 n1_M2_69180_36780 0.988200
R4688 n1_M2_69180_36780 n1_M2_70260_36780 0.988200
R4689 n1_M2_70260_36780 n1_M2_71340_36780 0.988200
R4690 n1_M2_71340_36780 n1_M2_72420_36780 0.988200
R4691 n1_M2_72420_36780 n1_M2_73500_36780 0.988200
R4692 n1_M2_73500_36780 n1_M2_74580_36780 0.988200
R4693 n1_M2_74580_36780 n1_M2_75660_36780 0.988200
R4694 n1_M2_75660_36780 n1_M2_76740_36780 0.988200
R4695 n1_M2_76740_36780 n1_M2_77820_36780 0.988200
R4696 n1_M2_77820_36780 n1_M2_78900_36780 0.988200
R4697 n1_M2_78900_36780 n1_M2_79980_36780 0.988200
R4698 n1_M2_79980_36780 n1_M2_81060_36780 0.988200
R4699 n1_M2_81060_36780 n1_M2_82140_36780 0.988200
R4700 n1_M2_82140_36780 n1_M2_83220_36780 0.988200
R4701 n1_M2_83220_36780 n1_M2_84300_36780 0.988200
R4702 n1_M2_84300_36780 n1_M2_85380_36780 0.988200
R4703 n1_M2_85380_36780 n1_M2_86460_36780 0.988200
R4704 n1_M2_86460_36780 n1_M2_87540_36780 0.988200
R4705 n1_M2_87540_36780 n1_M2_88620_36780 0.988200
R4706 n1_M2_88620_36780 n1_M2_89700_36780 0.988200
R4707 n1_M2_89700_36780 n1_M2_90780_36780 0.988200
R4708 n1_M2_90780_36780 n1_M2_91860_36780 0.988200
R4709 n1_M2_91860_36780 n1_M2_92940_36780 0.988200
R4710 n1_M2_92940_36780 n1_M2_94020_36780 0.988200
R4711 n1_M2_94020_36780 n1_M2_95100_36780 0.988200
R4712 n1_M2_95100_36780 n1_M2_96180_36780 0.988200
R4713 n1_M2_96180_36780 n1_M2_97260_36780 0.988200
R4714 n1_M2_97260_36780 n1_M2_98340_36780 0.988200
R4715 n1_M2_98340_36780 n1_M2_99420_36780 0.988200
R4716 n1_M2_99420_36780 n1_M2_100500_36780 0.988200
R4717 n1_M2_100500_36780 n1_M2_101580_36780 0.988200
R4718 n1_M2_101580_36780 n1_M2_102660_36780 0.988200
R4719 n1_M2_102660_36780 n1_M2_103740_36780 0.988200
R4720 n1_M2_103740_36780 n1_M2_104820_36780 0.988200
R4721 n1_M2_104820_36780 n1_M2_105900_36780 0.988200
R4722 n1_M2_105900_36780 n1_M2_106980_36780 0.988200
R4723 n1_M2_106980_36780 n1_M2_108060_36780 0.988200
R4724 n1_M2_108060_36780 n1_M2_109140_36780 0.988200
R4725 n1_M2_109140_36780 n1_M2_110220_36780 0.988200
R4726 n1_M2_110220_36780 n1_M2_111300_36780 0.988200
R4727 n1_M2_111300_36780 n1_M2_112380_36780 0.988200
R4728 n1_M2_112380_36780 n1_M2_113460_36780 0.988200
R4729 n1_M2_113460_36780 n1_M2_114540_36780 0.988200
R4730 n1_M2_114540_36780 n1_M2_115620_36780 0.988200
R4731 n1_M2_115620_36780 n1_M2_116700_36780 0.988200
R4732 n1_M2_116700_36780 n1_M2_117780_36780 0.988200
R4733 n1_M2_117780_36780 n1_M2_118860_36780 0.988200
R4734 n1_M2_118860_36780 n1_M2_119940_36780 0.988200
R4735 n1_M2_119940_36780 n1_M2_121020_36780 0.988200
R4736 n1_M2_121020_36780 n1_M2_122100_36780 0.988200
R4737 n1_M2_122100_36780 n1_M2_123180_36780 0.988200
R4738 n1_M2_123180_36780 n1_M2_124260_36780 0.988200
R4739 n1_M2_124260_36780 n1_M2_125340_36780 0.988200
R4740 n1_M2_125340_36780 n1_M2_126420_36780 0.988200
R4741 n1_M2_126420_36780 n1_M2_127500_36780 0.988200
R4742 n1_M2_127500_36780 n1_M2_128580_36780 0.988200
R4743 n1_M2_128580_36780 n1_M2_129660_36780 0.988200
R4744 n1_M2_129660_36780 n1_M2_130740_36780 0.988200
R4745 n1_M2_130740_36780 n1_M2_131820_36780 0.988200
R4746 n1_M2_131820_36780 n1_M2_132900_36780 0.988200
R4747 n1_M2_132900_36780 n1_M2_133980_36780 0.988200
R4748 n1_M2_133980_36780 n1_M2_135060_36780 0.988200
R4749 n1_M2_135060_36780 n1_M2_136140_36780 0.988200
R4750 n1_M2_136140_36780 n1_M2_137220_36780 0.988200
R4751 n1_M2_137220_36780 n1_M2_138300_36780 0.988200
R4752 n1_M2_138300_36780 n1_M2_139380_36780 0.988200
R4753 n1_M2_139380_36780 n1_M2_140460_36780 0.988200
R4754 n1_M2_140460_36780 n1_M2_141540_36780 0.988200
R4755 n1_M2_141540_36780 n1_M2_142620_36780 0.988200
R4756 n1_M2_142620_36780 n1_M2_143700_36780 0.988200
R4757 n1_M2_143700_36780 n1_M2_144780_36780 0.988200
R4758 n1_M2_144780_36780 n1_M2_145860_36780 0.988200
R4759 n1_M2_145860_36780 n1_M2_146940_36780 0.988200
R4760 n1_M2_60_37860 n1_M2_1140_37860 0.988200
R4761 n1_M2_1140_37860 n1_M2_2220_37860 0.988200
R4762 n1_M2_2220_37860 n1_M2_3300_37860 0.988200
R4763 n1_M2_3300_37860 n1_M2_4380_37860 0.988200
R4764 n1_M2_4380_37860 n1_M2_5460_37860 0.988200
R4765 n1_M2_5460_37860 n1_M2_6540_37860 0.988200
R4766 n1_M2_6540_37860 n1_M2_7620_37860 0.988200
R4767 n1_M2_7620_37860 n1_M2_8700_37860 0.988200
R4768 n1_M2_8700_37860 n1_M2_9780_37860 0.988200
R4769 n1_M2_9780_37860 n1_M2_10860_37860 0.988200
R4770 n1_M2_10860_37860 n1_M2_11940_37860 0.988200
R4771 n1_M2_11940_37860 n1_M2_13020_37860 0.988200
R4772 n1_M2_13020_37860 n1_M2_14100_37860 0.988200
R4773 n1_M2_14100_37860 n1_M2_15180_37860 0.988200
R4774 n1_M2_15180_37860 n1_M2_16260_37860 0.988200
R4775 n1_M2_16260_37860 n1_M2_17340_37860 0.988200
R4776 n1_M2_17340_37860 n1_M2_18420_37860 0.988200
R4777 n1_M2_18420_37860 n1_M2_19500_37860 0.988200
R4778 n1_M2_19500_37860 n1_M2_20580_37860 0.988200
R4779 n1_M2_20580_37860 n1_M2_21660_37860 0.988200
R4780 n1_M2_21660_37860 n1_M2_22740_37860 0.988200
R4781 n1_M2_22740_37860 n1_M2_23820_37860 0.988200
R4782 n1_M2_23820_37860 n1_M2_24900_37860 0.988200
R4783 n1_M2_24900_37860 n1_M2_25980_37860 0.988200
R4784 n1_M2_25980_37860 n1_M2_27060_37860 0.988200
R4785 n1_M2_27060_37860 n1_M2_28140_37860 0.988200
R4786 n1_M2_28140_37860 n1_M2_29220_37860 0.988200
R4787 n1_M2_29220_37860 n1_M2_30300_37860 0.988200
R4788 n1_M2_30300_37860 n1_M2_31380_37860 0.988200
R4789 n1_M2_31380_37860 n1_M2_32460_37860 0.988200
R4790 n1_M2_32460_37860 n1_M2_33540_37860 0.988200
R4791 n1_M2_33540_37860 n1_M2_34620_37860 0.988200
R4792 n1_M2_34620_37860 n1_M2_35700_37860 0.988200
R4793 n1_M2_35700_37860 n1_M2_36780_37860 0.988200
R4794 n1_M2_36780_37860 n1_M2_37860_37860 0.988200
R4795 n1_M2_37860_37860 n1_M2_38940_37860 0.988200
R4796 n1_M2_38940_37860 n1_M2_40020_37860 0.988200
R4797 n1_M2_40020_37860 n1_M2_41100_37860 0.988200
R4798 n1_M2_41100_37860 n1_M2_42180_37860 0.988200
R4799 n1_M2_42180_37860 n1_M2_43260_37860 0.988200
R4800 n1_M2_43260_37860 n1_M2_44340_37860 0.988200
R4801 n1_M2_44340_37860 n1_M2_45420_37860 0.988200
R4802 n1_M2_45420_37860 n1_M2_46500_37860 0.988200
R4803 n1_M2_46500_37860 n1_M2_47580_37860 0.988200
R4804 n1_M2_47580_37860 n1_M2_48660_37860 0.988200
R4805 n1_M2_48660_37860 n1_M2_49740_37860 0.988200
R4806 n1_M2_49740_37860 n1_M2_50820_37860 0.988200
R4807 n1_M2_50820_37860 n1_M2_51900_37860 0.988200
R4808 n1_M2_51900_37860 n1_M2_52980_37860 0.988200
R4809 n1_M2_52980_37860 n1_M2_54060_37860 0.988200
R4810 n1_M2_54060_37860 n1_M2_55140_37860 0.988200
R4811 n1_M2_55140_37860 n1_M2_56220_37860 0.988200
R4812 n1_M2_56220_37860 n1_M2_57300_37860 0.988200
R4813 n1_M2_57300_37860 n1_M2_58380_37860 0.988200
R4814 n1_M2_58380_37860 n1_M2_59460_37860 0.988200
R4815 n1_M2_59460_37860 n1_M2_60540_37860 0.988200
R4816 n1_M2_60540_37860 n1_M2_61620_37860 0.988200
R4817 n1_M2_61620_37860 n1_M2_62700_37860 0.988200
R4818 n1_M2_62700_37860 n1_M2_63780_37860 0.988200
R4819 n1_M2_63780_37860 n1_M2_64860_37860 0.988200
R4820 n1_M2_64860_37860 n1_M2_65940_37860 0.988200
R4821 n1_M2_65940_37860 n1_M2_67020_37860 0.988200
R4822 n1_M2_67020_37860 n1_M2_68100_37860 0.988200
R4823 n1_M2_68100_37860 n1_M2_69180_37860 0.988200
R4824 n1_M2_69180_37860 n1_M2_70260_37860 0.988200
R4825 n1_M2_70260_37860 n1_M2_71340_37860 0.988200
R4826 n1_M2_71340_37860 n1_M2_72420_37860 0.988200
R4827 n1_M2_72420_37860 n1_M2_73500_37860 0.988200
R4828 n1_M2_73500_37860 n1_M2_74580_37860 0.988200
R4829 n1_M2_74580_37860 n1_M2_75660_37860 0.988200
R4830 n1_M2_75660_37860 n1_M2_76740_37860 0.988200
R4831 n1_M2_76740_37860 n1_M2_77820_37860 0.988200
R4832 n1_M2_77820_37860 n1_M2_78900_37860 0.988200
R4833 n1_M2_78900_37860 n1_M2_79980_37860 0.988200
R4834 n1_M2_79980_37860 n1_M2_81060_37860 0.988200
R4835 n1_M2_81060_37860 n1_M2_82140_37860 0.988200
R4836 n1_M2_82140_37860 n1_M2_83220_37860 0.988200
R4837 n1_M2_83220_37860 n1_M2_84300_37860 0.988200
R4838 n1_M2_84300_37860 n1_M2_85380_37860 0.988200
R4839 n1_M2_85380_37860 n1_M2_86460_37860 0.988200
R4840 n1_M2_86460_37860 n1_M2_87540_37860 0.988200
R4841 n1_M2_87540_37860 n1_M2_88620_37860 0.988200
R4842 n1_M2_88620_37860 n1_M2_89700_37860 0.988200
R4843 n1_M2_89700_37860 n1_M2_90780_37860 0.988200
R4844 n1_M2_90780_37860 n1_M2_91860_37860 0.988200
R4845 n1_M2_91860_37860 n1_M2_92940_37860 0.988200
R4846 n1_M2_92940_37860 n1_M2_94020_37860 0.988200
R4847 n1_M2_94020_37860 n1_M2_95100_37860 0.988200
R4848 n1_M2_95100_37860 n1_M2_96180_37860 0.988200
R4849 n1_M2_96180_37860 n1_M2_97260_37860 0.988200
R4850 n1_M2_97260_37860 n1_M2_98340_37860 0.988200
R4851 n1_M2_98340_37860 n1_M2_99420_37860 0.988200
R4852 n1_M2_99420_37860 n1_M2_100500_37860 0.988200
R4853 n1_M2_100500_37860 n1_M2_101580_37860 0.988200
R4854 n1_M2_101580_37860 n1_M2_102660_37860 0.988200
R4855 n1_M2_102660_37860 n1_M2_103740_37860 0.988200
R4856 n1_M2_103740_37860 n1_M2_104820_37860 0.988200
R4857 n1_M2_104820_37860 n1_M2_105900_37860 0.988200
R4858 n1_M2_105900_37860 n1_M2_106980_37860 0.988200
R4859 n1_M2_106980_37860 n1_M2_108060_37860 0.988200
R4860 n1_M2_108060_37860 n1_M2_109140_37860 0.988200
R4861 n1_M2_109140_37860 n1_M2_110220_37860 0.988200
R4862 n1_M2_110220_37860 n1_M2_111300_37860 0.988200
R4863 n1_M2_111300_37860 n1_M2_112380_37860 0.988200
R4864 n1_M2_112380_37860 n1_M2_113460_37860 0.988200
R4865 n1_M2_113460_37860 n1_M2_114540_37860 0.988200
R4866 n1_M2_114540_37860 n1_M2_115620_37860 0.988200
R4867 n1_M2_115620_37860 n1_M2_116700_37860 0.988200
R4868 n1_M2_116700_37860 n1_M2_117780_37860 0.988200
R4869 n1_M2_117780_37860 n1_M2_118860_37860 0.988200
R4870 n1_M2_118860_37860 n1_M2_119940_37860 0.988200
R4871 n1_M2_119940_37860 n1_M2_121020_37860 0.988200
R4872 n1_M2_121020_37860 n1_M2_122100_37860 0.988200
R4873 n1_M2_122100_37860 n1_M2_123180_37860 0.988200
R4874 n1_M2_123180_37860 n1_M2_124260_37860 0.988200
R4875 n1_M2_124260_37860 n1_M2_125340_37860 0.988200
R4876 n1_M2_125340_37860 n1_M2_126420_37860 0.988200
R4877 n1_M2_126420_37860 n1_M2_127500_37860 0.988200
R4878 n1_M2_127500_37860 n1_M2_128580_37860 0.988200
R4879 n1_M2_128580_37860 n1_M2_129660_37860 0.988200
R4880 n1_M2_129660_37860 n1_M2_130740_37860 0.988200
R4881 n1_M2_130740_37860 n1_M2_131820_37860 0.988200
R4882 n1_M2_131820_37860 n1_M2_132900_37860 0.988200
R4883 n1_M2_132900_37860 n1_M2_133980_37860 0.988200
R4884 n1_M2_133980_37860 n1_M2_135060_37860 0.988200
R4885 n1_M2_135060_37860 n1_M2_136140_37860 0.988200
R4886 n1_M2_136140_37860 n1_M2_137220_37860 0.988200
R4887 n1_M2_137220_37860 n1_M2_138300_37860 0.988200
R4888 n1_M2_138300_37860 n1_M2_139380_37860 0.988200
R4889 n1_M2_139380_37860 n1_M2_140460_37860 0.988200
R4890 n1_M2_140460_37860 n1_M2_141540_37860 0.988200
R4891 n1_M2_141540_37860 n1_M2_142620_37860 0.988200
R4892 n1_M2_142620_37860 n1_M2_143700_37860 0.988200
R4893 n1_M2_143700_37860 n1_M2_144780_37860 0.988200
R4894 n1_M2_144780_37860 n1_M2_145860_37860 0.988200
R4895 n1_M2_145860_37860 n1_M2_146940_37860 0.988200
R4896 n1_M2_60_38940 n1_M2_1140_38940 0.988200
R4897 n1_M2_1140_38940 n1_M2_2220_38940 0.988200
R4898 n1_M2_2220_38940 n1_M2_3300_38940 0.988200
R4899 n1_M2_3300_38940 n1_M2_4380_38940 0.988200
R4900 n1_M2_4380_38940 n1_M2_5460_38940 0.988200
R4901 n1_M2_5460_38940 n1_M2_6540_38940 0.988200
R4902 n1_M2_6540_38940 n1_M2_7620_38940 0.988200
R4903 n1_M2_7620_38940 n1_M2_8700_38940 0.988200
R4904 n1_M2_8700_38940 n1_M2_9780_38940 0.988200
R4905 n1_M2_9780_38940 n1_M2_10860_38940 0.988200
R4906 n1_M2_10860_38940 n1_M2_11940_38940 0.988200
R4907 n1_M2_11940_38940 n1_M2_13020_38940 0.988200
R4908 n1_M2_13020_38940 n1_M2_14100_38940 0.988200
R4909 n1_M2_14100_38940 n1_M2_15180_38940 0.988200
R4910 n1_M2_15180_38940 n1_M2_16260_38940 0.988200
R4911 n1_M2_16260_38940 n1_M2_17340_38940 0.988200
R4912 n1_M2_17340_38940 n1_M2_18420_38940 0.988200
R4913 n1_M2_18420_38940 n1_M2_19500_38940 0.988200
R4914 n1_M2_19500_38940 n1_M2_20580_38940 0.988200
R4915 n1_M2_20580_38940 n1_M2_21660_38940 0.988200
R4916 n1_M2_21660_38940 n1_M2_22740_38940 0.988200
R4917 n1_M2_22740_38940 n1_M2_23820_38940 0.988200
R4918 n1_M2_23820_38940 n1_M2_24900_38940 0.988200
R4919 n1_M2_24900_38940 n1_M2_25980_38940 0.988200
R4920 n1_M2_25980_38940 n1_M2_27060_38940 0.988200
R4921 n1_M2_27060_38940 n1_M2_28140_38940 0.988200
R4922 n1_M2_28140_38940 n1_M2_29220_38940 0.988200
R4923 n1_M2_29220_38940 n1_M2_30300_38940 0.988200
R4924 n1_M2_30300_38940 n1_M2_31380_38940 0.988200
R4925 n1_M2_31380_38940 n1_M2_32460_38940 0.988200
R4926 n1_M2_32460_38940 n1_M2_33540_38940 0.988200
R4927 n1_M2_33540_38940 n1_M2_34620_38940 0.988200
R4928 n1_M2_34620_38940 n1_M2_35700_38940 0.988200
R4929 n1_M2_35700_38940 n1_M2_36780_38940 0.988200
R4930 n1_M2_36780_38940 n1_M2_37860_38940 0.988200
R4931 n1_M2_37860_38940 n1_M2_38940_38940 0.988200
R4932 n1_M2_38940_38940 n1_M2_40020_38940 0.988200
R4933 n1_M2_40020_38940 n1_M2_41100_38940 0.988200
R4934 n1_M2_41100_38940 n1_M2_42180_38940 0.988200
R4935 n1_M2_42180_38940 n1_M2_43260_38940 0.988200
R4936 n1_M2_43260_38940 n1_M2_44340_38940 0.988200
R4937 n1_M2_44340_38940 n1_M2_45420_38940 0.988200
R4938 n1_M2_45420_38940 n1_M2_46500_38940 0.988200
R4939 n1_M2_46500_38940 n1_M2_47580_38940 0.988200
R4940 n1_M2_47580_38940 n1_M2_48660_38940 0.988200
R4941 n1_M2_48660_38940 n1_M2_49740_38940 0.988200
R4942 n1_M2_49740_38940 n1_M2_50820_38940 0.988200
R4943 n1_M2_50820_38940 n1_M2_51900_38940 0.988200
R4944 n1_M2_51900_38940 n1_M2_52980_38940 0.988200
R4945 n1_M2_52980_38940 n1_M2_54060_38940 0.988200
R4946 n1_M2_54060_38940 n1_M2_55140_38940 0.988200
R4947 n1_M2_55140_38940 n1_M2_56220_38940 0.988200
R4948 n1_M2_56220_38940 n1_M2_57300_38940 0.988200
R4949 n1_M2_57300_38940 n1_M2_58380_38940 0.988200
R4950 n1_M2_58380_38940 n1_M2_59460_38940 0.988200
R4951 n1_M2_59460_38940 n1_M2_60540_38940 0.988200
R4952 n1_M2_60540_38940 n1_M2_61620_38940 0.988200
R4953 n1_M2_61620_38940 n1_M2_62700_38940 0.988200
R4954 n1_M2_62700_38940 n1_M2_63780_38940 0.988200
R4955 n1_M2_63780_38940 n1_M2_64860_38940 0.988200
R4956 n1_M2_64860_38940 n1_M2_65940_38940 0.988200
R4957 n1_M2_65940_38940 n1_M2_67020_38940 0.988200
R4958 n1_M2_67020_38940 n1_M2_68100_38940 0.988200
R4959 n1_M2_68100_38940 n1_M2_69180_38940 0.988200
R4960 n1_M2_69180_38940 n1_M2_70260_38940 0.988200
R4961 n1_M2_70260_38940 n1_M2_71340_38940 0.988200
R4962 n1_M2_71340_38940 n1_M2_72420_38940 0.988200
R4963 n1_M2_72420_38940 n1_M2_73500_38940 0.988200
R4964 n1_M2_73500_38940 n1_M2_74580_38940 0.988200
R4965 n1_M2_74580_38940 n1_M2_75660_38940 0.988200
R4966 n1_M2_75660_38940 n1_M2_76740_38940 0.988200
R4967 n1_M2_76740_38940 n1_M2_77820_38940 0.988200
R4968 n1_M2_77820_38940 n1_M2_78900_38940 0.988200
R4969 n1_M2_78900_38940 n1_M2_79980_38940 0.988200
R4970 n1_M2_79980_38940 n1_M2_81060_38940 0.988200
R4971 n1_M2_81060_38940 n1_M2_82140_38940 0.988200
R4972 n1_M2_82140_38940 n1_M2_83220_38940 0.988200
R4973 n1_M2_83220_38940 n1_M2_84300_38940 0.988200
R4974 n1_M2_84300_38940 n1_M2_85380_38940 0.988200
R4975 n1_M2_85380_38940 n1_M2_86460_38940 0.988200
R4976 n1_M2_86460_38940 n1_M2_87540_38940 0.988200
R4977 n1_M2_87540_38940 n1_M2_88620_38940 0.988200
R4978 n1_M2_88620_38940 n1_M2_89700_38940 0.988200
R4979 n1_M2_89700_38940 n1_M2_90780_38940 0.988200
R4980 n1_M2_90780_38940 n1_M2_91860_38940 0.988200
R4981 n1_M2_91860_38940 n1_M2_92940_38940 0.988200
R4982 n1_M2_92940_38940 n1_M2_94020_38940 0.988200
R4983 n1_M2_94020_38940 n1_M2_95100_38940 0.988200
R4984 n1_M2_95100_38940 n1_M2_96180_38940 0.988200
R4985 n1_M2_96180_38940 n1_M2_97260_38940 0.988200
R4986 n1_M2_97260_38940 n1_M2_98340_38940 0.988200
R4987 n1_M2_98340_38940 n1_M2_99420_38940 0.988200
R4988 n1_M2_99420_38940 n1_M2_100500_38940 0.988200
R4989 n1_M2_100500_38940 n1_M2_101580_38940 0.988200
R4990 n1_M2_101580_38940 n1_M2_102660_38940 0.988200
R4991 n1_M2_102660_38940 n1_M2_103740_38940 0.988200
R4992 n1_M2_103740_38940 n1_M2_104820_38940 0.988200
R4993 n1_M2_104820_38940 n1_M2_105900_38940 0.988200
R4994 n1_M2_105900_38940 n1_M2_106980_38940 0.988200
R4995 n1_M2_106980_38940 n1_M2_108060_38940 0.988200
R4996 n1_M2_108060_38940 n1_M2_109140_38940 0.988200
R4997 n1_M2_109140_38940 n1_M2_110220_38940 0.988200
R4998 n1_M2_110220_38940 n1_M2_111300_38940 0.988200
R4999 n1_M2_111300_38940 n1_M2_112380_38940 0.988200
R5000 n1_M2_112380_38940 n1_M2_113460_38940 0.988200
R5001 n1_M2_113460_38940 n1_M2_114540_38940 0.988200
R5002 n1_M2_114540_38940 n1_M2_115620_38940 0.988200
R5003 n1_M2_115620_38940 n1_M2_116700_38940 0.988200
R5004 n1_M2_116700_38940 n1_M2_117780_38940 0.988200
R5005 n1_M2_117780_38940 n1_M2_118860_38940 0.988200
R5006 n1_M2_118860_38940 n1_M2_119940_38940 0.988200
R5007 n1_M2_119940_38940 n1_M2_121020_38940 0.988200
R5008 n1_M2_121020_38940 n1_M2_122100_38940 0.988200
R5009 n1_M2_122100_38940 n1_M2_123180_38940 0.988200
R5010 n1_M2_123180_38940 n1_M2_124260_38940 0.988200
R5011 n1_M2_124260_38940 n1_M2_125340_38940 0.988200
R5012 n1_M2_125340_38940 n1_M2_126420_38940 0.988200
R5013 n1_M2_126420_38940 n1_M2_127500_38940 0.988200
R5014 n1_M2_127500_38940 n1_M2_128580_38940 0.988200
R5015 n1_M2_128580_38940 n1_M2_129660_38940 0.988200
R5016 n1_M2_129660_38940 n1_M2_130740_38940 0.988200
R5017 n1_M2_130740_38940 n1_M2_131820_38940 0.988200
R5018 n1_M2_131820_38940 n1_M2_132900_38940 0.988200
R5019 n1_M2_132900_38940 n1_M2_133980_38940 0.988200
R5020 n1_M2_133980_38940 n1_M2_135060_38940 0.988200
R5021 n1_M2_135060_38940 n1_M2_136140_38940 0.988200
R5022 n1_M2_136140_38940 n1_M2_137220_38940 0.988200
R5023 n1_M2_137220_38940 n1_M2_138300_38940 0.988200
R5024 n1_M2_138300_38940 n1_M2_139380_38940 0.988200
R5025 n1_M2_139380_38940 n1_M2_140460_38940 0.988200
R5026 n1_M2_140460_38940 n1_M2_141540_38940 0.988200
R5027 n1_M2_141540_38940 n1_M2_142620_38940 0.988200
R5028 n1_M2_142620_38940 n1_M2_143700_38940 0.988200
R5029 n1_M2_143700_38940 n1_M2_144780_38940 0.988200
R5030 n1_M2_144780_38940 n1_M2_145860_38940 0.988200
R5031 n1_M2_145860_38940 n1_M2_146940_38940 0.988200
R5032 n1_M2_60_40020 n1_M2_1140_40020 0.988200
R5033 n1_M2_1140_40020 n1_M2_2220_40020 0.988200
R5034 n1_M2_2220_40020 n1_M2_3300_40020 0.988200
R5035 n1_M2_3300_40020 n1_M2_4380_40020 0.988200
R5036 n1_M2_4380_40020 n1_M2_5460_40020 0.988200
R5037 n1_M2_5460_40020 n1_M2_6540_40020 0.988200
R5038 n1_M2_6540_40020 n1_M2_7620_40020 0.988200
R5039 n1_M2_7620_40020 n1_M2_8700_40020 0.988200
R5040 n1_M2_8700_40020 n1_M2_9780_40020 0.988200
R5041 n1_M2_9780_40020 n1_M2_10860_40020 0.988200
R5042 n1_M2_10860_40020 n1_M2_11940_40020 0.988200
R5043 n1_M2_11940_40020 n1_M2_13020_40020 0.988200
R5044 n1_M2_13020_40020 n1_M2_14100_40020 0.988200
R5045 n1_M2_14100_40020 n1_M2_15180_40020 0.988200
R5046 n1_M2_15180_40020 n1_M2_16260_40020 0.988200
R5047 n1_M2_16260_40020 n1_M2_17340_40020 0.988200
R5048 n1_M2_17340_40020 n1_M2_18420_40020 0.988200
R5049 n1_M2_18420_40020 n1_M2_19500_40020 0.988200
R5050 n1_M2_19500_40020 n1_M2_20580_40020 0.988200
R5051 n1_M2_20580_40020 n1_M2_21660_40020 0.988200
R5052 n1_M2_21660_40020 n1_M2_22740_40020 0.988200
R5053 n1_M2_22740_40020 n1_M2_23820_40020 0.988200
R5054 n1_M2_23820_40020 n1_M2_24900_40020 0.988200
R5055 n1_M2_24900_40020 n1_M2_25980_40020 0.988200
R5056 n1_M2_25980_40020 n1_M2_27060_40020 0.988200
R5057 n1_M2_27060_40020 n1_M2_28140_40020 0.988200
R5058 n1_M2_28140_40020 n1_M2_29220_40020 0.988200
R5059 n1_M2_29220_40020 n1_M2_30300_40020 0.988200
R5060 n1_M2_30300_40020 n1_M2_31380_40020 0.988200
R5061 n1_M2_31380_40020 n1_M2_32460_40020 0.988200
R5062 n1_M2_32460_40020 n1_M2_33540_40020 0.988200
R5063 n1_M2_33540_40020 n1_M2_34620_40020 0.988200
R5064 n1_M2_34620_40020 n1_M2_35700_40020 0.988200
R5065 n1_M2_35700_40020 n1_M2_36780_40020 0.988200
R5066 n1_M2_36780_40020 n1_M2_37860_40020 0.988200
R5067 n1_M2_37860_40020 n1_M2_38940_40020 0.988200
R5068 n1_M2_38940_40020 n1_M2_40020_40020 0.988200
R5069 n1_M2_40020_40020 n1_M2_41100_40020 0.988200
R5070 n1_M2_41100_40020 n1_M2_42180_40020 0.988200
R5071 n1_M2_42180_40020 n1_M2_43260_40020 0.988200
R5072 n1_M2_43260_40020 n1_M2_44340_40020 0.988200
R5073 n1_M2_44340_40020 n1_M2_45420_40020 0.988200
R5074 n1_M2_45420_40020 n1_M2_46500_40020 0.988200
R5075 n1_M2_46500_40020 n1_M2_47580_40020 0.988200
R5076 n1_M2_47580_40020 n1_M2_48660_40020 0.988200
R5077 n1_M2_48660_40020 n1_M2_49740_40020 0.988200
R5078 n1_M2_49740_40020 n1_M2_50820_40020 0.988200
R5079 n1_M2_50820_40020 n1_M2_51900_40020 0.988200
R5080 n1_M2_51900_40020 n1_M2_52980_40020 0.988200
R5081 n1_M2_52980_40020 n1_M2_54060_40020 0.988200
R5082 n1_M2_54060_40020 n1_M2_55140_40020 0.988200
R5083 n1_M2_55140_40020 n1_M2_56220_40020 0.988200
R5084 n1_M2_56220_40020 n1_M2_57300_40020 0.988200
R5085 n1_M2_57300_40020 n1_M2_58380_40020 0.988200
R5086 n1_M2_58380_40020 n1_M2_59460_40020 0.988200
R5087 n1_M2_59460_40020 n1_M2_60540_40020 0.988200
R5088 n1_M2_60540_40020 n1_M2_61620_40020 0.988200
R5089 n1_M2_61620_40020 n1_M2_62700_40020 0.988200
R5090 n1_M2_62700_40020 n1_M2_63780_40020 0.988200
R5091 n1_M2_63780_40020 n1_M2_64860_40020 0.988200
R5092 n1_M2_64860_40020 n1_M2_65940_40020 0.988200
R5093 n1_M2_65940_40020 n1_M2_67020_40020 0.988200
R5094 n1_M2_67020_40020 n1_M2_68100_40020 0.988200
R5095 n1_M2_68100_40020 n1_M2_69180_40020 0.988200
R5096 n1_M2_69180_40020 n1_M2_70260_40020 0.988200
R5097 n1_M2_70260_40020 n1_M2_71340_40020 0.988200
R5098 n1_M2_71340_40020 n1_M2_72420_40020 0.988200
R5099 n1_M2_72420_40020 n1_M2_73500_40020 0.988200
R5100 n1_M2_73500_40020 n1_M2_74580_40020 0.988200
R5101 n1_M2_74580_40020 n1_M2_75660_40020 0.988200
R5102 n1_M2_75660_40020 n1_M2_76740_40020 0.988200
R5103 n1_M2_76740_40020 n1_M2_77820_40020 0.988200
R5104 n1_M2_77820_40020 n1_M2_78900_40020 0.988200
R5105 n1_M2_78900_40020 n1_M2_79980_40020 0.988200
R5106 n1_M2_79980_40020 n1_M2_81060_40020 0.988200
R5107 n1_M2_81060_40020 n1_M2_82140_40020 0.988200
R5108 n1_M2_82140_40020 n1_M2_83220_40020 0.988200
R5109 n1_M2_83220_40020 n1_M2_84300_40020 0.988200
R5110 n1_M2_84300_40020 n1_M2_85380_40020 0.988200
R5111 n1_M2_85380_40020 n1_M2_86460_40020 0.988200
R5112 n1_M2_86460_40020 n1_M2_87540_40020 0.988200
R5113 n1_M2_87540_40020 n1_M2_88620_40020 0.988200
R5114 n1_M2_88620_40020 n1_M2_89700_40020 0.988200
R5115 n1_M2_89700_40020 n1_M2_90780_40020 0.988200
R5116 n1_M2_90780_40020 n1_M2_91860_40020 0.988200
R5117 n1_M2_91860_40020 n1_M2_92940_40020 0.988200
R5118 n1_M2_92940_40020 n1_M2_94020_40020 0.988200
R5119 n1_M2_94020_40020 n1_M2_95100_40020 0.988200
R5120 n1_M2_95100_40020 n1_M2_96180_40020 0.988200
R5121 n1_M2_96180_40020 n1_M2_97260_40020 0.988200
R5122 n1_M2_97260_40020 n1_M2_98340_40020 0.988200
R5123 n1_M2_98340_40020 n1_M2_99420_40020 0.988200
R5124 n1_M2_99420_40020 n1_M2_100500_40020 0.988200
R5125 n1_M2_100500_40020 n1_M2_101580_40020 0.988200
R5126 n1_M2_101580_40020 n1_M2_102660_40020 0.988200
R5127 n1_M2_102660_40020 n1_M2_103740_40020 0.988200
R5128 n1_M2_103740_40020 n1_M2_104820_40020 0.988200
R5129 n1_M2_104820_40020 n1_M2_105900_40020 0.988200
R5130 n1_M2_105900_40020 n1_M2_106980_40020 0.988200
R5131 n1_M2_106980_40020 n1_M2_108060_40020 0.988200
R5132 n1_M2_108060_40020 n1_M2_109140_40020 0.988200
R5133 n1_M2_109140_40020 n1_M2_110220_40020 0.988200
R5134 n1_M2_110220_40020 n1_M2_111300_40020 0.988200
R5135 n1_M2_111300_40020 n1_M2_112380_40020 0.988200
R5136 n1_M2_112380_40020 n1_M2_113460_40020 0.988200
R5137 n1_M2_113460_40020 n1_M2_114540_40020 0.988200
R5138 n1_M2_114540_40020 n1_M2_115620_40020 0.988200
R5139 n1_M2_115620_40020 n1_M2_116700_40020 0.988200
R5140 n1_M2_116700_40020 n1_M2_117780_40020 0.988200
R5141 n1_M2_117780_40020 n1_M2_118860_40020 0.988200
R5142 n1_M2_118860_40020 n1_M2_119940_40020 0.988200
R5143 n1_M2_119940_40020 n1_M2_121020_40020 0.988200
R5144 n1_M2_121020_40020 n1_M2_122100_40020 0.988200
R5145 n1_M2_122100_40020 n1_M2_123180_40020 0.988200
R5146 n1_M2_123180_40020 n1_M2_124260_40020 0.988200
R5147 n1_M2_124260_40020 n1_M2_125340_40020 0.988200
R5148 n1_M2_125340_40020 n1_M2_126420_40020 0.988200
R5149 n1_M2_126420_40020 n1_M2_127500_40020 0.988200
R5150 n1_M2_127500_40020 n1_M2_128580_40020 0.988200
R5151 n1_M2_128580_40020 n1_M2_129660_40020 0.988200
R5152 n1_M2_129660_40020 n1_M2_130740_40020 0.988200
R5153 n1_M2_130740_40020 n1_M2_131820_40020 0.988200
R5154 n1_M2_131820_40020 n1_M2_132900_40020 0.988200
R5155 n1_M2_132900_40020 n1_M2_133980_40020 0.988200
R5156 n1_M2_133980_40020 n1_M2_135060_40020 0.988200
R5157 n1_M2_135060_40020 n1_M2_136140_40020 0.988200
R5158 n1_M2_136140_40020 n1_M2_137220_40020 0.988200
R5159 n1_M2_137220_40020 n1_M2_138300_40020 0.988200
R5160 n1_M2_138300_40020 n1_M2_139380_40020 0.988200
R5161 n1_M2_139380_40020 n1_M2_140460_40020 0.988200
R5162 n1_M2_140460_40020 n1_M2_141540_40020 0.988200
R5163 n1_M2_141540_40020 n1_M2_142620_40020 0.988200
R5164 n1_M2_142620_40020 n1_M2_143700_40020 0.988200
R5165 n1_M2_143700_40020 n1_M2_144780_40020 0.988200
R5166 n1_M2_144780_40020 n1_M2_145860_40020 0.988200
R5167 n1_M2_145860_40020 n1_M2_146940_40020 0.988200
R5168 n1_M2_60_41100 n1_M2_1140_41100 0.988200
R5169 n1_M2_1140_41100 n1_M2_2220_41100 0.988200
R5170 n1_M2_2220_41100 n1_M2_3300_41100 0.988200
R5171 n1_M2_3300_41100 n1_M2_4380_41100 0.988200
R5172 n1_M2_4380_41100 n1_M2_5460_41100 0.988200
R5173 n1_M2_5460_41100 n1_M2_6540_41100 0.988200
R5174 n1_M2_6540_41100 n1_M2_7620_41100 0.988200
R5175 n1_M2_7620_41100 n1_M2_8700_41100 0.988200
R5176 n1_M2_8700_41100 n1_M2_9780_41100 0.988200
R5177 n1_M2_9780_41100 n1_M2_10860_41100 0.988200
R5178 n1_M2_10860_41100 n1_M2_11940_41100 0.988200
R5179 n1_M2_11940_41100 n1_M2_13020_41100 0.988200
R5180 n1_M2_13020_41100 n1_M2_14100_41100 0.988200
R5181 n1_M2_14100_41100 n1_M2_15180_41100 0.988200
R5182 n1_M2_15180_41100 n1_M2_16260_41100 0.988200
R5183 n1_M2_16260_41100 n1_M2_17340_41100 0.988200
R5184 n1_M2_17340_41100 n1_M2_18420_41100 0.988200
R5185 n1_M2_18420_41100 n1_M2_19500_41100 0.988200
R5186 n1_M2_19500_41100 n1_M2_20580_41100 0.988200
R5187 n1_M2_20580_41100 n1_M2_21660_41100 0.988200
R5188 n1_M2_21660_41100 n1_M2_22740_41100 0.988200
R5189 n1_M2_22740_41100 n1_M2_23820_41100 0.988200
R5190 n1_M2_23820_41100 n1_M2_24900_41100 0.988200
R5191 n1_M2_24900_41100 n1_M2_25980_41100 0.988200
R5192 n1_M2_25980_41100 n1_M2_27060_41100 0.988200
R5193 n1_M2_27060_41100 n1_M2_28140_41100 0.988200
R5194 n1_M2_28140_41100 n1_M2_29220_41100 0.988200
R5195 n1_M2_29220_41100 n1_M2_30300_41100 0.988200
R5196 n1_M2_30300_41100 n1_M2_31380_41100 0.988200
R5197 n1_M2_31380_41100 n1_M2_32460_41100 0.988200
R5198 n1_M2_32460_41100 n1_M2_33540_41100 0.988200
R5199 n1_M2_33540_41100 n1_M2_34620_41100 0.988200
R5200 n1_M2_34620_41100 n1_M2_35700_41100 0.988200
R5201 n1_M2_35700_41100 n1_M2_36780_41100 0.988200
R5202 n1_M2_36780_41100 n1_M2_37860_41100 0.988200
R5203 n1_M2_37860_41100 n1_M2_38940_41100 0.988200
R5204 n1_M2_38940_41100 n1_M2_40020_41100 0.988200
R5205 n1_M2_40020_41100 n1_M2_41100_41100 0.988200
R5206 n1_M2_41100_41100 n1_M2_42180_41100 0.988200
R5207 n1_M2_42180_41100 n1_M2_43260_41100 0.988200
R5208 n1_M2_43260_41100 n1_M2_44340_41100 0.988200
R5209 n1_M2_44340_41100 n1_M2_45420_41100 0.988200
R5210 n1_M2_45420_41100 n1_M2_46500_41100 0.988200
R5211 n1_M2_46500_41100 n1_M2_47580_41100 0.988200
R5212 n1_M2_47580_41100 n1_M2_48660_41100 0.988200
R5213 n1_M2_48660_41100 n1_M2_49740_41100 0.988200
R5214 n1_M2_49740_41100 n1_M2_50820_41100 0.988200
R5215 n1_M2_50820_41100 n1_M2_51900_41100 0.988200
R5216 n1_M2_51900_41100 n1_M2_52980_41100 0.988200
R5217 n1_M2_52980_41100 n1_M2_54060_41100 0.988200
R5218 n1_M2_54060_41100 n1_M2_55140_41100 0.988200
R5219 n1_M2_55140_41100 n1_M2_56220_41100 0.988200
R5220 n1_M2_56220_41100 n1_M2_57300_41100 0.988200
R5221 n1_M2_57300_41100 n1_M2_58380_41100 0.988200
R5222 n1_M2_58380_41100 n1_M2_59460_41100 0.988200
R5223 n1_M2_59460_41100 n1_M2_60540_41100 0.988200
R5224 n1_M2_60540_41100 n1_M2_61620_41100 0.988200
R5225 n1_M2_61620_41100 n1_M2_62700_41100 0.988200
R5226 n1_M2_62700_41100 n1_M2_63780_41100 0.988200
R5227 n1_M2_63780_41100 n1_M2_64860_41100 0.988200
R5228 n1_M2_64860_41100 n1_M2_65940_41100 0.988200
R5229 n1_M2_65940_41100 n1_M2_67020_41100 0.988200
R5230 n1_M2_67020_41100 n1_M2_68100_41100 0.988200
R5231 n1_M2_68100_41100 n1_M2_69180_41100 0.988200
R5232 n1_M2_69180_41100 n1_M2_70260_41100 0.988200
R5233 n1_M2_70260_41100 n1_M2_71340_41100 0.988200
R5234 n1_M2_71340_41100 n1_M2_72420_41100 0.988200
R5235 n1_M2_72420_41100 n1_M2_73500_41100 0.988200
R5236 n1_M2_73500_41100 n1_M2_74580_41100 0.988200
R5237 n1_M2_74580_41100 n1_M2_75660_41100 0.988200
R5238 n1_M2_75660_41100 n1_M2_76740_41100 0.988200
R5239 n1_M2_76740_41100 n1_M2_77820_41100 0.988200
R5240 n1_M2_77820_41100 n1_M2_78900_41100 0.988200
R5241 n1_M2_78900_41100 n1_M2_79980_41100 0.988200
R5242 n1_M2_79980_41100 n1_M2_81060_41100 0.988200
R5243 n1_M2_81060_41100 n1_M2_82140_41100 0.988200
R5244 n1_M2_82140_41100 n1_M2_83220_41100 0.988200
R5245 n1_M2_83220_41100 n1_M2_84300_41100 0.988200
R5246 n1_M2_84300_41100 n1_M2_85380_41100 0.988200
R5247 n1_M2_85380_41100 n1_M2_86460_41100 0.988200
R5248 n1_M2_86460_41100 n1_M2_87540_41100 0.988200
R5249 n1_M2_87540_41100 n1_M2_88620_41100 0.988200
R5250 n1_M2_88620_41100 n1_M2_89700_41100 0.988200
R5251 n1_M2_89700_41100 n1_M2_90780_41100 0.988200
R5252 n1_M2_90780_41100 n1_M2_91860_41100 0.988200
R5253 n1_M2_91860_41100 n1_M2_92940_41100 0.988200
R5254 n1_M2_92940_41100 n1_M2_94020_41100 0.988200
R5255 n1_M2_94020_41100 n1_M2_95100_41100 0.988200
R5256 n1_M2_95100_41100 n1_M2_96180_41100 0.988200
R5257 n1_M2_96180_41100 n1_M2_97260_41100 0.988200
R5258 n1_M2_97260_41100 n1_M2_98340_41100 0.988200
R5259 n1_M2_98340_41100 n1_M2_99420_41100 0.988200
R5260 n1_M2_99420_41100 n1_M2_100500_41100 0.988200
R5261 n1_M2_100500_41100 n1_M2_101580_41100 0.988200
R5262 n1_M2_101580_41100 n1_M2_102660_41100 0.988200
R5263 n1_M2_102660_41100 n1_M2_103740_41100 0.988200
R5264 n1_M2_103740_41100 n1_M2_104820_41100 0.988200
R5265 n1_M2_104820_41100 n1_M2_105900_41100 0.988200
R5266 n1_M2_105900_41100 n1_M2_106980_41100 0.988200
R5267 n1_M2_106980_41100 n1_M2_108060_41100 0.988200
R5268 n1_M2_108060_41100 n1_M2_109140_41100 0.988200
R5269 n1_M2_109140_41100 n1_M2_110220_41100 0.988200
R5270 n1_M2_110220_41100 n1_M2_111300_41100 0.988200
R5271 n1_M2_111300_41100 n1_M2_112380_41100 0.988200
R5272 n1_M2_112380_41100 n1_M2_113460_41100 0.988200
R5273 n1_M2_113460_41100 n1_M2_114540_41100 0.988200
R5274 n1_M2_114540_41100 n1_M2_115620_41100 0.988200
R5275 n1_M2_115620_41100 n1_M2_116700_41100 0.988200
R5276 n1_M2_116700_41100 n1_M2_117780_41100 0.988200
R5277 n1_M2_117780_41100 n1_M2_118860_41100 0.988200
R5278 n1_M2_118860_41100 n1_M2_119940_41100 0.988200
R5279 n1_M2_119940_41100 n1_M2_121020_41100 0.988200
R5280 n1_M2_121020_41100 n1_M2_122100_41100 0.988200
R5281 n1_M2_122100_41100 n1_M2_123180_41100 0.988200
R5282 n1_M2_123180_41100 n1_M2_124260_41100 0.988200
R5283 n1_M2_124260_41100 n1_M2_125340_41100 0.988200
R5284 n1_M2_125340_41100 n1_M2_126420_41100 0.988200
R5285 n1_M2_126420_41100 n1_M2_127500_41100 0.988200
R5286 n1_M2_127500_41100 n1_M2_128580_41100 0.988200
R5287 n1_M2_128580_41100 n1_M2_129660_41100 0.988200
R5288 n1_M2_129660_41100 n1_M2_130740_41100 0.988200
R5289 n1_M2_130740_41100 n1_M2_131820_41100 0.988200
R5290 n1_M2_131820_41100 n1_M2_132900_41100 0.988200
R5291 n1_M2_132900_41100 n1_M2_133980_41100 0.988200
R5292 n1_M2_133980_41100 n1_M2_135060_41100 0.988200
R5293 n1_M2_135060_41100 n1_M2_136140_41100 0.988200
R5294 n1_M2_136140_41100 n1_M2_137220_41100 0.988200
R5295 n1_M2_137220_41100 n1_M2_138300_41100 0.988200
R5296 n1_M2_138300_41100 n1_M2_139380_41100 0.988200
R5297 n1_M2_139380_41100 n1_M2_140460_41100 0.988200
R5298 n1_M2_140460_41100 n1_M2_141540_41100 0.988200
R5299 n1_M2_141540_41100 n1_M2_142620_41100 0.988200
R5300 n1_M2_142620_41100 n1_M2_143700_41100 0.988200
R5301 n1_M2_143700_41100 n1_M2_144780_41100 0.988200
R5302 n1_M2_144780_41100 n1_M2_145860_41100 0.988200
R5303 n1_M2_145860_41100 n1_M2_146940_41100 0.988200
R5304 n1_M2_60_42180 n1_M2_1140_42180 0.988200
R5305 n1_M2_1140_42180 n1_M2_2220_42180 0.988200
R5306 n1_M2_2220_42180 n1_M2_3300_42180 0.988200
R5307 n1_M2_3300_42180 n1_M2_4380_42180 0.988200
R5308 n1_M2_4380_42180 n1_M2_5460_42180 0.988200
R5309 n1_M2_5460_42180 n1_M2_6540_42180 0.988200
R5310 n1_M2_6540_42180 n1_M2_7620_42180 0.988200
R5311 n1_M2_7620_42180 n1_M2_8700_42180 0.988200
R5312 n1_M2_8700_42180 n1_M2_9780_42180 0.988200
R5313 n1_M2_9780_42180 n1_M2_10860_42180 0.988200
R5314 n1_M2_10860_42180 n1_M2_11940_42180 0.988200
R5315 n1_M2_11940_42180 n1_M2_13020_42180 0.988200
R5316 n1_M2_13020_42180 n1_M2_14100_42180 0.988200
R5317 n1_M2_14100_42180 n1_M2_15180_42180 0.988200
R5318 n1_M2_15180_42180 n1_M2_16260_42180 0.988200
R5319 n1_M2_16260_42180 n1_M2_17340_42180 0.988200
R5320 n1_M2_17340_42180 n1_M2_18420_42180 0.988200
R5321 n1_M2_18420_42180 n1_M2_19500_42180 0.988200
R5322 n1_M2_19500_42180 n1_M2_20580_42180 0.988200
R5323 n1_M2_20580_42180 n1_M2_21660_42180 0.988200
R5324 n1_M2_21660_42180 n1_M2_22740_42180 0.988200
R5325 n1_M2_22740_42180 n1_M2_23820_42180 0.988200
R5326 n1_M2_23820_42180 n1_M2_24900_42180 0.988200
R5327 n1_M2_24900_42180 n1_M2_25980_42180 0.988200
R5328 n1_M2_25980_42180 n1_M2_27060_42180 0.988200
R5329 n1_M2_27060_42180 n1_M2_28140_42180 0.988200
R5330 n1_M2_28140_42180 n1_M2_29220_42180 0.988200
R5331 n1_M2_29220_42180 n1_M2_30300_42180 0.988200
R5332 n1_M2_30300_42180 n1_M2_31380_42180 0.988200
R5333 n1_M2_31380_42180 n1_M2_32460_42180 0.988200
R5334 n1_M2_32460_42180 n1_M2_33540_42180 0.988200
R5335 n1_M2_33540_42180 n1_M2_34620_42180 0.988200
R5336 n1_M2_34620_42180 n1_M2_35700_42180 0.988200
R5337 n1_M2_35700_42180 n1_M2_36780_42180 0.988200
R5338 n1_M2_36780_42180 n1_M2_37860_42180 0.988200
R5339 n1_M2_37860_42180 n1_M2_38940_42180 0.988200
R5340 n1_M2_38940_42180 n1_M2_40020_42180 0.988200
R5341 n1_M2_40020_42180 n1_M2_41100_42180 0.988200
R5342 n1_M2_41100_42180 n1_M2_42180_42180 0.988200
R5343 n1_M2_42180_42180 n1_M2_43260_42180 0.988200
R5344 n1_M2_43260_42180 n1_M2_44340_42180 0.988200
R5345 n1_M2_44340_42180 n1_M2_45420_42180 0.988200
R5346 n1_M2_45420_42180 n1_M2_46500_42180 0.988200
R5347 n1_M2_46500_42180 n1_M2_47580_42180 0.988200
R5348 n1_M2_47580_42180 n1_M2_48660_42180 0.988200
R5349 n1_M2_48660_42180 n1_M2_49740_42180 0.988200
R5350 n1_M2_49740_42180 n1_M2_50820_42180 0.988200
R5351 n1_M2_50820_42180 n1_M2_51900_42180 0.988200
R5352 n1_M2_51900_42180 n1_M2_52980_42180 0.988200
R5353 n1_M2_52980_42180 n1_M2_54060_42180 0.988200
R5354 n1_M2_54060_42180 n1_M2_55140_42180 0.988200
R5355 n1_M2_55140_42180 n1_M2_56220_42180 0.988200
R5356 n1_M2_56220_42180 n1_M2_57300_42180 0.988200
R5357 n1_M2_57300_42180 n1_M2_58380_42180 0.988200
R5358 n1_M2_58380_42180 n1_M2_59460_42180 0.988200
R5359 n1_M2_59460_42180 n1_M2_60540_42180 0.988200
R5360 n1_M2_60540_42180 n1_M2_61620_42180 0.988200
R5361 n1_M2_61620_42180 n1_M2_62700_42180 0.988200
R5362 n1_M2_62700_42180 n1_M2_63780_42180 0.988200
R5363 n1_M2_63780_42180 n1_M2_64860_42180 0.988200
R5364 n1_M2_64860_42180 n1_M2_65940_42180 0.988200
R5365 n1_M2_65940_42180 n1_M2_67020_42180 0.988200
R5366 n1_M2_67020_42180 n1_M2_68100_42180 0.988200
R5367 n1_M2_68100_42180 n1_M2_69180_42180 0.988200
R5368 n1_M2_69180_42180 n1_M2_70260_42180 0.988200
R5369 n1_M2_70260_42180 n1_M2_71340_42180 0.988200
R5370 n1_M2_71340_42180 n1_M2_72420_42180 0.988200
R5371 n1_M2_72420_42180 n1_M2_73500_42180 0.988200
R5372 n1_M2_73500_42180 n1_M2_74580_42180 0.988200
R5373 n1_M2_74580_42180 n1_M2_75660_42180 0.988200
R5374 n1_M2_75660_42180 n1_M2_76740_42180 0.988200
R5375 n1_M2_76740_42180 n1_M2_77820_42180 0.988200
R5376 n1_M2_77820_42180 n1_M2_78900_42180 0.988200
R5377 n1_M2_78900_42180 n1_M2_79980_42180 0.988200
R5378 n1_M2_79980_42180 n1_M2_81060_42180 0.988200
R5379 n1_M2_81060_42180 n1_M2_82140_42180 0.988200
R5380 n1_M2_82140_42180 n1_M2_83220_42180 0.988200
R5381 n1_M2_83220_42180 n1_M2_84300_42180 0.988200
R5382 n1_M2_84300_42180 n1_M2_85380_42180 0.988200
R5383 n1_M2_85380_42180 n1_M2_86460_42180 0.988200
R5384 n1_M2_86460_42180 n1_M2_87540_42180 0.988200
R5385 n1_M2_87540_42180 n1_M2_88620_42180 0.988200
R5386 n1_M2_88620_42180 n1_M2_89700_42180 0.988200
R5387 n1_M2_89700_42180 n1_M2_90780_42180 0.988200
R5388 n1_M2_90780_42180 n1_M2_91860_42180 0.988200
R5389 n1_M2_91860_42180 n1_M2_92940_42180 0.988200
R5390 n1_M2_92940_42180 n1_M2_94020_42180 0.988200
R5391 n1_M2_94020_42180 n1_M2_95100_42180 0.988200
R5392 n1_M2_95100_42180 n1_M2_96180_42180 0.988200
R5393 n1_M2_96180_42180 n1_M2_97260_42180 0.988200
R5394 n1_M2_97260_42180 n1_M2_98340_42180 0.988200
R5395 n1_M2_98340_42180 n1_M2_99420_42180 0.988200
R5396 n1_M2_99420_42180 n1_M2_100500_42180 0.988200
R5397 n1_M2_100500_42180 n1_M2_101580_42180 0.988200
R5398 n1_M2_101580_42180 n1_M2_102660_42180 0.988200
R5399 n1_M2_102660_42180 n1_M2_103740_42180 0.988200
R5400 n1_M2_103740_42180 n1_M2_104820_42180 0.988200
R5401 n1_M2_104820_42180 n1_M2_105900_42180 0.988200
R5402 n1_M2_105900_42180 n1_M2_106980_42180 0.988200
R5403 n1_M2_106980_42180 n1_M2_108060_42180 0.988200
R5404 n1_M2_108060_42180 n1_M2_109140_42180 0.988200
R5405 n1_M2_109140_42180 n1_M2_110220_42180 0.988200
R5406 n1_M2_110220_42180 n1_M2_111300_42180 0.988200
R5407 n1_M2_111300_42180 n1_M2_112380_42180 0.988200
R5408 n1_M2_112380_42180 n1_M2_113460_42180 0.988200
R5409 n1_M2_113460_42180 n1_M2_114540_42180 0.988200
R5410 n1_M2_114540_42180 n1_M2_115620_42180 0.988200
R5411 n1_M2_115620_42180 n1_M2_116700_42180 0.988200
R5412 n1_M2_116700_42180 n1_M2_117780_42180 0.988200
R5413 n1_M2_117780_42180 n1_M2_118860_42180 0.988200
R5414 n1_M2_118860_42180 n1_M2_119940_42180 0.988200
R5415 n1_M2_119940_42180 n1_M2_121020_42180 0.988200
R5416 n1_M2_121020_42180 n1_M2_122100_42180 0.988200
R5417 n1_M2_122100_42180 n1_M2_123180_42180 0.988200
R5418 n1_M2_123180_42180 n1_M2_124260_42180 0.988200
R5419 n1_M2_124260_42180 n1_M2_125340_42180 0.988200
R5420 n1_M2_125340_42180 n1_M2_126420_42180 0.988200
R5421 n1_M2_126420_42180 n1_M2_127500_42180 0.988200
R5422 n1_M2_127500_42180 n1_M2_128580_42180 0.988200
R5423 n1_M2_128580_42180 n1_M2_129660_42180 0.988200
R5424 n1_M2_129660_42180 n1_M2_130740_42180 0.988200
R5425 n1_M2_130740_42180 n1_M2_131820_42180 0.988200
R5426 n1_M2_131820_42180 n1_M2_132900_42180 0.988200
R5427 n1_M2_132900_42180 n1_M2_133980_42180 0.988200
R5428 n1_M2_133980_42180 n1_M2_135060_42180 0.988200
R5429 n1_M2_135060_42180 n1_M2_136140_42180 0.988200
R5430 n1_M2_136140_42180 n1_M2_137220_42180 0.988200
R5431 n1_M2_137220_42180 n1_M2_138300_42180 0.988200
R5432 n1_M2_138300_42180 n1_M2_139380_42180 0.988200
R5433 n1_M2_139380_42180 n1_M2_140460_42180 0.988200
R5434 n1_M2_140460_42180 n1_M2_141540_42180 0.988200
R5435 n1_M2_141540_42180 n1_M2_142620_42180 0.988200
R5436 n1_M2_142620_42180 n1_M2_143700_42180 0.988200
R5437 n1_M2_143700_42180 n1_M2_144780_42180 0.988200
R5438 n1_M2_144780_42180 n1_M2_145860_42180 0.988200
R5439 n1_M2_145860_42180 n1_M2_146940_42180 0.988200
R5440 n1_M2_60_43260 n1_M2_1140_43260 0.988200
R5441 n1_M2_1140_43260 n1_M2_2220_43260 0.988200
R5442 n1_M2_2220_43260 n1_M2_3300_43260 0.988200
R5443 n1_M2_3300_43260 n1_M2_4380_43260 0.988200
R5444 n1_M2_4380_43260 n1_M2_5460_43260 0.988200
R5445 n1_M2_5460_43260 n1_M2_6540_43260 0.988200
R5446 n1_M2_6540_43260 n1_M2_7620_43260 0.988200
R5447 n1_M2_7620_43260 n1_M2_8700_43260 0.988200
R5448 n1_M2_8700_43260 n1_M2_9780_43260 0.988200
R5449 n1_M2_9780_43260 n1_M2_10860_43260 0.988200
R5450 n1_M2_10860_43260 n1_M2_11940_43260 0.988200
R5451 n1_M2_11940_43260 n1_M2_13020_43260 0.988200
R5452 n1_M2_13020_43260 n1_M2_14100_43260 0.988200
R5453 n1_M2_14100_43260 n1_M2_15180_43260 0.988200
R5454 n1_M2_15180_43260 n1_M2_16260_43260 0.988200
R5455 n1_M2_16260_43260 n1_M2_17340_43260 0.988200
R5456 n1_M2_17340_43260 n1_M2_18420_43260 0.988200
R5457 n1_M2_18420_43260 n1_M2_19500_43260 0.988200
R5458 n1_M2_19500_43260 n1_M2_20580_43260 0.988200
R5459 n1_M2_20580_43260 n1_M2_21660_43260 0.988200
R5460 n1_M2_21660_43260 n1_M2_22740_43260 0.988200
R5461 n1_M2_22740_43260 n1_M2_23820_43260 0.988200
R5462 n1_M2_23820_43260 n1_M2_24900_43260 0.988200
R5463 n1_M2_24900_43260 n1_M2_25980_43260 0.988200
R5464 n1_M2_25980_43260 n1_M2_27060_43260 0.988200
R5465 n1_M2_27060_43260 n1_M2_28140_43260 0.988200
R5466 n1_M2_28140_43260 n1_M2_29220_43260 0.988200
R5467 n1_M2_29220_43260 n1_M2_30300_43260 0.988200
R5468 n1_M2_30300_43260 n1_M2_31380_43260 0.988200
R5469 n1_M2_31380_43260 n1_M2_32460_43260 0.988200
R5470 n1_M2_32460_43260 n1_M2_33540_43260 0.988200
R5471 n1_M2_33540_43260 n1_M2_34620_43260 0.988200
R5472 n1_M2_34620_43260 n1_M2_35700_43260 0.988200
R5473 n1_M2_35700_43260 n1_M2_36780_43260 0.988200
R5474 n1_M2_36780_43260 n1_M2_37860_43260 0.988200
R5475 n1_M2_37860_43260 n1_M2_38940_43260 0.988200
R5476 n1_M2_38940_43260 n1_M2_40020_43260 0.988200
R5477 n1_M2_40020_43260 n1_M2_41100_43260 0.988200
R5478 n1_M2_41100_43260 n1_M2_42180_43260 0.988200
R5479 n1_M2_42180_43260 n1_M2_43260_43260 0.988200
R5480 n1_M2_43260_43260 n1_M2_44340_43260 0.988200
R5481 n1_M2_44340_43260 n1_M2_45420_43260 0.988200
R5482 n1_M2_45420_43260 n1_M2_46500_43260 0.988200
R5483 n1_M2_46500_43260 n1_M2_47580_43260 0.988200
R5484 n1_M2_47580_43260 n1_M2_48660_43260 0.988200
R5485 n1_M2_48660_43260 n1_M2_49740_43260 0.988200
R5486 n1_M2_49740_43260 n1_M2_50820_43260 0.988200
R5487 n1_M2_50820_43260 n1_M2_51900_43260 0.988200
R5488 n1_M2_51900_43260 n1_M2_52980_43260 0.988200
R5489 n1_M2_52980_43260 n1_M2_54060_43260 0.988200
R5490 n1_M2_54060_43260 n1_M2_55140_43260 0.988200
R5491 n1_M2_55140_43260 n1_M2_56220_43260 0.988200
R5492 n1_M2_56220_43260 n1_M2_57300_43260 0.988200
R5493 n1_M2_57300_43260 n1_M2_58380_43260 0.988200
R5494 n1_M2_58380_43260 n1_M2_59460_43260 0.988200
R5495 n1_M2_59460_43260 n1_M2_60540_43260 0.988200
R5496 n1_M2_60540_43260 n1_M2_61620_43260 0.988200
R5497 n1_M2_61620_43260 n1_M2_62700_43260 0.988200
R5498 n1_M2_62700_43260 n1_M2_63780_43260 0.988200
R5499 n1_M2_63780_43260 n1_M2_64860_43260 0.988200
R5500 n1_M2_64860_43260 n1_M2_65940_43260 0.988200
R5501 n1_M2_65940_43260 n1_M2_67020_43260 0.988200
R5502 n1_M2_67020_43260 n1_M2_68100_43260 0.988200
R5503 n1_M2_68100_43260 n1_M2_69180_43260 0.988200
R5504 n1_M2_69180_43260 n1_M2_70260_43260 0.988200
R5505 n1_M2_70260_43260 n1_M2_71340_43260 0.988200
R5506 n1_M2_71340_43260 n1_M2_72420_43260 0.988200
R5507 n1_M2_72420_43260 n1_M2_73500_43260 0.988200
R5508 n1_M2_73500_43260 n1_M2_74580_43260 0.988200
R5509 n1_M2_74580_43260 n1_M2_75660_43260 0.988200
R5510 n1_M2_75660_43260 n1_M2_76740_43260 0.988200
R5511 n1_M2_76740_43260 n1_M2_77820_43260 0.988200
R5512 n1_M2_77820_43260 n1_M2_78900_43260 0.988200
R5513 n1_M2_78900_43260 n1_M2_79980_43260 0.988200
R5514 n1_M2_79980_43260 n1_M2_81060_43260 0.988200
R5515 n1_M2_81060_43260 n1_M2_82140_43260 0.988200
R5516 n1_M2_82140_43260 n1_M2_83220_43260 0.988200
R5517 n1_M2_83220_43260 n1_M2_84300_43260 0.988200
R5518 n1_M2_84300_43260 n1_M2_85380_43260 0.988200
R5519 n1_M2_85380_43260 n1_M2_86460_43260 0.988200
R5520 n1_M2_86460_43260 n1_M2_87540_43260 0.988200
R5521 n1_M2_87540_43260 n1_M2_88620_43260 0.988200
R5522 n1_M2_88620_43260 n1_M2_89700_43260 0.988200
R5523 n1_M2_89700_43260 n1_M2_90780_43260 0.988200
R5524 n1_M2_90780_43260 n1_M2_91860_43260 0.988200
R5525 n1_M2_91860_43260 n1_M2_92940_43260 0.988200
R5526 n1_M2_92940_43260 n1_M2_94020_43260 0.988200
R5527 n1_M2_94020_43260 n1_M2_95100_43260 0.988200
R5528 n1_M2_95100_43260 n1_M2_96180_43260 0.988200
R5529 n1_M2_96180_43260 n1_M2_97260_43260 0.988200
R5530 n1_M2_97260_43260 n1_M2_98340_43260 0.988200
R5531 n1_M2_98340_43260 n1_M2_99420_43260 0.988200
R5532 n1_M2_99420_43260 n1_M2_100500_43260 0.988200
R5533 n1_M2_100500_43260 n1_M2_101580_43260 0.988200
R5534 n1_M2_101580_43260 n1_M2_102660_43260 0.988200
R5535 n1_M2_102660_43260 n1_M2_103740_43260 0.988200
R5536 n1_M2_103740_43260 n1_M2_104820_43260 0.988200
R5537 n1_M2_104820_43260 n1_M2_105900_43260 0.988200
R5538 n1_M2_105900_43260 n1_M2_106980_43260 0.988200
R5539 n1_M2_106980_43260 n1_M2_108060_43260 0.988200
R5540 n1_M2_108060_43260 n1_M2_109140_43260 0.988200
R5541 n1_M2_109140_43260 n1_M2_110220_43260 0.988200
R5542 n1_M2_110220_43260 n1_M2_111300_43260 0.988200
R5543 n1_M2_111300_43260 n1_M2_112380_43260 0.988200
R5544 n1_M2_112380_43260 n1_M2_113460_43260 0.988200
R5545 n1_M2_113460_43260 n1_M2_114540_43260 0.988200
R5546 n1_M2_114540_43260 n1_M2_115620_43260 0.988200
R5547 n1_M2_115620_43260 n1_M2_116700_43260 0.988200
R5548 n1_M2_116700_43260 n1_M2_117780_43260 0.988200
R5549 n1_M2_117780_43260 n1_M2_118860_43260 0.988200
R5550 n1_M2_118860_43260 n1_M2_119940_43260 0.988200
R5551 n1_M2_119940_43260 n1_M2_121020_43260 0.988200
R5552 n1_M2_121020_43260 n1_M2_122100_43260 0.988200
R5553 n1_M2_122100_43260 n1_M2_123180_43260 0.988200
R5554 n1_M2_123180_43260 n1_M2_124260_43260 0.988200
R5555 n1_M2_124260_43260 n1_M2_125340_43260 0.988200
R5556 n1_M2_125340_43260 n1_M2_126420_43260 0.988200
R5557 n1_M2_126420_43260 n1_M2_127500_43260 0.988200
R5558 n1_M2_127500_43260 n1_M2_128580_43260 0.988200
R5559 n1_M2_128580_43260 n1_M2_129660_43260 0.988200
R5560 n1_M2_129660_43260 n1_M2_130740_43260 0.988200
R5561 n1_M2_130740_43260 n1_M2_131820_43260 0.988200
R5562 n1_M2_131820_43260 n1_M2_132900_43260 0.988200
R5563 n1_M2_132900_43260 n1_M2_133980_43260 0.988200
R5564 n1_M2_133980_43260 n1_M2_135060_43260 0.988200
R5565 n1_M2_135060_43260 n1_M2_136140_43260 0.988200
R5566 n1_M2_136140_43260 n1_M2_137220_43260 0.988200
R5567 n1_M2_137220_43260 n1_M2_138300_43260 0.988200
R5568 n1_M2_138300_43260 n1_M2_139380_43260 0.988200
R5569 n1_M2_139380_43260 n1_M2_140460_43260 0.988200
R5570 n1_M2_140460_43260 n1_M2_141540_43260 0.988200
R5571 n1_M2_141540_43260 n1_M2_142620_43260 0.988200
R5572 n1_M2_142620_43260 n1_M2_143700_43260 0.988200
R5573 n1_M2_143700_43260 n1_M2_144780_43260 0.988200
R5574 n1_M2_144780_43260 n1_M2_145860_43260 0.988200
R5575 n1_M2_145860_43260 n1_M2_146940_43260 0.988200
R5576 n1_M2_60_44340 n1_M2_1140_44340 0.988200
R5577 n1_M2_1140_44340 n1_M2_2220_44340 0.988200
R5578 n1_M2_2220_44340 n1_M2_3300_44340 0.988200
R5579 n1_M2_3300_44340 n1_M2_4380_44340 0.988200
R5580 n1_M2_4380_44340 n1_M2_5460_44340 0.988200
R5581 n1_M2_5460_44340 n1_M2_6540_44340 0.988200
R5582 n1_M2_6540_44340 n1_M2_7620_44340 0.988200
R5583 n1_M2_7620_44340 n1_M2_8700_44340 0.988200
R5584 n1_M2_8700_44340 n1_M2_9780_44340 0.988200
R5585 n1_M2_9780_44340 n1_M2_10860_44340 0.988200
R5586 n1_M2_10860_44340 n1_M2_11940_44340 0.988200
R5587 n1_M2_11940_44340 n1_M2_13020_44340 0.988200
R5588 n1_M2_13020_44340 n1_M2_14100_44340 0.988200
R5589 n1_M2_14100_44340 n1_M2_15180_44340 0.988200
R5590 n1_M2_15180_44340 n1_M2_16260_44340 0.988200
R5591 n1_M2_16260_44340 n1_M2_17340_44340 0.988200
R5592 n1_M2_17340_44340 n1_M2_18420_44340 0.988200
R5593 n1_M2_18420_44340 n1_M2_19500_44340 0.988200
R5594 n1_M2_19500_44340 n1_M2_20580_44340 0.988200
R5595 n1_M2_20580_44340 n1_M2_21660_44340 0.988200
R5596 n1_M2_21660_44340 n1_M2_22740_44340 0.988200
R5597 n1_M2_22740_44340 n1_M2_23820_44340 0.988200
R5598 n1_M2_23820_44340 n1_M2_24900_44340 0.988200
R5599 n1_M2_24900_44340 n1_M2_25980_44340 0.988200
R5600 n1_M2_25980_44340 n1_M2_27060_44340 0.988200
R5601 n1_M2_27060_44340 n1_M2_28140_44340 0.988200
R5602 n1_M2_28140_44340 n1_M2_29220_44340 0.988200
R5603 n1_M2_29220_44340 n1_M2_30300_44340 0.988200
R5604 n1_M2_30300_44340 n1_M2_31380_44340 0.988200
R5605 n1_M2_31380_44340 n1_M2_32460_44340 0.988200
R5606 n1_M2_32460_44340 n1_M2_33540_44340 0.988200
R5607 n1_M2_33540_44340 n1_M2_34620_44340 0.988200
R5608 n1_M2_34620_44340 n1_M2_35700_44340 0.988200
R5609 n1_M2_35700_44340 n1_M2_36780_44340 0.988200
R5610 n1_M2_36780_44340 n1_M2_37860_44340 0.988200
R5611 n1_M2_37860_44340 n1_M2_38940_44340 0.988200
R5612 n1_M2_38940_44340 n1_M2_40020_44340 0.988200
R5613 n1_M2_40020_44340 n1_M2_41100_44340 0.988200
R5614 n1_M2_41100_44340 n1_M2_42180_44340 0.988200
R5615 n1_M2_42180_44340 n1_M2_43260_44340 0.988200
R5616 n1_M2_43260_44340 n1_M2_44340_44340 0.988200
R5617 n1_M2_44340_44340 n1_M2_45420_44340 0.988200
R5618 n1_M2_45420_44340 n1_M2_46500_44340 0.988200
R5619 n1_M2_46500_44340 n1_M2_47580_44340 0.988200
R5620 n1_M2_47580_44340 n1_M2_48660_44340 0.988200
R5621 n1_M2_48660_44340 n1_M2_49740_44340 0.988200
R5622 n1_M2_49740_44340 n1_M2_50820_44340 0.988200
R5623 n1_M2_50820_44340 n1_M2_51900_44340 0.988200
R5624 n1_M2_51900_44340 n1_M2_52980_44340 0.988200
R5625 n1_M2_52980_44340 n1_M2_54060_44340 0.988200
R5626 n1_M2_54060_44340 n1_M2_55140_44340 0.988200
R5627 n1_M2_55140_44340 n1_M2_56220_44340 0.988200
R5628 n1_M2_56220_44340 n1_M2_57300_44340 0.988200
R5629 n1_M2_57300_44340 n1_M2_58380_44340 0.988200
R5630 n1_M2_58380_44340 n1_M2_59460_44340 0.988200
R5631 n1_M2_59460_44340 n1_M2_60540_44340 0.988200
R5632 n1_M2_60540_44340 n1_M2_61620_44340 0.988200
R5633 n1_M2_61620_44340 n1_M2_62700_44340 0.988200
R5634 n1_M2_62700_44340 n1_M2_63780_44340 0.988200
R5635 n1_M2_63780_44340 n1_M2_64860_44340 0.988200
R5636 n1_M2_64860_44340 n1_M2_65940_44340 0.988200
R5637 n1_M2_65940_44340 n1_M2_67020_44340 0.988200
R5638 n1_M2_67020_44340 n1_M2_68100_44340 0.988200
R5639 n1_M2_68100_44340 n1_M2_69180_44340 0.988200
R5640 n1_M2_69180_44340 n1_M2_70260_44340 0.988200
R5641 n1_M2_70260_44340 n1_M2_71340_44340 0.988200
R5642 n1_M2_71340_44340 n1_M2_72420_44340 0.988200
R5643 n1_M2_72420_44340 n1_M2_73500_44340 0.988200
R5644 n1_M2_73500_44340 n1_M2_74580_44340 0.988200
R5645 n1_M2_74580_44340 n1_M2_75660_44340 0.988200
R5646 n1_M2_75660_44340 n1_M2_76740_44340 0.988200
R5647 n1_M2_76740_44340 n1_M2_77820_44340 0.988200
R5648 n1_M2_77820_44340 n1_M2_78900_44340 0.988200
R5649 n1_M2_78900_44340 n1_M2_79980_44340 0.988200
R5650 n1_M2_79980_44340 n1_M2_81060_44340 0.988200
R5651 n1_M2_81060_44340 n1_M2_82140_44340 0.988200
R5652 n1_M2_82140_44340 n1_M2_83220_44340 0.988200
R5653 n1_M2_83220_44340 n1_M2_84300_44340 0.988200
R5654 n1_M2_84300_44340 n1_M2_85380_44340 0.988200
R5655 n1_M2_85380_44340 n1_M2_86460_44340 0.988200
R5656 n1_M2_86460_44340 n1_M2_87540_44340 0.988200
R5657 n1_M2_87540_44340 n1_M2_88620_44340 0.988200
R5658 n1_M2_88620_44340 n1_M2_89700_44340 0.988200
R5659 n1_M2_89700_44340 n1_M2_90780_44340 0.988200
R5660 n1_M2_90780_44340 n1_M2_91860_44340 0.988200
R5661 n1_M2_91860_44340 n1_M2_92940_44340 0.988200
R5662 n1_M2_92940_44340 n1_M2_94020_44340 0.988200
R5663 n1_M2_94020_44340 n1_M2_95100_44340 0.988200
R5664 n1_M2_95100_44340 n1_M2_96180_44340 0.988200
R5665 n1_M2_96180_44340 n1_M2_97260_44340 0.988200
R5666 n1_M2_97260_44340 n1_M2_98340_44340 0.988200
R5667 n1_M2_98340_44340 n1_M2_99420_44340 0.988200
R5668 n1_M2_99420_44340 n1_M2_100500_44340 0.988200
R5669 n1_M2_100500_44340 n1_M2_101580_44340 0.988200
R5670 n1_M2_101580_44340 n1_M2_102660_44340 0.988200
R5671 n1_M2_102660_44340 n1_M2_103740_44340 0.988200
R5672 n1_M2_103740_44340 n1_M2_104820_44340 0.988200
R5673 n1_M2_104820_44340 n1_M2_105900_44340 0.988200
R5674 n1_M2_105900_44340 n1_M2_106980_44340 0.988200
R5675 n1_M2_106980_44340 n1_M2_108060_44340 0.988200
R5676 n1_M2_108060_44340 n1_M2_109140_44340 0.988200
R5677 n1_M2_109140_44340 n1_M2_110220_44340 0.988200
R5678 n1_M2_110220_44340 n1_M2_111300_44340 0.988200
R5679 n1_M2_111300_44340 n1_M2_112380_44340 0.988200
R5680 n1_M2_112380_44340 n1_M2_113460_44340 0.988200
R5681 n1_M2_113460_44340 n1_M2_114540_44340 0.988200
R5682 n1_M2_114540_44340 n1_M2_115620_44340 0.988200
R5683 n1_M2_115620_44340 n1_M2_116700_44340 0.988200
R5684 n1_M2_116700_44340 n1_M2_117780_44340 0.988200
R5685 n1_M2_117780_44340 n1_M2_118860_44340 0.988200
R5686 n1_M2_118860_44340 n1_M2_119940_44340 0.988200
R5687 n1_M2_119940_44340 n1_M2_121020_44340 0.988200
R5688 n1_M2_121020_44340 n1_M2_122100_44340 0.988200
R5689 n1_M2_122100_44340 n1_M2_123180_44340 0.988200
R5690 n1_M2_123180_44340 n1_M2_124260_44340 0.988200
R5691 n1_M2_124260_44340 n1_M2_125340_44340 0.988200
R5692 n1_M2_125340_44340 n1_M2_126420_44340 0.988200
R5693 n1_M2_126420_44340 n1_M2_127500_44340 0.988200
R5694 n1_M2_127500_44340 n1_M2_128580_44340 0.988200
R5695 n1_M2_128580_44340 n1_M2_129660_44340 0.988200
R5696 n1_M2_129660_44340 n1_M2_130740_44340 0.988200
R5697 n1_M2_130740_44340 n1_M2_131820_44340 0.988200
R5698 n1_M2_131820_44340 n1_M2_132900_44340 0.988200
R5699 n1_M2_132900_44340 n1_M2_133980_44340 0.988200
R5700 n1_M2_133980_44340 n1_M2_135060_44340 0.988200
R5701 n1_M2_135060_44340 n1_M2_136140_44340 0.988200
R5702 n1_M2_136140_44340 n1_M2_137220_44340 0.988200
R5703 n1_M2_137220_44340 n1_M2_138300_44340 0.988200
R5704 n1_M2_138300_44340 n1_M2_139380_44340 0.988200
R5705 n1_M2_139380_44340 n1_M2_140460_44340 0.988200
R5706 n1_M2_140460_44340 n1_M2_141540_44340 0.988200
R5707 n1_M2_141540_44340 n1_M2_142620_44340 0.988200
R5708 n1_M2_142620_44340 n1_M2_143700_44340 0.988200
R5709 n1_M2_143700_44340 n1_M2_144780_44340 0.988200
R5710 n1_M2_144780_44340 n1_M2_145860_44340 0.988200
R5711 n1_M2_145860_44340 n1_M2_146940_44340 0.988200
R5712 n1_M2_60_45420 n1_M2_1140_45420 0.988200
R5713 n1_M2_1140_45420 n1_M2_2220_45420 0.988200
R5714 n1_M2_2220_45420 n1_M2_3300_45420 0.988200
R5715 n1_M2_3300_45420 n1_M2_4380_45420 0.988200
R5716 n1_M2_4380_45420 n1_M2_5460_45420 0.988200
R5717 n1_M2_5460_45420 n1_M2_6540_45420 0.988200
R5718 n1_M2_6540_45420 n1_M2_7620_45420 0.988200
R5719 n1_M2_7620_45420 n1_M2_8700_45420 0.988200
R5720 n1_M2_8700_45420 n1_M2_9780_45420 0.988200
R5721 n1_M2_9780_45420 n1_M2_10860_45420 0.988200
R5722 n1_M2_10860_45420 n1_M2_11940_45420 0.988200
R5723 n1_M2_11940_45420 n1_M2_13020_45420 0.988200
R5724 n1_M2_13020_45420 n1_M2_14100_45420 0.988200
R5725 n1_M2_14100_45420 n1_M2_15180_45420 0.988200
R5726 n1_M2_15180_45420 n1_M2_16260_45420 0.988200
R5727 n1_M2_16260_45420 n1_M2_17340_45420 0.988200
R5728 n1_M2_17340_45420 n1_M2_18420_45420 0.988200
R5729 n1_M2_18420_45420 n1_M2_19500_45420 0.988200
R5730 n1_M2_19500_45420 n1_M2_20580_45420 0.988200
R5731 n1_M2_20580_45420 n1_M2_21660_45420 0.988200
R5732 n1_M2_21660_45420 n1_M2_22740_45420 0.988200
R5733 n1_M2_22740_45420 n1_M2_23820_45420 0.988200
R5734 n1_M2_23820_45420 n1_M2_24900_45420 0.988200
R5735 n1_M2_24900_45420 n1_M2_25980_45420 0.988200
R5736 n1_M2_25980_45420 n1_M2_27060_45420 0.988200
R5737 n1_M2_27060_45420 n1_M2_28140_45420 0.988200
R5738 n1_M2_28140_45420 n1_M2_29220_45420 0.988200
R5739 n1_M2_29220_45420 n1_M2_30300_45420 0.988200
R5740 n1_M2_30300_45420 n1_M2_31380_45420 0.988200
R5741 n1_M2_31380_45420 n1_M2_32460_45420 0.988200
R5742 n1_M2_32460_45420 n1_M2_33540_45420 0.988200
R5743 n1_M2_33540_45420 n1_M2_34620_45420 0.988200
R5744 n1_M2_34620_45420 n1_M2_35700_45420 0.988200
R5745 n1_M2_35700_45420 n1_M2_36780_45420 0.988200
R5746 n1_M2_36780_45420 n1_M2_37860_45420 0.988200
R5747 n1_M2_37860_45420 n1_M2_38940_45420 0.988200
R5748 n1_M2_38940_45420 n1_M2_40020_45420 0.988200
R5749 n1_M2_40020_45420 n1_M2_41100_45420 0.988200
R5750 n1_M2_41100_45420 n1_M2_42180_45420 0.988200
R5751 n1_M2_42180_45420 n1_M2_43260_45420 0.988200
R5752 n1_M2_43260_45420 n1_M2_44340_45420 0.988200
R5753 n1_M2_44340_45420 n1_M2_45420_45420 0.988200
R5754 n1_M2_45420_45420 n1_M2_46500_45420 0.988200
R5755 n1_M2_46500_45420 n1_M2_47580_45420 0.988200
R5756 n1_M2_47580_45420 n1_M2_48660_45420 0.988200
R5757 n1_M2_48660_45420 n1_M2_49740_45420 0.988200
R5758 n1_M2_49740_45420 n1_M2_50820_45420 0.988200
R5759 n1_M2_50820_45420 n1_M2_51900_45420 0.988200
R5760 n1_M2_51900_45420 n1_M2_52980_45420 0.988200
R5761 n1_M2_52980_45420 n1_M2_54060_45420 0.988200
R5762 n1_M2_54060_45420 n1_M2_55140_45420 0.988200
R5763 n1_M2_55140_45420 n1_M2_56220_45420 0.988200
R5764 n1_M2_56220_45420 n1_M2_57300_45420 0.988200
R5765 n1_M2_57300_45420 n1_M2_58380_45420 0.988200
R5766 n1_M2_58380_45420 n1_M2_59460_45420 0.988200
R5767 n1_M2_59460_45420 n1_M2_60540_45420 0.988200
R5768 n1_M2_60540_45420 n1_M2_61620_45420 0.988200
R5769 n1_M2_61620_45420 n1_M2_62700_45420 0.988200
R5770 n1_M2_62700_45420 n1_M2_63780_45420 0.988200
R5771 n1_M2_63780_45420 n1_M2_64860_45420 0.988200
R5772 n1_M2_64860_45420 n1_M2_65940_45420 0.988200
R5773 n1_M2_65940_45420 n1_M2_67020_45420 0.988200
R5774 n1_M2_67020_45420 n1_M2_68100_45420 0.988200
R5775 n1_M2_68100_45420 n1_M2_69180_45420 0.988200
R5776 n1_M2_69180_45420 n1_M2_70260_45420 0.988200
R5777 n1_M2_70260_45420 n1_M2_71340_45420 0.988200
R5778 n1_M2_71340_45420 n1_M2_72420_45420 0.988200
R5779 n1_M2_72420_45420 n1_M2_73500_45420 0.988200
R5780 n1_M2_73500_45420 n1_M2_74580_45420 0.988200
R5781 n1_M2_74580_45420 n1_M2_75660_45420 0.988200
R5782 n1_M2_75660_45420 n1_M2_76740_45420 0.988200
R5783 n1_M2_76740_45420 n1_M2_77820_45420 0.988200
R5784 n1_M2_77820_45420 n1_M2_78900_45420 0.988200
R5785 n1_M2_78900_45420 n1_M2_79980_45420 0.988200
R5786 n1_M2_79980_45420 n1_M2_81060_45420 0.988200
R5787 n1_M2_81060_45420 n1_M2_82140_45420 0.988200
R5788 n1_M2_82140_45420 n1_M2_83220_45420 0.988200
R5789 n1_M2_83220_45420 n1_M2_84300_45420 0.988200
R5790 n1_M2_84300_45420 n1_M2_85380_45420 0.988200
R5791 n1_M2_85380_45420 n1_M2_86460_45420 0.988200
R5792 n1_M2_86460_45420 n1_M2_87540_45420 0.988200
R5793 n1_M2_87540_45420 n1_M2_88620_45420 0.988200
R5794 n1_M2_88620_45420 n1_M2_89700_45420 0.988200
R5795 n1_M2_89700_45420 n1_M2_90780_45420 0.988200
R5796 n1_M2_90780_45420 n1_M2_91860_45420 0.988200
R5797 n1_M2_91860_45420 n1_M2_92940_45420 0.988200
R5798 n1_M2_92940_45420 n1_M2_94020_45420 0.988200
R5799 n1_M2_94020_45420 n1_M2_95100_45420 0.988200
R5800 n1_M2_95100_45420 n1_M2_96180_45420 0.988200
R5801 n1_M2_96180_45420 n1_M2_97260_45420 0.988200
R5802 n1_M2_97260_45420 n1_M2_98340_45420 0.988200
R5803 n1_M2_98340_45420 n1_M2_99420_45420 0.988200
R5804 n1_M2_99420_45420 n1_M2_100500_45420 0.988200
R5805 n1_M2_100500_45420 n1_M2_101580_45420 0.988200
R5806 n1_M2_101580_45420 n1_M2_102660_45420 0.988200
R5807 n1_M2_102660_45420 n1_M2_103740_45420 0.988200
R5808 n1_M2_103740_45420 n1_M2_104820_45420 0.988200
R5809 n1_M2_104820_45420 n1_M2_105900_45420 0.988200
R5810 n1_M2_105900_45420 n1_M2_106980_45420 0.988200
R5811 n1_M2_106980_45420 n1_M2_108060_45420 0.988200
R5812 n1_M2_108060_45420 n1_M2_109140_45420 0.988200
R5813 n1_M2_109140_45420 n1_M2_110220_45420 0.988200
R5814 n1_M2_110220_45420 n1_M2_111300_45420 0.988200
R5815 n1_M2_111300_45420 n1_M2_112380_45420 0.988200
R5816 n1_M2_112380_45420 n1_M2_113460_45420 0.988200
R5817 n1_M2_113460_45420 n1_M2_114540_45420 0.988200
R5818 n1_M2_114540_45420 n1_M2_115620_45420 0.988200
R5819 n1_M2_115620_45420 n1_M2_116700_45420 0.988200
R5820 n1_M2_116700_45420 n1_M2_117780_45420 0.988200
R5821 n1_M2_117780_45420 n1_M2_118860_45420 0.988200
R5822 n1_M2_118860_45420 n1_M2_119940_45420 0.988200
R5823 n1_M2_119940_45420 n1_M2_121020_45420 0.988200
R5824 n1_M2_121020_45420 n1_M2_122100_45420 0.988200
R5825 n1_M2_122100_45420 n1_M2_123180_45420 0.988200
R5826 n1_M2_123180_45420 n1_M2_124260_45420 0.988200
R5827 n1_M2_124260_45420 n1_M2_125340_45420 0.988200
R5828 n1_M2_125340_45420 n1_M2_126420_45420 0.988200
R5829 n1_M2_126420_45420 n1_M2_127500_45420 0.988200
R5830 n1_M2_127500_45420 n1_M2_128580_45420 0.988200
R5831 n1_M2_128580_45420 n1_M2_129660_45420 0.988200
R5832 n1_M2_129660_45420 n1_M2_130740_45420 0.988200
R5833 n1_M2_130740_45420 n1_M2_131820_45420 0.988200
R5834 n1_M2_131820_45420 n1_M2_132900_45420 0.988200
R5835 n1_M2_132900_45420 n1_M2_133980_45420 0.988200
R5836 n1_M2_133980_45420 n1_M2_135060_45420 0.988200
R5837 n1_M2_135060_45420 n1_M2_136140_45420 0.988200
R5838 n1_M2_136140_45420 n1_M2_137220_45420 0.988200
R5839 n1_M2_137220_45420 n1_M2_138300_45420 0.988200
R5840 n1_M2_138300_45420 n1_M2_139380_45420 0.988200
R5841 n1_M2_139380_45420 n1_M2_140460_45420 0.988200
R5842 n1_M2_140460_45420 n1_M2_141540_45420 0.988200
R5843 n1_M2_141540_45420 n1_M2_142620_45420 0.988200
R5844 n1_M2_142620_45420 n1_M2_143700_45420 0.988200
R5845 n1_M2_143700_45420 n1_M2_144780_45420 0.988200
R5846 n1_M2_144780_45420 n1_M2_145860_45420 0.988200
R5847 n1_M2_145860_45420 n1_M2_146940_45420 0.988200
R5848 n1_M2_60_46500 n1_M2_1140_46500 0.988200
R5849 n1_M2_1140_46500 n1_M2_2220_46500 0.988200
R5850 n1_M2_2220_46500 n1_M2_3300_46500 0.988200
R5851 n1_M2_3300_46500 n1_M2_4380_46500 0.988200
R5852 n1_M2_4380_46500 n1_M2_5460_46500 0.988200
R5853 n1_M2_5460_46500 n1_M2_6540_46500 0.988200
R5854 n1_M2_6540_46500 n1_M2_7620_46500 0.988200
R5855 n1_M2_7620_46500 n1_M2_8700_46500 0.988200
R5856 n1_M2_8700_46500 n1_M2_9780_46500 0.988200
R5857 n1_M2_9780_46500 n1_M2_10860_46500 0.988200
R5858 n1_M2_10860_46500 n1_M2_11940_46500 0.988200
R5859 n1_M2_11940_46500 n1_M2_13020_46500 0.988200
R5860 n1_M2_13020_46500 n1_M2_14100_46500 0.988200
R5861 n1_M2_14100_46500 n1_M2_15180_46500 0.988200
R5862 n1_M2_15180_46500 n1_M2_16260_46500 0.988200
R5863 n1_M2_16260_46500 n1_M2_17340_46500 0.988200
R5864 n1_M2_17340_46500 n1_M2_18420_46500 0.988200
R5865 n1_M2_18420_46500 n1_M2_19500_46500 0.988200
R5866 n1_M2_19500_46500 n1_M2_20580_46500 0.988200
R5867 n1_M2_20580_46500 n1_M2_21660_46500 0.988200
R5868 n1_M2_21660_46500 n1_M2_22740_46500 0.988200
R5869 n1_M2_22740_46500 n1_M2_23820_46500 0.988200
R5870 n1_M2_23820_46500 n1_M2_24900_46500 0.988200
R5871 n1_M2_24900_46500 n1_M2_25980_46500 0.988200
R5872 n1_M2_25980_46500 n1_M2_27060_46500 0.988200
R5873 n1_M2_27060_46500 n1_M2_28140_46500 0.988200
R5874 n1_M2_28140_46500 n1_M2_29220_46500 0.988200
R5875 n1_M2_29220_46500 n1_M2_30300_46500 0.988200
R5876 n1_M2_30300_46500 n1_M2_31380_46500 0.988200
R5877 n1_M2_31380_46500 n1_M2_32460_46500 0.988200
R5878 n1_M2_32460_46500 n1_M2_33540_46500 0.988200
R5879 n1_M2_33540_46500 n1_M2_34620_46500 0.988200
R5880 n1_M2_34620_46500 n1_M2_35700_46500 0.988200
R5881 n1_M2_35700_46500 n1_M2_36780_46500 0.988200
R5882 n1_M2_36780_46500 n1_M2_37860_46500 0.988200
R5883 n1_M2_37860_46500 n1_M2_38940_46500 0.988200
R5884 n1_M2_38940_46500 n1_M2_40020_46500 0.988200
R5885 n1_M2_40020_46500 n1_M2_41100_46500 0.988200
R5886 n1_M2_41100_46500 n1_M2_42180_46500 0.988200
R5887 n1_M2_42180_46500 n1_M2_43260_46500 0.988200
R5888 n1_M2_43260_46500 n1_M2_44340_46500 0.988200
R5889 n1_M2_44340_46500 n1_M2_45420_46500 0.988200
R5890 n1_M2_45420_46500 n1_M2_46500_46500 0.988200
R5891 n1_M2_46500_46500 n1_M2_47580_46500 0.988200
R5892 n1_M2_47580_46500 n1_M2_48660_46500 0.988200
R5893 n1_M2_48660_46500 n1_M2_49740_46500 0.988200
R5894 n1_M2_49740_46500 n1_M2_50820_46500 0.988200
R5895 n1_M2_50820_46500 n1_M2_51900_46500 0.988200
R5896 n1_M2_51900_46500 n1_M2_52980_46500 0.988200
R5897 n1_M2_52980_46500 n1_M2_54060_46500 0.988200
R5898 n1_M2_54060_46500 n1_M2_55140_46500 0.988200
R5899 n1_M2_55140_46500 n1_M2_56220_46500 0.988200
R5900 n1_M2_56220_46500 n1_M2_57300_46500 0.988200
R5901 n1_M2_57300_46500 n1_M2_58380_46500 0.988200
R5902 n1_M2_58380_46500 n1_M2_59460_46500 0.988200
R5903 n1_M2_59460_46500 n1_M2_60540_46500 0.988200
R5904 n1_M2_60540_46500 n1_M2_61620_46500 0.988200
R5905 n1_M2_61620_46500 n1_M2_62700_46500 0.988200
R5906 n1_M2_62700_46500 n1_M2_63780_46500 0.988200
R5907 n1_M2_63780_46500 n1_M2_64860_46500 0.988200
R5908 n1_M2_64860_46500 n1_M2_65940_46500 0.988200
R5909 n1_M2_65940_46500 n1_M2_67020_46500 0.988200
R5910 n1_M2_67020_46500 n1_M2_68100_46500 0.988200
R5911 n1_M2_68100_46500 n1_M2_69180_46500 0.988200
R5912 n1_M2_69180_46500 n1_M2_70260_46500 0.988200
R5913 n1_M2_70260_46500 n1_M2_71340_46500 0.988200
R5914 n1_M2_71340_46500 n1_M2_72420_46500 0.988200
R5915 n1_M2_72420_46500 n1_M2_73500_46500 0.988200
R5916 n1_M2_73500_46500 n1_M2_74580_46500 0.988200
R5917 n1_M2_74580_46500 n1_M2_75660_46500 0.988200
R5918 n1_M2_75660_46500 n1_M2_76740_46500 0.988200
R5919 n1_M2_76740_46500 n1_M2_77820_46500 0.988200
R5920 n1_M2_77820_46500 n1_M2_78900_46500 0.988200
R5921 n1_M2_78900_46500 n1_M2_79980_46500 0.988200
R5922 n1_M2_79980_46500 n1_M2_81060_46500 0.988200
R5923 n1_M2_81060_46500 n1_M2_82140_46500 0.988200
R5924 n1_M2_82140_46500 n1_M2_83220_46500 0.988200
R5925 n1_M2_83220_46500 n1_M2_84300_46500 0.988200
R5926 n1_M2_84300_46500 n1_M2_85380_46500 0.988200
R5927 n1_M2_85380_46500 n1_M2_86460_46500 0.988200
R5928 n1_M2_86460_46500 n1_M2_87540_46500 0.988200
R5929 n1_M2_87540_46500 n1_M2_88620_46500 0.988200
R5930 n1_M2_88620_46500 n1_M2_89700_46500 0.988200
R5931 n1_M2_89700_46500 n1_M2_90780_46500 0.988200
R5932 n1_M2_90780_46500 n1_M2_91860_46500 0.988200
R5933 n1_M2_91860_46500 n1_M2_92940_46500 0.988200
R5934 n1_M2_92940_46500 n1_M2_94020_46500 0.988200
R5935 n1_M2_94020_46500 n1_M2_95100_46500 0.988200
R5936 n1_M2_95100_46500 n1_M2_96180_46500 0.988200
R5937 n1_M2_96180_46500 n1_M2_97260_46500 0.988200
R5938 n1_M2_97260_46500 n1_M2_98340_46500 0.988200
R5939 n1_M2_98340_46500 n1_M2_99420_46500 0.988200
R5940 n1_M2_99420_46500 n1_M2_100500_46500 0.988200
R5941 n1_M2_100500_46500 n1_M2_101580_46500 0.988200
R5942 n1_M2_101580_46500 n1_M2_102660_46500 0.988200
R5943 n1_M2_102660_46500 n1_M2_103740_46500 0.988200
R5944 n1_M2_103740_46500 n1_M2_104820_46500 0.988200
R5945 n1_M2_104820_46500 n1_M2_105900_46500 0.988200
R5946 n1_M2_105900_46500 n1_M2_106980_46500 0.988200
R5947 n1_M2_106980_46500 n1_M2_108060_46500 0.988200
R5948 n1_M2_108060_46500 n1_M2_109140_46500 0.988200
R5949 n1_M2_109140_46500 n1_M2_110220_46500 0.988200
R5950 n1_M2_110220_46500 n1_M2_111300_46500 0.988200
R5951 n1_M2_111300_46500 n1_M2_112380_46500 0.988200
R5952 n1_M2_112380_46500 n1_M2_113460_46500 0.988200
R5953 n1_M2_113460_46500 n1_M2_114540_46500 0.988200
R5954 n1_M2_114540_46500 n1_M2_115620_46500 0.988200
R5955 n1_M2_115620_46500 n1_M2_116700_46500 0.988200
R5956 n1_M2_116700_46500 n1_M2_117780_46500 0.988200
R5957 n1_M2_117780_46500 n1_M2_118860_46500 0.988200
R5958 n1_M2_118860_46500 n1_M2_119940_46500 0.988200
R5959 n1_M2_119940_46500 n1_M2_121020_46500 0.988200
R5960 n1_M2_121020_46500 n1_M2_122100_46500 0.988200
R5961 n1_M2_122100_46500 n1_M2_123180_46500 0.988200
R5962 n1_M2_123180_46500 n1_M2_124260_46500 0.988200
R5963 n1_M2_124260_46500 n1_M2_125340_46500 0.988200
R5964 n1_M2_125340_46500 n1_M2_126420_46500 0.988200
R5965 n1_M2_126420_46500 n1_M2_127500_46500 0.988200
R5966 n1_M2_127500_46500 n1_M2_128580_46500 0.988200
R5967 n1_M2_128580_46500 n1_M2_129660_46500 0.988200
R5968 n1_M2_129660_46500 n1_M2_130740_46500 0.988200
R5969 n1_M2_130740_46500 n1_M2_131820_46500 0.988200
R5970 n1_M2_131820_46500 n1_M2_132900_46500 0.988200
R5971 n1_M2_132900_46500 n1_M2_133980_46500 0.988200
R5972 n1_M2_133980_46500 n1_M2_135060_46500 0.988200
R5973 n1_M2_135060_46500 n1_M2_136140_46500 0.988200
R5974 n1_M2_136140_46500 n1_M2_137220_46500 0.988200
R5975 n1_M2_137220_46500 n1_M2_138300_46500 0.988200
R5976 n1_M2_138300_46500 n1_M2_139380_46500 0.988200
R5977 n1_M2_139380_46500 n1_M2_140460_46500 0.988200
R5978 n1_M2_140460_46500 n1_M2_141540_46500 0.988200
R5979 n1_M2_141540_46500 n1_M2_142620_46500 0.988200
R5980 n1_M2_142620_46500 n1_M2_143700_46500 0.988200
R5981 n1_M2_143700_46500 n1_M2_144780_46500 0.988200
R5982 n1_M2_144780_46500 n1_M2_145860_46500 0.988200
R5983 n1_M2_145860_46500 n1_M2_146940_46500 0.988200
R5984 n1_M2_60_47580 n1_M2_1140_47580 0.988200
R5985 n1_M2_1140_47580 n1_M2_2220_47580 0.988200
R5986 n1_M2_2220_47580 n1_M2_3300_47580 0.988200
R5987 n1_M2_3300_47580 n1_M2_4380_47580 0.988200
R5988 n1_M2_4380_47580 n1_M2_5460_47580 0.988200
R5989 n1_M2_5460_47580 n1_M2_6540_47580 0.988200
R5990 n1_M2_6540_47580 n1_M2_7620_47580 0.988200
R5991 n1_M2_7620_47580 n1_M2_8700_47580 0.988200
R5992 n1_M2_8700_47580 n1_M2_9780_47580 0.988200
R5993 n1_M2_9780_47580 n1_M2_10860_47580 0.988200
R5994 n1_M2_10860_47580 n1_M2_11940_47580 0.988200
R5995 n1_M2_11940_47580 n1_M2_13020_47580 0.988200
R5996 n1_M2_13020_47580 n1_M2_14100_47580 0.988200
R5997 n1_M2_14100_47580 n1_M2_15180_47580 0.988200
R5998 n1_M2_15180_47580 n1_M2_16260_47580 0.988200
R5999 n1_M2_16260_47580 n1_M2_17340_47580 0.988200
R6000 n1_M2_17340_47580 n1_M2_18420_47580 0.988200
R6001 n1_M2_18420_47580 n1_M2_19500_47580 0.988200
R6002 n1_M2_19500_47580 n1_M2_20580_47580 0.988200
R6003 n1_M2_20580_47580 n1_M2_21660_47580 0.988200
R6004 n1_M2_21660_47580 n1_M2_22740_47580 0.988200
R6005 n1_M2_22740_47580 n1_M2_23820_47580 0.988200
R6006 n1_M2_23820_47580 n1_M2_24900_47580 0.988200
R6007 n1_M2_24900_47580 n1_M2_25980_47580 0.988200
R6008 n1_M2_25980_47580 n1_M2_27060_47580 0.988200
R6009 n1_M2_27060_47580 n1_M2_28140_47580 0.988200
R6010 n1_M2_28140_47580 n1_M2_29220_47580 0.988200
R6011 n1_M2_29220_47580 n1_M2_30300_47580 0.988200
R6012 n1_M2_30300_47580 n1_M2_31380_47580 0.988200
R6013 n1_M2_31380_47580 n1_M2_32460_47580 0.988200
R6014 n1_M2_32460_47580 n1_M2_33540_47580 0.988200
R6015 n1_M2_33540_47580 n1_M2_34620_47580 0.988200
R6016 n1_M2_34620_47580 n1_M2_35700_47580 0.988200
R6017 n1_M2_35700_47580 n1_M2_36780_47580 0.988200
R6018 n1_M2_36780_47580 n1_M2_37860_47580 0.988200
R6019 n1_M2_37860_47580 n1_M2_38940_47580 0.988200
R6020 n1_M2_38940_47580 n1_M2_40020_47580 0.988200
R6021 n1_M2_40020_47580 n1_M2_41100_47580 0.988200
R6022 n1_M2_41100_47580 n1_M2_42180_47580 0.988200
R6023 n1_M2_42180_47580 n1_M2_43260_47580 0.988200
R6024 n1_M2_43260_47580 n1_M2_44340_47580 0.988200
R6025 n1_M2_44340_47580 n1_M2_45420_47580 0.988200
R6026 n1_M2_45420_47580 n1_M2_46500_47580 0.988200
R6027 n1_M2_46500_47580 n1_M2_47580_47580 0.988200
R6028 n1_M2_47580_47580 n1_M2_48660_47580 0.988200
R6029 n1_M2_48660_47580 n1_M2_49740_47580 0.988200
R6030 n1_M2_49740_47580 n1_M2_50820_47580 0.988200
R6031 n1_M2_50820_47580 n1_M2_51900_47580 0.988200
R6032 n1_M2_51900_47580 n1_M2_52980_47580 0.988200
R6033 n1_M2_52980_47580 n1_M2_54060_47580 0.988200
R6034 n1_M2_54060_47580 n1_M2_55140_47580 0.988200
R6035 n1_M2_55140_47580 n1_M2_56220_47580 0.988200
R6036 n1_M2_56220_47580 n1_M2_57300_47580 0.988200
R6037 n1_M2_57300_47580 n1_M2_58380_47580 0.988200
R6038 n1_M2_58380_47580 n1_M2_59460_47580 0.988200
R6039 n1_M2_59460_47580 n1_M2_60540_47580 0.988200
R6040 n1_M2_60540_47580 n1_M2_61620_47580 0.988200
R6041 n1_M2_61620_47580 n1_M2_62700_47580 0.988200
R6042 n1_M2_62700_47580 n1_M2_63780_47580 0.988200
R6043 n1_M2_63780_47580 n1_M2_64860_47580 0.988200
R6044 n1_M2_64860_47580 n1_M2_65940_47580 0.988200
R6045 n1_M2_65940_47580 n1_M2_67020_47580 0.988200
R6046 n1_M2_67020_47580 n1_M2_68100_47580 0.988200
R6047 n1_M2_68100_47580 n1_M2_69180_47580 0.988200
R6048 n1_M2_69180_47580 n1_M2_70260_47580 0.988200
R6049 n1_M2_70260_47580 n1_M2_71340_47580 0.988200
R6050 n1_M2_71340_47580 n1_M2_72420_47580 0.988200
R6051 n1_M2_72420_47580 n1_M2_73500_47580 0.988200
R6052 n1_M2_73500_47580 n1_M2_74580_47580 0.988200
R6053 n1_M2_74580_47580 n1_M2_75660_47580 0.988200
R6054 n1_M2_75660_47580 n1_M2_76740_47580 0.988200
R6055 n1_M2_76740_47580 n1_M2_77820_47580 0.988200
R6056 n1_M2_77820_47580 n1_M2_78900_47580 0.988200
R6057 n1_M2_78900_47580 n1_M2_79980_47580 0.988200
R6058 n1_M2_79980_47580 n1_M2_81060_47580 0.988200
R6059 n1_M2_81060_47580 n1_M2_82140_47580 0.988200
R6060 n1_M2_82140_47580 n1_M2_83220_47580 0.988200
R6061 n1_M2_83220_47580 n1_M2_84300_47580 0.988200
R6062 n1_M2_84300_47580 n1_M2_85380_47580 0.988200
R6063 n1_M2_85380_47580 n1_M2_86460_47580 0.988200
R6064 n1_M2_86460_47580 n1_M2_87540_47580 0.988200
R6065 n1_M2_87540_47580 n1_M2_88620_47580 0.988200
R6066 n1_M2_88620_47580 n1_M2_89700_47580 0.988200
R6067 n1_M2_89700_47580 n1_M2_90780_47580 0.988200
R6068 n1_M2_90780_47580 n1_M2_91860_47580 0.988200
R6069 n1_M2_91860_47580 n1_M2_92940_47580 0.988200
R6070 n1_M2_92940_47580 n1_M2_94020_47580 0.988200
R6071 n1_M2_94020_47580 n1_M2_95100_47580 0.988200
R6072 n1_M2_95100_47580 n1_M2_96180_47580 0.988200
R6073 n1_M2_96180_47580 n1_M2_97260_47580 0.988200
R6074 n1_M2_97260_47580 n1_M2_98340_47580 0.988200
R6075 n1_M2_98340_47580 n1_M2_99420_47580 0.988200
R6076 n1_M2_99420_47580 n1_M2_100500_47580 0.988200
R6077 n1_M2_100500_47580 n1_M2_101580_47580 0.988200
R6078 n1_M2_101580_47580 n1_M2_102660_47580 0.988200
R6079 n1_M2_102660_47580 n1_M2_103740_47580 0.988200
R6080 n1_M2_103740_47580 n1_M2_104820_47580 0.988200
R6081 n1_M2_104820_47580 n1_M2_105900_47580 0.988200
R6082 n1_M2_105900_47580 n1_M2_106980_47580 0.988200
R6083 n1_M2_106980_47580 n1_M2_108060_47580 0.988200
R6084 n1_M2_108060_47580 n1_M2_109140_47580 0.988200
R6085 n1_M2_109140_47580 n1_M2_110220_47580 0.988200
R6086 n1_M2_110220_47580 n1_M2_111300_47580 0.988200
R6087 n1_M2_111300_47580 n1_M2_112380_47580 0.988200
R6088 n1_M2_112380_47580 n1_M2_113460_47580 0.988200
R6089 n1_M2_113460_47580 n1_M2_114540_47580 0.988200
R6090 n1_M2_114540_47580 n1_M2_115620_47580 0.988200
R6091 n1_M2_115620_47580 n1_M2_116700_47580 0.988200
R6092 n1_M2_116700_47580 n1_M2_117780_47580 0.988200
R6093 n1_M2_117780_47580 n1_M2_118860_47580 0.988200
R6094 n1_M2_118860_47580 n1_M2_119940_47580 0.988200
R6095 n1_M2_119940_47580 n1_M2_121020_47580 0.988200
R6096 n1_M2_121020_47580 n1_M2_122100_47580 0.988200
R6097 n1_M2_122100_47580 n1_M2_123180_47580 0.988200
R6098 n1_M2_123180_47580 n1_M2_124260_47580 0.988200
R6099 n1_M2_124260_47580 n1_M2_125340_47580 0.988200
R6100 n1_M2_125340_47580 n1_M2_126420_47580 0.988200
R6101 n1_M2_126420_47580 n1_M2_127500_47580 0.988200
R6102 n1_M2_127500_47580 n1_M2_128580_47580 0.988200
R6103 n1_M2_128580_47580 n1_M2_129660_47580 0.988200
R6104 n1_M2_129660_47580 n1_M2_130740_47580 0.988200
R6105 n1_M2_130740_47580 n1_M2_131820_47580 0.988200
R6106 n1_M2_131820_47580 n1_M2_132900_47580 0.988200
R6107 n1_M2_132900_47580 n1_M2_133980_47580 0.988200
R6108 n1_M2_133980_47580 n1_M2_135060_47580 0.988200
R6109 n1_M2_135060_47580 n1_M2_136140_47580 0.988200
R6110 n1_M2_136140_47580 n1_M2_137220_47580 0.988200
R6111 n1_M2_137220_47580 n1_M2_138300_47580 0.988200
R6112 n1_M2_138300_47580 n1_M2_139380_47580 0.988200
R6113 n1_M2_139380_47580 n1_M2_140460_47580 0.988200
R6114 n1_M2_140460_47580 n1_M2_141540_47580 0.988200
R6115 n1_M2_141540_47580 n1_M2_142620_47580 0.988200
R6116 n1_M2_142620_47580 n1_M2_143700_47580 0.988200
R6117 n1_M2_143700_47580 n1_M2_144780_47580 0.988200
R6118 n1_M2_144780_47580 n1_M2_145860_47580 0.988200
R6119 n1_M2_145860_47580 n1_M2_146940_47580 0.988200
R6120 n1_M2_60_48660 n1_M2_1140_48660 0.988200
R6121 n1_M2_1140_48660 n1_M2_2220_48660 0.988200
R6122 n1_M2_2220_48660 n1_M2_3300_48660 0.988200
R6123 n1_M2_3300_48660 n1_M2_4380_48660 0.988200
R6124 n1_M2_4380_48660 n1_M2_5460_48660 0.988200
R6125 n1_M2_5460_48660 n1_M2_6540_48660 0.988200
R6126 n1_M2_6540_48660 n1_M2_7620_48660 0.988200
R6127 n1_M2_7620_48660 n1_M2_8700_48660 0.988200
R6128 n1_M2_8700_48660 n1_M2_9780_48660 0.988200
R6129 n1_M2_9780_48660 n1_M2_10860_48660 0.988200
R6130 n1_M2_10860_48660 n1_M2_11940_48660 0.988200
R6131 n1_M2_11940_48660 n1_M2_13020_48660 0.988200
R6132 n1_M2_13020_48660 n1_M2_14100_48660 0.988200
R6133 n1_M2_14100_48660 n1_M2_15180_48660 0.988200
R6134 n1_M2_15180_48660 n1_M2_16260_48660 0.988200
R6135 n1_M2_16260_48660 n1_M2_17340_48660 0.988200
R6136 n1_M2_17340_48660 n1_M2_18420_48660 0.988200
R6137 n1_M2_18420_48660 n1_M2_19500_48660 0.988200
R6138 n1_M2_19500_48660 n1_M2_20580_48660 0.988200
R6139 n1_M2_20580_48660 n1_M2_21660_48660 0.988200
R6140 n1_M2_21660_48660 n1_M2_22740_48660 0.988200
R6141 n1_M2_22740_48660 n1_M2_23820_48660 0.988200
R6142 n1_M2_23820_48660 n1_M2_24900_48660 0.988200
R6143 n1_M2_24900_48660 n1_M2_25980_48660 0.988200
R6144 n1_M2_25980_48660 n1_M2_27060_48660 0.988200
R6145 n1_M2_27060_48660 n1_M2_28140_48660 0.988200
R6146 n1_M2_28140_48660 n1_M2_29220_48660 0.988200
R6147 n1_M2_29220_48660 n1_M2_30300_48660 0.988200
R6148 n1_M2_30300_48660 n1_M2_31380_48660 0.988200
R6149 n1_M2_31380_48660 n1_M2_32460_48660 0.988200
R6150 n1_M2_32460_48660 n1_M2_33540_48660 0.988200
R6151 n1_M2_33540_48660 n1_M2_34620_48660 0.988200
R6152 n1_M2_34620_48660 n1_M2_35700_48660 0.988200
R6153 n1_M2_35700_48660 n1_M2_36780_48660 0.988200
R6154 n1_M2_36780_48660 n1_M2_37860_48660 0.988200
R6155 n1_M2_37860_48660 n1_M2_38940_48660 0.988200
R6156 n1_M2_38940_48660 n1_M2_40020_48660 0.988200
R6157 n1_M2_40020_48660 n1_M2_41100_48660 0.988200
R6158 n1_M2_41100_48660 n1_M2_42180_48660 0.988200
R6159 n1_M2_42180_48660 n1_M2_43260_48660 0.988200
R6160 n1_M2_43260_48660 n1_M2_44340_48660 0.988200
R6161 n1_M2_44340_48660 n1_M2_45420_48660 0.988200
R6162 n1_M2_45420_48660 n1_M2_46500_48660 0.988200
R6163 n1_M2_46500_48660 n1_M2_47580_48660 0.988200
R6164 n1_M2_47580_48660 n1_M2_48660_48660 0.988200
R6165 n1_M2_48660_48660 n1_M2_49740_48660 0.988200
R6166 n1_M2_49740_48660 n1_M2_50820_48660 0.988200
R6167 n1_M2_50820_48660 n1_M2_51900_48660 0.988200
R6168 n1_M2_51900_48660 n1_M2_52980_48660 0.988200
R6169 n1_M2_52980_48660 n1_M2_54060_48660 0.988200
R6170 n1_M2_54060_48660 n1_M2_55140_48660 0.988200
R6171 n1_M2_55140_48660 n1_M2_56220_48660 0.988200
R6172 n1_M2_56220_48660 n1_M2_57300_48660 0.988200
R6173 n1_M2_57300_48660 n1_M2_58380_48660 0.988200
R6174 n1_M2_58380_48660 n1_M2_59460_48660 0.988200
R6175 n1_M2_59460_48660 n1_M2_60540_48660 0.988200
R6176 n1_M2_60540_48660 n1_M2_61620_48660 0.988200
R6177 n1_M2_61620_48660 n1_M2_62700_48660 0.988200
R6178 n1_M2_62700_48660 n1_M2_63780_48660 0.988200
R6179 n1_M2_63780_48660 n1_M2_64860_48660 0.988200
R6180 n1_M2_64860_48660 n1_M2_65940_48660 0.988200
R6181 n1_M2_65940_48660 n1_M2_67020_48660 0.988200
R6182 n1_M2_67020_48660 n1_M2_68100_48660 0.988200
R6183 n1_M2_68100_48660 n1_M2_69180_48660 0.988200
R6184 n1_M2_69180_48660 n1_M2_70260_48660 0.988200
R6185 n1_M2_70260_48660 n1_M2_71340_48660 0.988200
R6186 n1_M2_71340_48660 n1_M2_72420_48660 0.988200
R6187 n1_M2_72420_48660 n1_M2_73500_48660 0.988200
R6188 n1_M2_73500_48660 n1_M2_74580_48660 0.988200
R6189 n1_M2_74580_48660 n1_M2_75660_48660 0.988200
R6190 n1_M2_75660_48660 n1_M2_76740_48660 0.988200
R6191 n1_M2_76740_48660 n1_M2_77820_48660 0.988200
R6192 n1_M2_77820_48660 n1_M2_78900_48660 0.988200
R6193 n1_M2_78900_48660 n1_M2_79980_48660 0.988200
R6194 n1_M2_79980_48660 n1_M2_81060_48660 0.988200
R6195 n1_M2_81060_48660 n1_M2_82140_48660 0.988200
R6196 n1_M2_82140_48660 n1_M2_83220_48660 0.988200
R6197 n1_M2_83220_48660 n1_M2_84300_48660 0.988200
R6198 n1_M2_84300_48660 n1_M2_85380_48660 0.988200
R6199 n1_M2_85380_48660 n1_M2_86460_48660 0.988200
R6200 n1_M2_86460_48660 n1_M2_87540_48660 0.988200
R6201 n1_M2_87540_48660 n1_M2_88620_48660 0.988200
R6202 n1_M2_88620_48660 n1_M2_89700_48660 0.988200
R6203 n1_M2_89700_48660 n1_M2_90780_48660 0.988200
R6204 n1_M2_90780_48660 n1_M2_91860_48660 0.988200
R6205 n1_M2_91860_48660 n1_M2_92940_48660 0.988200
R6206 n1_M2_92940_48660 n1_M2_94020_48660 0.988200
R6207 n1_M2_94020_48660 n1_M2_95100_48660 0.988200
R6208 n1_M2_95100_48660 n1_M2_96180_48660 0.988200
R6209 n1_M2_96180_48660 n1_M2_97260_48660 0.988200
R6210 n1_M2_97260_48660 n1_M2_98340_48660 0.988200
R6211 n1_M2_98340_48660 n1_M2_99420_48660 0.988200
R6212 n1_M2_99420_48660 n1_M2_100500_48660 0.988200
R6213 n1_M2_100500_48660 n1_M2_101580_48660 0.988200
R6214 n1_M2_101580_48660 n1_M2_102660_48660 0.988200
R6215 n1_M2_102660_48660 n1_M2_103740_48660 0.988200
R6216 n1_M2_103740_48660 n1_M2_104820_48660 0.988200
R6217 n1_M2_104820_48660 n1_M2_105900_48660 0.988200
R6218 n1_M2_105900_48660 n1_M2_106980_48660 0.988200
R6219 n1_M2_106980_48660 n1_M2_108060_48660 0.988200
R6220 n1_M2_108060_48660 n1_M2_109140_48660 0.988200
R6221 n1_M2_109140_48660 n1_M2_110220_48660 0.988200
R6222 n1_M2_110220_48660 n1_M2_111300_48660 0.988200
R6223 n1_M2_111300_48660 n1_M2_112380_48660 0.988200
R6224 n1_M2_112380_48660 n1_M2_113460_48660 0.988200
R6225 n1_M2_113460_48660 n1_M2_114540_48660 0.988200
R6226 n1_M2_114540_48660 n1_M2_115620_48660 0.988200
R6227 n1_M2_115620_48660 n1_M2_116700_48660 0.988200
R6228 n1_M2_116700_48660 n1_M2_117780_48660 0.988200
R6229 n1_M2_117780_48660 n1_M2_118860_48660 0.988200
R6230 n1_M2_118860_48660 n1_M2_119940_48660 0.988200
R6231 n1_M2_119940_48660 n1_M2_121020_48660 0.988200
R6232 n1_M2_121020_48660 n1_M2_122100_48660 0.988200
R6233 n1_M2_122100_48660 n1_M2_123180_48660 0.988200
R6234 n1_M2_123180_48660 n1_M2_124260_48660 0.988200
R6235 n1_M2_124260_48660 n1_M2_125340_48660 0.988200
R6236 n1_M2_125340_48660 n1_M2_126420_48660 0.988200
R6237 n1_M2_126420_48660 n1_M2_127500_48660 0.988200
R6238 n1_M2_127500_48660 n1_M2_128580_48660 0.988200
R6239 n1_M2_128580_48660 n1_M2_129660_48660 0.988200
R6240 n1_M2_129660_48660 n1_M2_130740_48660 0.988200
R6241 n1_M2_130740_48660 n1_M2_131820_48660 0.988200
R6242 n1_M2_131820_48660 n1_M2_132900_48660 0.988200
R6243 n1_M2_132900_48660 n1_M2_133980_48660 0.988200
R6244 n1_M2_133980_48660 n1_M2_135060_48660 0.988200
R6245 n1_M2_135060_48660 n1_M2_136140_48660 0.988200
R6246 n1_M2_136140_48660 n1_M2_137220_48660 0.988200
R6247 n1_M2_137220_48660 n1_M2_138300_48660 0.988200
R6248 n1_M2_138300_48660 n1_M2_139380_48660 0.988200
R6249 n1_M2_139380_48660 n1_M2_140460_48660 0.988200
R6250 n1_M2_140460_48660 n1_M2_141540_48660 0.988200
R6251 n1_M2_141540_48660 n1_M2_142620_48660 0.988200
R6252 n1_M2_142620_48660 n1_M2_143700_48660 0.988200
R6253 n1_M2_143700_48660 n1_M2_144780_48660 0.988200
R6254 n1_M2_144780_48660 n1_M2_145860_48660 0.988200
R6255 n1_M2_145860_48660 n1_M2_146940_48660 0.988200
R6256 n1_M2_60_49740 n1_M2_1140_49740 0.988200
R6257 n1_M2_1140_49740 n1_M2_2220_49740 0.988200
R6258 n1_M2_2220_49740 n1_M2_3300_49740 0.988200
R6259 n1_M2_3300_49740 n1_M2_4380_49740 0.988200
R6260 n1_M2_4380_49740 n1_M2_5460_49740 0.988200
R6261 n1_M2_5460_49740 n1_M2_6540_49740 0.988200
R6262 n1_M2_6540_49740 n1_M2_7620_49740 0.988200
R6263 n1_M2_7620_49740 n1_M2_8700_49740 0.988200
R6264 n1_M2_8700_49740 n1_M2_9780_49740 0.988200
R6265 n1_M2_9780_49740 n1_M2_10860_49740 0.988200
R6266 n1_M2_10860_49740 n1_M2_11940_49740 0.988200
R6267 n1_M2_11940_49740 n1_M2_13020_49740 0.988200
R6268 n1_M2_13020_49740 n1_M2_14100_49740 0.988200
R6269 n1_M2_14100_49740 n1_M2_15180_49740 0.988200
R6270 n1_M2_15180_49740 n1_M2_16260_49740 0.988200
R6271 n1_M2_16260_49740 n1_M2_17340_49740 0.988200
R6272 n1_M2_17340_49740 n1_M2_18420_49740 0.988200
R6273 n1_M2_18420_49740 n1_M2_19500_49740 0.988200
R6274 n1_M2_19500_49740 n1_M2_20580_49740 0.988200
R6275 n1_M2_20580_49740 n1_M2_21660_49740 0.988200
R6276 n1_M2_21660_49740 n1_M2_22740_49740 0.988200
R6277 n1_M2_22740_49740 n1_M2_23820_49740 0.988200
R6278 n1_M2_23820_49740 n1_M2_24900_49740 0.988200
R6279 n1_M2_24900_49740 n1_M2_25980_49740 0.988200
R6280 n1_M2_25980_49740 n1_M2_27060_49740 0.988200
R6281 n1_M2_27060_49740 n1_M2_28140_49740 0.988200
R6282 n1_M2_28140_49740 n1_M2_29220_49740 0.988200
R6283 n1_M2_29220_49740 n1_M2_30300_49740 0.988200
R6284 n1_M2_30300_49740 n1_M2_31380_49740 0.988200
R6285 n1_M2_31380_49740 n1_M2_32460_49740 0.988200
R6286 n1_M2_32460_49740 n1_M2_33540_49740 0.988200
R6287 n1_M2_33540_49740 n1_M2_34620_49740 0.988200
R6288 n1_M2_34620_49740 n1_M2_35700_49740 0.988200
R6289 n1_M2_35700_49740 n1_M2_36780_49740 0.988200
R6290 n1_M2_36780_49740 n1_M2_37860_49740 0.988200
R6291 n1_M2_37860_49740 n1_M2_38940_49740 0.988200
R6292 n1_M2_38940_49740 n1_M2_40020_49740 0.988200
R6293 n1_M2_40020_49740 n1_M2_41100_49740 0.988200
R6294 n1_M2_41100_49740 n1_M2_42180_49740 0.988200
R6295 n1_M2_42180_49740 n1_M2_43260_49740 0.988200
R6296 n1_M2_43260_49740 n1_M2_44340_49740 0.988200
R6297 n1_M2_44340_49740 n1_M2_45420_49740 0.988200
R6298 n1_M2_45420_49740 n1_M2_46500_49740 0.988200
R6299 n1_M2_46500_49740 n1_M2_47580_49740 0.988200
R6300 n1_M2_47580_49740 n1_M2_48660_49740 0.988200
R6301 n1_M2_48660_49740 n1_M2_49740_49740 0.988200
R6302 n1_M2_49740_49740 n1_M2_50820_49740 0.988200
R6303 n1_M2_50820_49740 n1_M2_51900_49740 0.988200
R6304 n1_M2_51900_49740 n1_M2_52980_49740 0.988200
R6305 n1_M2_52980_49740 n1_M2_54060_49740 0.988200
R6306 n1_M2_54060_49740 n1_M2_55140_49740 0.988200
R6307 n1_M2_55140_49740 n1_M2_56220_49740 0.988200
R6308 n1_M2_56220_49740 n1_M2_57300_49740 0.988200
R6309 n1_M2_57300_49740 n1_M2_58380_49740 0.988200
R6310 n1_M2_58380_49740 n1_M2_59460_49740 0.988200
R6311 n1_M2_59460_49740 n1_M2_60540_49740 0.988200
R6312 n1_M2_60540_49740 n1_M2_61620_49740 0.988200
R6313 n1_M2_61620_49740 n1_M2_62700_49740 0.988200
R6314 n1_M2_62700_49740 n1_M2_63780_49740 0.988200
R6315 n1_M2_63780_49740 n1_M2_64860_49740 0.988200
R6316 n1_M2_64860_49740 n1_M2_65940_49740 0.988200
R6317 n1_M2_65940_49740 n1_M2_67020_49740 0.988200
R6318 n1_M2_67020_49740 n1_M2_68100_49740 0.988200
R6319 n1_M2_68100_49740 n1_M2_69180_49740 0.988200
R6320 n1_M2_69180_49740 n1_M2_70260_49740 0.988200
R6321 n1_M2_70260_49740 n1_M2_71340_49740 0.988200
R6322 n1_M2_71340_49740 n1_M2_72420_49740 0.988200
R6323 n1_M2_72420_49740 n1_M2_73500_49740 0.988200
R6324 n1_M2_73500_49740 n1_M2_74580_49740 0.988200
R6325 n1_M2_74580_49740 n1_M2_75660_49740 0.988200
R6326 n1_M2_75660_49740 n1_M2_76740_49740 0.988200
R6327 n1_M2_76740_49740 n1_M2_77820_49740 0.988200
R6328 n1_M2_77820_49740 n1_M2_78900_49740 0.988200
R6329 n1_M2_78900_49740 n1_M2_79980_49740 0.988200
R6330 n1_M2_79980_49740 n1_M2_81060_49740 0.988200
R6331 n1_M2_81060_49740 n1_M2_82140_49740 0.988200
R6332 n1_M2_82140_49740 n1_M2_83220_49740 0.988200
R6333 n1_M2_83220_49740 n1_M2_84300_49740 0.988200
R6334 n1_M2_84300_49740 n1_M2_85380_49740 0.988200
R6335 n1_M2_85380_49740 n1_M2_86460_49740 0.988200
R6336 n1_M2_86460_49740 n1_M2_87540_49740 0.988200
R6337 n1_M2_87540_49740 n1_M2_88620_49740 0.988200
R6338 n1_M2_88620_49740 n1_M2_89700_49740 0.988200
R6339 n1_M2_89700_49740 n1_M2_90780_49740 0.988200
R6340 n1_M2_90780_49740 n1_M2_91860_49740 0.988200
R6341 n1_M2_91860_49740 n1_M2_92940_49740 0.988200
R6342 n1_M2_92940_49740 n1_M2_94020_49740 0.988200
R6343 n1_M2_94020_49740 n1_M2_95100_49740 0.988200
R6344 n1_M2_95100_49740 n1_M2_96180_49740 0.988200
R6345 n1_M2_96180_49740 n1_M2_97260_49740 0.988200
R6346 n1_M2_97260_49740 n1_M2_98340_49740 0.988200
R6347 n1_M2_98340_49740 n1_M2_99420_49740 0.988200
R6348 n1_M2_99420_49740 n1_M2_100500_49740 0.988200
R6349 n1_M2_100500_49740 n1_M2_101580_49740 0.988200
R6350 n1_M2_101580_49740 n1_M2_102660_49740 0.988200
R6351 n1_M2_102660_49740 n1_M2_103740_49740 0.988200
R6352 n1_M2_103740_49740 n1_M2_104820_49740 0.988200
R6353 n1_M2_104820_49740 n1_M2_105900_49740 0.988200
R6354 n1_M2_105900_49740 n1_M2_106980_49740 0.988200
R6355 n1_M2_106980_49740 n1_M2_108060_49740 0.988200
R6356 n1_M2_108060_49740 n1_M2_109140_49740 0.988200
R6357 n1_M2_109140_49740 n1_M2_110220_49740 0.988200
R6358 n1_M2_110220_49740 n1_M2_111300_49740 0.988200
R6359 n1_M2_111300_49740 n1_M2_112380_49740 0.988200
R6360 n1_M2_112380_49740 n1_M2_113460_49740 0.988200
R6361 n1_M2_113460_49740 n1_M2_114540_49740 0.988200
R6362 n1_M2_114540_49740 n1_M2_115620_49740 0.988200
R6363 n1_M2_115620_49740 n1_M2_116700_49740 0.988200
R6364 n1_M2_116700_49740 n1_M2_117780_49740 0.988200
R6365 n1_M2_117780_49740 n1_M2_118860_49740 0.988200
R6366 n1_M2_118860_49740 n1_M2_119940_49740 0.988200
R6367 n1_M2_119940_49740 n1_M2_121020_49740 0.988200
R6368 n1_M2_121020_49740 n1_M2_122100_49740 0.988200
R6369 n1_M2_122100_49740 n1_M2_123180_49740 0.988200
R6370 n1_M2_123180_49740 n1_M2_124260_49740 0.988200
R6371 n1_M2_124260_49740 n1_M2_125340_49740 0.988200
R6372 n1_M2_125340_49740 n1_M2_126420_49740 0.988200
R6373 n1_M2_126420_49740 n1_M2_127500_49740 0.988200
R6374 n1_M2_127500_49740 n1_M2_128580_49740 0.988200
R6375 n1_M2_128580_49740 n1_M2_129660_49740 0.988200
R6376 n1_M2_129660_49740 n1_M2_130740_49740 0.988200
R6377 n1_M2_130740_49740 n1_M2_131820_49740 0.988200
R6378 n1_M2_131820_49740 n1_M2_132900_49740 0.988200
R6379 n1_M2_132900_49740 n1_M2_133980_49740 0.988200
R6380 n1_M2_133980_49740 n1_M2_135060_49740 0.988200
R6381 n1_M2_135060_49740 n1_M2_136140_49740 0.988200
R6382 n1_M2_136140_49740 n1_M2_137220_49740 0.988200
R6383 n1_M2_137220_49740 n1_M2_138300_49740 0.988200
R6384 n1_M2_138300_49740 n1_M2_139380_49740 0.988200
R6385 n1_M2_139380_49740 n1_M2_140460_49740 0.988200
R6386 n1_M2_140460_49740 n1_M2_141540_49740 0.988200
R6387 n1_M2_141540_49740 n1_M2_142620_49740 0.988200
R6388 n1_M2_142620_49740 n1_M2_143700_49740 0.988200
R6389 n1_M2_143700_49740 n1_M2_144780_49740 0.988200
R6390 n1_M2_144780_49740 n1_M2_145860_49740 0.988200
R6391 n1_M2_145860_49740 n1_M2_146940_49740 0.988200
R6392 n1_M2_60_50820 n1_M2_1140_50820 0.988200
R6393 n1_M2_1140_50820 n1_M2_2220_50820 0.988200
R6394 n1_M2_2220_50820 n1_M2_3300_50820 0.988200
R6395 n1_M2_3300_50820 n1_M2_4380_50820 0.988200
R6396 n1_M2_4380_50820 n1_M2_5460_50820 0.988200
R6397 n1_M2_5460_50820 n1_M2_6540_50820 0.988200
R6398 n1_M2_6540_50820 n1_M2_7620_50820 0.988200
R6399 n1_M2_7620_50820 n1_M2_8700_50820 0.988200
R6400 n1_M2_8700_50820 n1_M2_9780_50820 0.988200
R6401 n1_M2_9780_50820 n1_M2_10860_50820 0.988200
R6402 n1_M2_10860_50820 n1_M2_11940_50820 0.988200
R6403 n1_M2_11940_50820 n1_M2_13020_50820 0.988200
R6404 n1_M2_13020_50820 n1_M2_14100_50820 0.988200
R6405 n1_M2_14100_50820 n1_M2_15180_50820 0.988200
R6406 n1_M2_15180_50820 n1_M2_16260_50820 0.988200
R6407 n1_M2_16260_50820 n1_M2_17340_50820 0.988200
R6408 n1_M2_17340_50820 n1_M2_18420_50820 0.988200
R6409 n1_M2_18420_50820 n1_M2_19500_50820 0.988200
R6410 n1_M2_19500_50820 n1_M2_20580_50820 0.988200
R6411 n1_M2_20580_50820 n1_M2_21660_50820 0.988200
R6412 n1_M2_21660_50820 n1_M2_22740_50820 0.988200
R6413 n1_M2_22740_50820 n1_M2_23820_50820 0.988200
R6414 n1_M2_23820_50820 n1_M2_24900_50820 0.988200
R6415 n1_M2_24900_50820 n1_M2_25980_50820 0.988200
R6416 n1_M2_25980_50820 n1_M2_27060_50820 0.988200
R6417 n1_M2_27060_50820 n1_M2_28140_50820 0.988200
R6418 n1_M2_28140_50820 n1_M2_29220_50820 0.988200
R6419 n1_M2_29220_50820 n1_M2_30300_50820 0.988200
R6420 n1_M2_30300_50820 n1_M2_31380_50820 0.988200
R6421 n1_M2_31380_50820 n1_M2_32460_50820 0.988200
R6422 n1_M2_32460_50820 n1_M2_33540_50820 0.988200
R6423 n1_M2_33540_50820 n1_M2_34620_50820 0.988200
R6424 n1_M2_34620_50820 n1_M2_35700_50820 0.988200
R6425 n1_M2_35700_50820 n1_M2_36780_50820 0.988200
R6426 n1_M2_36780_50820 n1_M2_37860_50820 0.988200
R6427 n1_M2_37860_50820 n1_M2_38940_50820 0.988200
R6428 n1_M2_38940_50820 n1_M2_40020_50820 0.988200
R6429 n1_M2_40020_50820 n1_M2_41100_50820 0.988200
R6430 n1_M2_41100_50820 n1_M2_42180_50820 0.988200
R6431 n1_M2_42180_50820 n1_M2_43260_50820 0.988200
R6432 n1_M2_43260_50820 n1_M2_44340_50820 0.988200
R6433 n1_M2_44340_50820 n1_M2_45420_50820 0.988200
R6434 n1_M2_45420_50820 n1_M2_46500_50820 0.988200
R6435 n1_M2_46500_50820 n1_M2_47580_50820 0.988200
R6436 n1_M2_47580_50820 n1_M2_48660_50820 0.988200
R6437 n1_M2_48660_50820 n1_M2_49740_50820 0.988200
R6438 n1_M2_49740_50820 n1_M2_50820_50820 0.988200
R6439 n1_M2_50820_50820 n1_M2_51900_50820 0.988200
R6440 n1_M2_51900_50820 n1_M2_52980_50820 0.988200
R6441 n1_M2_52980_50820 n1_M2_54060_50820 0.988200
R6442 n1_M2_54060_50820 n1_M2_55140_50820 0.988200
R6443 n1_M2_55140_50820 n1_M2_56220_50820 0.988200
R6444 n1_M2_56220_50820 n1_M2_57300_50820 0.988200
R6445 n1_M2_57300_50820 n1_M2_58380_50820 0.988200
R6446 n1_M2_58380_50820 n1_M2_59460_50820 0.988200
R6447 n1_M2_59460_50820 n1_M2_60540_50820 0.988200
R6448 n1_M2_60540_50820 n1_M2_61620_50820 0.988200
R6449 n1_M2_61620_50820 n1_M2_62700_50820 0.988200
R6450 n1_M2_62700_50820 n1_M2_63780_50820 0.988200
R6451 n1_M2_63780_50820 n1_M2_64860_50820 0.988200
R6452 n1_M2_64860_50820 n1_M2_65940_50820 0.988200
R6453 n1_M2_65940_50820 n1_M2_67020_50820 0.988200
R6454 n1_M2_67020_50820 n1_M2_68100_50820 0.988200
R6455 n1_M2_68100_50820 n1_M2_69180_50820 0.988200
R6456 n1_M2_69180_50820 n1_M2_70260_50820 0.988200
R6457 n1_M2_70260_50820 n1_M2_71340_50820 0.988200
R6458 n1_M2_71340_50820 n1_M2_72420_50820 0.988200
R6459 n1_M2_72420_50820 n1_M2_73500_50820 0.988200
R6460 n1_M2_73500_50820 n1_M2_74580_50820 0.988200
R6461 n1_M2_74580_50820 n1_M2_75660_50820 0.988200
R6462 n1_M2_75660_50820 n1_M2_76740_50820 0.988200
R6463 n1_M2_76740_50820 n1_M2_77820_50820 0.988200
R6464 n1_M2_77820_50820 n1_M2_78900_50820 0.988200
R6465 n1_M2_78900_50820 n1_M2_79980_50820 0.988200
R6466 n1_M2_79980_50820 n1_M2_81060_50820 0.988200
R6467 n1_M2_81060_50820 n1_M2_82140_50820 0.988200
R6468 n1_M2_82140_50820 n1_M2_83220_50820 0.988200
R6469 n1_M2_83220_50820 n1_M2_84300_50820 0.988200
R6470 n1_M2_84300_50820 n1_M2_85380_50820 0.988200
R6471 n1_M2_85380_50820 n1_M2_86460_50820 0.988200
R6472 n1_M2_86460_50820 n1_M2_87540_50820 0.988200
R6473 n1_M2_87540_50820 n1_M2_88620_50820 0.988200
R6474 n1_M2_88620_50820 n1_M2_89700_50820 0.988200
R6475 n1_M2_89700_50820 n1_M2_90780_50820 0.988200
R6476 n1_M2_90780_50820 n1_M2_91860_50820 0.988200
R6477 n1_M2_91860_50820 n1_M2_92940_50820 0.988200
R6478 n1_M2_92940_50820 n1_M2_94020_50820 0.988200
R6479 n1_M2_94020_50820 n1_M2_95100_50820 0.988200
R6480 n1_M2_95100_50820 n1_M2_96180_50820 0.988200
R6481 n1_M2_96180_50820 n1_M2_97260_50820 0.988200
R6482 n1_M2_97260_50820 n1_M2_98340_50820 0.988200
R6483 n1_M2_98340_50820 n1_M2_99420_50820 0.988200
R6484 n1_M2_99420_50820 n1_M2_100500_50820 0.988200
R6485 n1_M2_100500_50820 n1_M2_101580_50820 0.988200
R6486 n1_M2_101580_50820 n1_M2_102660_50820 0.988200
R6487 n1_M2_102660_50820 n1_M2_103740_50820 0.988200
R6488 n1_M2_103740_50820 n1_M2_104820_50820 0.988200
R6489 n1_M2_104820_50820 n1_M2_105900_50820 0.988200
R6490 n1_M2_105900_50820 n1_M2_106980_50820 0.988200
R6491 n1_M2_106980_50820 n1_M2_108060_50820 0.988200
R6492 n1_M2_108060_50820 n1_M2_109140_50820 0.988200
R6493 n1_M2_109140_50820 n1_M2_110220_50820 0.988200
R6494 n1_M2_110220_50820 n1_M2_111300_50820 0.988200
R6495 n1_M2_111300_50820 n1_M2_112380_50820 0.988200
R6496 n1_M2_112380_50820 n1_M2_113460_50820 0.988200
R6497 n1_M2_113460_50820 n1_M2_114540_50820 0.988200
R6498 n1_M2_114540_50820 n1_M2_115620_50820 0.988200
R6499 n1_M2_115620_50820 n1_M2_116700_50820 0.988200
R6500 n1_M2_116700_50820 n1_M2_117780_50820 0.988200
R6501 n1_M2_117780_50820 n1_M2_118860_50820 0.988200
R6502 n1_M2_118860_50820 n1_M2_119940_50820 0.988200
R6503 n1_M2_119940_50820 n1_M2_121020_50820 0.988200
R6504 n1_M2_121020_50820 n1_M2_122100_50820 0.988200
R6505 n1_M2_122100_50820 n1_M2_123180_50820 0.988200
R6506 n1_M2_123180_50820 n1_M2_124260_50820 0.988200
R6507 n1_M2_124260_50820 n1_M2_125340_50820 0.988200
R6508 n1_M2_125340_50820 n1_M2_126420_50820 0.988200
R6509 n1_M2_126420_50820 n1_M2_127500_50820 0.988200
R6510 n1_M2_127500_50820 n1_M2_128580_50820 0.988200
R6511 n1_M2_128580_50820 n1_M2_129660_50820 0.988200
R6512 n1_M2_129660_50820 n1_M2_130740_50820 0.988200
R6513 n1_M2_130740_50820 n1_M2_131820_50820 0.988200
R6514 n1_M2_131820_50820 n1_M2_132900_50820 0.988200
R6515 n1_M2_132900_50820 n1_M2_133980_50820 0.988200
R6516 n1_M2_133980_50820 n1_M2_135060_50820 0.988200
R6517 n1_M2_135060_50820 n1_M2_136140_50820 0.988200
R6518 n1_M2_136140_50820 n1_M2_137220_50820 0.988200
R6519 n1_M2_137220_50820 n1_M2_138300_50820 0.988200
R6520 n1_M2_138300_50820 n1_M2_139380_50820 0.988200
R6521 n1_M2_139380_50820 n1_M2_140460_50820 0.988200
R6522 n1_M2_140460_50820 n1_M2_141540_50820 0.988200
R6523 n1_M2_141540_50820 n1_M2_142620_50820 0.988200
R6524 n1_M2_142620_50820 n1_M2_143700_50820 0.988200
R6525 n1_M2_143700_50820 n1_M2_144780_50820 0.988200
R6526 n1_M2_144780_50820 n1_M2_145860_50820 0.988200
R6527 n1_M2_145860_50820 n1_M2_146940_50820 0.988200
R6528 n1_M2_60_51900 n1_M2_1140_51900 0.988200
R6529 n1_M2_1140_51900 n1_M2_2220_51900 0.988200
R6530 n1_M2_2220_51900 n1_M2_3300_51900 0.988200
R6531 n1_M2_3300_51900 n1_M2_4380_51900 0.988200
R6532 n1_M2_4380_51900 n1_M2_5460_51900 0.988200
R6533 n1_M2_5460_51900 n1_M2_6540_51900 0.988200
R6534 n1_M2_6540_51900 n1_M2_7620_51900 0.988200
R6535 n1_M2_7620_51900 n1_M2_8700_51900 0.988200
R6536 n1_M2_8700_51900 n1_M2_9780_51900 0.988200
R6537 n1_M2_9780_51900 n1_M2_10860_51900 0.988200
R6538 n1_M2_10860_51900 n1_M2_11940_51900 0.988200
R6539 n1_M2_11940_51900 n1_M2_13020_51900 0.988200
R6540 n1_M2_13020_51900 n1_M2_14100_51900 0.988200
R6541 n1_M2_14100_51900 n1_M2_15180_51900 0.988200
R6542 n1_M2_15180_51900 n1_M2_16260_51900 0.988200
R6543 n1_M2_16260_51900 n1_M2_17340_51900 0.988200
R6544 n1_M2_17340_51900 n1_M2_18420_51900 0.988200
R6545 n1_M2_18420_51900 n1_M2_19500_51900 0.988200
R6546 n1_M2_19500_51900 n1_M2_20580_51900 0.988200
R6547 n1_M2_20580_51900 n1_M2_21660_51900 0.988200
R6548 n1_M2_21660_51900 n1_M2_22740_51900 0.988200
R6549 n1_M2_22740_51900 n1_M2_23820_51900 0.988200
R6550 n1_M2_23820_51900 n1_M2_24900_51900 0.988200
R6551 n1_M2_24900_51900 n1_M2_25980_51900 0.988200
R6552 n1_M2_25980_51900 n1_M2_27060_51900 0.988200
R6553 n1_M2_27060_51900 n1_M2_28140_51900 0.988200
R6554 n1_M2_28140_51900 n1_M2_29220_51900 0.988200
R6555 n1_M2_29220_51900 n1_M2_30300_51900 0.988200
R6556 n1_M2_30300_51900 n1_M2_31380_51900 0.988200
R6557 n1_M2_31380_51900 n1_M2_32460_51900 0.988200
R6558 n1_M2_32460_51900 n1_M2_33540_51900 0.988200
R6559 n1_M2_33540_51900 n1_M2_34620_51900 0.988200
R6560 n1_M2_34620_51900 n1_M2_35700_51900 0.988200
R6561 n1_M2_35700_51900 n1_M2_36780_51900 0.988200
R6562 n1_M2_36780_51900 n1_M2_37860_51900 0.988200
R6563 n1_M2_37860_51900 n1_M2_38940_51900 0.988200
R6564 n1_M2_38940_51900 n1_M2_40020_51900 0.988200
R6565 n1_M2_40020_51900 n1_M2_41100_51900 0.988200
R6566 n1_M2_41100_51900 n1_M2_42180_51900 0.988200
R6567 n1_M2_42180_51900 n1_M2_43260_51900 0.988200
R6568 n1_M2_43260_51900 n1_M2_44340_51900 0.988200
R6569 n1_M2_44340_51900 n1_M2_45420_51900 0.988200
R6570 n1_M2_45420_51900 n1_M2_46500_51900 0.988200
R6571 n1_M2_46500_51900 n1_M2_47580_51900 0.988200
R6572 n1_M2_47580_51900 n1_M2_48660_51900 0.988200
R6573 n1_M2_48660_51900 n1_M2_49740_51900 0.988200
R6574 n1_M2_49740_51900 n1_M2_50820_51900 0.988200
R6575 n1_M2_50820_51900 n1_M2_51900_51900 0.988200
R6576 n1_M2_51900_51900 n1_M2_52980_51900 0.988200
R6577 n1_M2_52980_51900 n1_M2_54060_51900 0.988200
R6578 n1_M2_54060_51900 n1_M2_55140_51900 0.988200
R6579 n1_M2_55140_51900 n1_M2_56220_51900 0.988200
R6580 n1_M2_56220_51900 n1_M2_57300_51900 0.988200
R6581 n1_M2_57300_51900 n1_M2_58380_51900 0.988200
R6582 n1_M2_58380_51900 n1_M2_59460_51900 0.988200
R6583 n1_M2_59460_51900 n1_M2_60540_51900 0.988200
R6584 n1_M2_60540_51900 n1_M2_61620_51900 0.988200
R6585 n1_M2_61620_51900 n1_M2_62700_51900 0.988200
R6586 n1_M2_62700_51900 n1_M2_63780_51900 0.988200
R6587 n1_M2_63780_51900 n1_M2_64860_51900 0.988200
R6588 n1_M2_64860_51900 n1_M2_65940_51900 0.988200
R6589 n1_M2_65940_51900 n1_M2_67020_51900 0.988200
R6590 n1_M2_67020_51900 n1_M2_68100_51900 0.988200
R6591 n1_M2_68100_51900 n1_M2_69180_51900 0.988200
R6592 n1_M2_69180_51900 n1_M2_70260_51900 0.988200
R6593 n1_M2_70260_51900 n1_M2_71340_51900 0.988200
R6594 n1_M2_71340_51900 n1_M2_72420_51900 0.988200
R6595 n1_M2_72420_51900 n1_M2_73500_51900 0.988200
R6596 n1_M2_73500_51900 n1_M2_74580_51900 0.988200
R6597 n1_M2_74580_51900 n1_M2_75660_51900 0.988200
R6598 n1_M2_75660_51900 n1_M2_76740_51900 0.988200
R6599 n1_M2_76740_51900 n1_M2_77820_51900 0.988200
R6600 n1_M2_77820_51900 n1_M2_78900_51900 0.988200
R6601 n1_M2_78900_51900 n1_M2_79980_51900 0.988200
R6602 n1_M2_79980_51900 n1_M2_81060_51900 0.988200
R6603 n1_M2_81060_51900 n1_M2_82140_51900 0.988200
R6604 n1_M2_82140_51900 n1_M2_83220_51900 0.988200
R6605 n1_M2_83220_51900 n1_M2_84300_51900 0.988200
R6606 n1_M2_84300_51900 n1_M2_85380_51900 0.988200
R6607 n1_M2_85380_51900 n1_M2_86460_51900 0.988200
R6608 n1_M2_86460_51900 n1_M2_87540_51900 0.988200
R6609 n1_M2_87540_51900 n1_M2_88620_51900 0.988200
R6610 n1_M2_88620_51900 n1_M2_89700_51900 0.988200
R6611 n1_M2_89700_51900 n1_M2_90780_51900 0.988200
R6612 n1_M2_90780_51900 n1_M2_91860_51900 0.988200
R6613 n1_M2_91860_51900 n1_M2_92940_51900 0.988200
R6614 n1_M2_92940_51900 n1_M2_94020_51900 0.988200
R6615 n1_M2_94020_51900 n1_M2_95100_51900 0.988200
R6616 n1_M2_95100_51900 n1_M2_96180_51900 0.988200
R6617 n1_M2_96180_51900 n1_M2_97260_51900 0.988200
R6618 n1_M2_97260_51900 n1_M2_98340_51900 0.988200
R6619 n1_M2_98340_51900 n1_M2_99420_51900 0.988200
R6620 n1_M2_99420_51900 n1_M2_100500_51900 0.988200
R6621 n1_M2_100500_51900 n1_M2_101580_51900 0.988200
R6622 n1_M2_101580_51900 n1_M2_102660_51900 0.988200
R6623 n1_M2_102660_51900 n1_M2_103740_51900 0.988200
R6624 n1_M2_103740_51900 n1_M2_104820_51900 0.988200
R6625 n1_M2_104820_51900 n1_M2_105900_51900 0.988200
R6626 n1_M2_105900_51900 n1_M2_106980_51900 0.988200
R6627 n1_M2_106980_51900 n1_M2_108060_51900 0.988200
R6628 n1_M2_108060_51900 n1_M2_109140_51900 0.988200
R6629 n1_M2_109140_51900 n1_M2_110220_51900 0.988200
R6630 n1_M2_110220_51900 n1_M2_111300_51900 0.988200
R6631 n1_M2_111300_51900 n1_M2_112380_51900 0.988200
R6632 n1_M2_112380_51900 n1_M2_113460_51900 0.988200
R6633 n1_M2_113460_51900 n1_M2_114540_51900 0.988200
R6634 n1_M2_114540_51900 n1_M2_115620_51900 0.988200
R6635 n1_M2_115620_51900 n1_M2_116700_51900 0.988200
R6636 n1_M2_116700_51900 n1_M2_117780_51900 0.988200
R6637 n1_M2_117780_51900 n1_M2_118860_51900 0.988200
R6638 n1_M2_118860_51900 n1_M2_119940_51900 0.988200
R6639 n1_M2_119940_51900 n1_M2_121020_51900 0.988200
R6640 n1_M2_121020_51900 n1_M2_122100_51900 0.988200
R6641 n1_M2_122100_51900 n1_M2_123180_51900 0.988200
R6642 n1_M2_123180_51900 n1_M2_124260_51900 0.988200
R6643 n1_M2_124260_51900 n1_M2_125340_51900 0.988200
R6644 n1_M2_125340_51900 n1_M2_126420_51900 0.988200
R6645 n1_M2_126420_51900 n1_M2_127500_51900 0.988200
R6646 n1_M2_127500_51900 n1_M2_128580_51900 0.988200
R6647 n1_M2_128580_51900 n1_M2_129660_51900 0.988200
R6648 n1_M2_129660_51900 n1_M2_130740_51900 0.988200
R6649 n1_M2_130740_51900 n1_M2_131820_51900 0.988200
R6650 n1_M2_131820_51900 n1_M2_132900_51900 0.988200
R6651 n1_M2_132900_51900 n1_M2_133980_51900 0.988200
R6652 n1_M2_133980_51900 n1_M2_135060_51900 0.988200
R6653 n1_M2_135060_51900 n1_M2_136140_51900 0.988200
R6654 n1_M2_136140_51900 n1_M2_137220_51900 0.988200
R6655 n1_M2_137220_51900 n1_M2_138300_51900 0.988200
R6656 n1_M2_138300_51900 n1_M2_139380_51900 0.988200
R6657 n1_M2_139380_51900 n1_M2_140460_51900 0.988200
R6658 n1_M2_140460_51900 n1_M2_141540_51900 0.988200
R6659 n1_M2_141540_51900 n1_M2_142620_51900 0.988200
R6660 n1_M2_142620_51900 n1_M2_143700_51900 0.988200
R6661 n1_M2_143700_51900 n1_M2_144780_51900 0.988200
R6662 n1_M2_144780_51900 n1_M2_145860_51900 0.988200
R6663 n1_M2_145860_51900 n1_M2_146940_51900 0.988200
R6664 n1_M2_60_52980 n1_M2_1140_52980 0.988200
R6665 n1_M2_1140_52980 n1_M2_2220_52980 0.988200
R6666 n1_M2_2220_52980 n1_M2_3300_52980 0.988200
R6667 n1_M2_3300_52980 n1_M2_4380_52980 0.988200
R6668 n1_M2_4380_52980 n1_M2_5460_52980 0.988200
R6669 n1_M2_5460_52980 n1_M2_6540_52980 0.988200
R6670 n1_M2_6540_52980 n1_M2_7620_52980 0.988200
R6671 n1_M2_7620_52980 n1_M2_8700_52980 0.988200
R6672 n1_M2_8700_52980 n1_M2_9780_52980 0.988200
R6673 n1_M2_9780_52980 n1_M2_10860_52980 0.988200
R6674 n1_M2_10860_52980 n1_M2_11940_52980 0.988200
R6675 n1_M2_11940_52980 n1_M2_13020_52980 0.988200
R6676 n1_M2_13020_52980 n1_M2_14100_52980 0.988200
R6677 n1_M2_14100_52980 n1_M2_15180_52980 0.988200
R6678 n1_M2_15180_52980 n1_M2_16260_52980 0.988200
R6679 n1_M2_16260_52980 n1_M2_17340_52980 0.988200
R6680 n1_M2_17340_52980 n1_M2_18420_52980 0.988200
R6681 n1_M2_18420_52980 n1_M2_19500_52980 0.988200
R6682 n1_M2_19500_52980 n1_M2_20580_52980 0.988200
R6683 n1_M2_20580_52980 n1_M2_21660_52980 0.988200
R6684 n1_M2_21660_52980 n1_M2_22740_52980 0.988200
R6685 n1_M2_22740_52980 n1_M2_23820_52980 0.988200
R6686 n1_M2_23820_52980 n1_M2_24900_52980 0.988200
R6687 n1_M2_24900_52980 n1_M2_25980_52980 0.988200
R6688 n1_M2_25980_52980 n1_M2_27060_52980 0.988200
R6689 n1_M2_27060_52980 n1_M2_28140_52980 0.988200
R6690 n1_M2_28140_52980 n1_M2_29220_52980 0.988200
R6691 n1_M2_29220_52980 n1_M2_30300_52980 0.988200
R6692 n1_M2_30300_52980 n1_M2_31380_52980 0.988200
R6693 n1_M2_31380_52980 n1_M2_32460_52980 0.988200
R6694 n1_M2_32460_52980 n1_M2_33540_52980 0.988200
R6695 n1_M2_33540_52980 n1_M2_34620_52980 0.988200
R6696 n1_M2_34620_52980 n1_M2_35700_52980 0.988200
R6697 n1_M2_35700_52980 n1_M2_36780_52980 0.988200
R6698 n1_M2_36780_52980 n1_M2_37860_52980 0.988200
R6699 n1_M2_37860_52980 n1_M2_38940_52980 0.988200
R6700 n1_M2_38940_52980 n1_M2_40020_52980 0.988200
R6701 n1_M2_40020_52980 n1_M2_41100_52980 0.988200
R6702 n1_M2_41100_52980 n1_M2_42180_52980 0.988200
R6703 n1_M2_42180_52980 n1_M2_43260_52980 0.988200
R6704 n1_M2_43260_52980 n1_M2_44340_52980 0.988200
R6705 n1_M2_44340_52980 n1_M2_45420_52980 0.988200
R6706 n1_M2_45420_52980 n1_M2_46500_52980 0.988200
R6707 n1_M2_46500_52980 n1_M2_47580_52980 0.988200
R6708 n1_M2_47580_52980 n1_M2_48660_52980 0.988200
R6709 n1_M2_48660_52980 n1_M2_49740_52980 0.988200
R6710 n1_M2_49740_52980 n1_M2_50820_52980 0.988200
R6711 n1_M2_50820_52980 n1_M2_51900_52980 0.988200
R6712 n1_M2_51900_52980 n1_M2_52980_52980 0.988200
R6713 n1_M2_52980_52980 n1_M2_54060_52980 0.988200
R6714 n1_M2_54060_52980 n1_M2_55140_52980 0.988200
R6715 n1_M2_55140_52980 n1_M2_56220_52980 0.988200
R6716 n1_M2_56220_52980 n1_M2_57300_52980 0.988200
R6717 n1_M2_57300_52980 n1_M2_58380_52980 0.988200
R6718 n1_M2_58380_52980 n1_M2_59460_52980 0.988200
R6719 n1_M2_59460_52980 n1_M2_60540_52980 0.988200
R6720 n1_M2_60540_52980 n1_M2_61620_52980 0.988200
R6721 n1_M2_61620_52980 n1_M2_62700_52980 0.988200
R6722 n1_M2_62700_52980 n1_M2_63780_52980 0.988200
R6723 n1_M2_63780_52980 n1_M2_64860_52980 0.988200
R6724 n1_M2_64860_52980 n1_M2_65940_52980 0.988200
R6725 n1_M2_65940_52980 n1_M2_67020_52980 0.988200
R6726 n1_M2_67020_52980 n1_M2_68100_52980 0.988200
R6727 n1_M2_68100_52980 n1_M2_69180_52980 0.988200
R6728 n1_M2_69180_52980 n1_M2_70260_52980 0.988200
R6729 n1_M2_70260_52980 n1_M2_71340_52980 0.988200
R6730 n1_M2_71340_52980 n1_M2_72420_52980 0.988200
R6731 n1_M2_72420_52980 n1_M2_73500_52980 0.988200
R6732 n1_M2_73500_52980 n1_M2_74580_52980 0.988200
R6733 n1_M2_74580_52980 n1_M2_75660_52980 0.988200
R6734 n1_M2_75660_52980 n1_M2_76740_52980 0.988200
R6735 n1_M2_76740_52980 n1_M2_77820_52980 0.988200
R6736 n1_M2_77820_52980 n1_M2_78900_52980 0.988200
R6737 n1_M2_78900_52980 n1_M2_79980_52980 0.988200
R6738 n1_M2_79980_52980 n1_M2_81060_52980 0.988200
R6739 n1_M2_81060_52980 n1_M2_82140_52980 0.988200
R6740 n1_M2_82140_52980 n1_M2_83220_52980 0.988200
R6741 n1_M2_83220_52980 n1_M2_84300_52980 0.988200
R6742 n1_M2_84300_52980 n1_M2_85380_52980 0.988200
R6743 n1_M2_85380_52980 n1_M2_86460_52980 0.988200
R6744 n1_M2_86460_52980 n1_M2_87540_52980 0.988200
R6745 n1_M2_87540_52980 n1_M2_88620_52980 0.988200
R6746 n1_M2_88620_52980 n1_M2_89700_52980 0.988200
R6747 n1_M2_89700_52980 n1_M2_90780_52980 0.988200
R6748 n1_M2_90780_52980 n1_M2_91860_52980 0.988200
R6749 n1_M2_91860_52980 n1_M2_92940_52980 0.988200
R6750 n1_M2_92940_52980 n1_M2_94020_52980 0.988200
R6751 n1_M2_94020_52980 n1_M2_95100_52980 0.988200
R6752 n1_M2_95100_52980 n1_M2_96180_52980 0.988200
R6753 n1_M2_96180_52980 n1_M2_97260_52980 0.988200
R6754 n1_M2_97260_52980 n1_M2_98340_52980 0.988200
R6755 n1_M2_98340_52980 n1_M2_99420_52980 0.988200
R6756 n1_M2_99420_52980 n1_M2_100500_52980 0.988200
R6757 n1_M2_100500_52980 n1_M2_101580_52980 0.988200
R6758 n1_M2_101580_52980 n1_M2_102660_52980 0.988200
R6759 n1_M2_102660_52980 n1_M2_103740_52980 0.988200
R6760 n1_M2_103740_52980 n1_M2_104820_52980 0.988200
R6761 n1_M2_104820_52980 n1_M2_105900_52980 0.988200
R6762 n1_M2_105900_52980 n1_M2_106980_52980 0.988200
R6763 n1_M2_106980_52980 n1_M2_108060_52980 0.988200
R6764 n1_M2_108060_52980 n1_M2_109140_52980 0.988200
R6765 n1_M2_109140_52980 n1_M2_110220_52980 0.988200
R6766 n1_M2_110220_52980 n1_M2_111300_52980 0.988200
R6767 n1_M2_111300_52980 n1_M2_112380_52980 0.988200
R6768 n1_M2_112380_52980 n1_M2_113460_52980 0.988200
R6769 n1_M2_113460_52980 n1_M2_114540_52980 0.988200
R6770 n1_M2_114540_52980 n1_M2_115620_52980 0.988200
R6771 n1_M2_115620_52980 n1_M2_116700_52980 0.988200
R6772 n1_M2_116700_52980 n1_M2_117780_52980 0.988200
R6773 n1_M2_117780_52980 n1_M2_118860_52980 0.988200
R6774 n1_M2_118860_52980 n1_M2_119940_52980 0.988200
R6775 n1_M2_119940_52980 n1_M2_121020_52980 0.988200
R6776 n1_M2_121020_52980 n1_M2_122100_52980 0.988200
R6777 n1_M2_122100_52980 n1_M2_123180_52980 0.988200
R6778 n1_M2_123180_52980 n1_M2_124260_52980 0.988200
R6779 n1_M2_124260_52980 n1_M2_125340_52980 0.988200
R6780 n1_M2_125340_52980 n1_M2_126420_52980 0.988200
R6781 n1_M2_126420_52980 n1_M2_127500_52980 0.988200
R6782 n1_M2_127500_52980 n1_M2_128580_52980 0.988200
R6783 n1_M2_128580_52980 n1_M2_129660_52980 0.988200
R6784 n1_M2_129660_52980 n1_M2_130740_52980 0.988200
R6785 n1_M2_130740_52980 n1_M2_131820_52980 0.988200
R6786 n1_M2_131820_52980 n1_M2_132900_52980 0.988200
R6787 n1_M2_132900_52980 n1_M2_133980_52980 0.988200
R6788 n1_M2_133980_52980 n1_M2_135060_52980 0.988200
R6789 n1_M2_135060_52980 n1_M2_136140_52980 0.988200
R6790 n1_M2_136140_52980 n1_M2_137220_52980 0.988200
R6791 n1_M2_137220_52980 n1_M2_138300_52980 0.988200
R6792 n1_M2_138300_52980 n1_M2_139380_52980 0.988200
R6793 n1_M2_139380_52980 n1_M2_140460_52980 0.988200
R6794 n1_M2_140460_52980 n1_M2_141540_52980 0.988200
R6795 n1_M2_141540_52980 n1_M2_142620_52980 0.988200
R6796 n1_M2_142620_52980 n1_M2_143700_52980 0.988200
R6797 n1_M2_143700_52980 n1_M2_144780_52980 0.988200
R6798 n1_M2_144780_52980 n1_M2_145860_52980 0.988200
R6799 n1_M2_145860_52980 n1_M2_146940_52980 0.988200
R6800 n1_M2_60_54060 n1_M2_1140_54060 0.988200
R6801 n1_M2_1140_54060 n1_M2_2220_54060 0.988200
R6802 n1_M2_2220_54060 n1_M2_3300_54060 0.988200
R6803 n1_M2_3300_54060 n1_M2_4380_54060 0.988200
R6804 n1_M2_4380_54060 n1_M2_5460_54060 0.988200
R6805 n1_M2_5460_54060 n1_M2_6540_54060 0.988200
R6806 n1_M2_6540_54060 n1_M2_7620_54060 0.988200
R6807 n1_M2_7620_54060 n1_M2_8700_54060 0.988200
R6808 n1_M2_8700_54060 n1_M2_9780_54060 0.988200
R6809 n1_M2_9780_54060 n1_M2_10860_54060 0.988200
R6810 n1_M2_10860_54060 n1_M2_11940_54060 0.988200
R6811 n1_M2_11940_54060 n1_M2_13020_54060 0.988200
R6812 n1_M2_13020_54060 n1_M2_14100_54060 0.988200
R6813 n1_M2_14100_54060 n1_M2_15180_54060 0.988200
R6814 n1_M2_15180_54060 n1_M2_16260_54060 0.988200
R6815 n1_M2_16260_54060 n1_M2_17340_54060 0.988200
R6816 n1_M2_17340_54060 n1_M2_18420_54060 0.988200
R6817 n1_M2_18420_54060 n1_M2_19500_54060 0.988200
R6818 n1_M2_19500_54060 n1_M2_20580_54060 0.988200
R6819 n1_M2_20580_54060 n1_M2_21660_54060 0.988200
R6820 n1_M2_21660_54060 n1_M2_22740_54060 0.988200
R6821 n1_M2_22740_54060 n1_M2_23820_54060 0.988200
R6822 n1_M2_23820_54060 n1_M2_24900_54060 0.988200
R6823 n1_M2_24900_54060 n1_M2_25980_54060 0.988200
R6824 n1_M2_25980_54060 n1_M2_27060_54060 0.988200
R6825 n1_M2_27060_54060 n1_M2_28140_54060 0.988200
R6826 n1_M2_28140_54060 n1_M2_29220_54060 0.988200
R6827 n1_M2_29220_54060 n1_M2_30300_54060 0.988200
R6828 n1_M2_30300_54060 n1_M2_31380_54060 0.988200
R6829 n1_M2_31380_54060 n1_M2_32460_54060 0.988200
R6830 n1_M2_32460_54060 n1_M2_33540_54060 0.988200
R6831 n1_M2_33540_54060 n1_M2_34620_54060 0.988200
R6832 n1_M2_34620_54060 n1_M2_35700_54060 0.988200
R6833 n1_M2_35700_54060 n1_M2_36780_54060 0.988200
R6834 n1_M2_36780_54060 n1_M2_37860_54060 0.988200
R6835 n1_M2_37860_54060 n1_M2_38940_54060 0.988200
R6836 n1_M2_38940_54060 n1_M2_40020_54060 0.988200
R6837 n1_M2_40020_54060 n1_M2_41100_54060 0.988200
R6838 n1_M2_41100_54060 n1_M2_42180_54060 0.988200
R6839 n1_M2_42180_54060 n1_M2_43260_54060 0.988200
R6840 n1_M2_43260_54060 n1_M2_44340_54060 0.988200
R6841 n1_M2_44340_54060 n1_M2_45420_54060 0.988200
R6842 n1_M2_45420_54060 n1_M2_46500_54060 0.988200
R6843 n1_M2_46500_54060 n1_M2_47580_54060 0.988200
R6844 n1_M2_47580_54060 n1_M2_48660_54060 0.988200
R6845 n1_M2_48660_54060 n1_M2_49740_54060 0.988200
R6846 n1_M2_49740_54060 n1_M2_50820_54060 0.988200
R6847 n1_M2_50820_54060 n1_M2_51900_54060 0.988200
R6848 n1_M2_51900_54060 n1_M2_52980_54060 0.988200
R6849 n1_M2_52980_54060 n1_M2_54060_54060 0.988200
R6850 n1_M2_54060_54060 n1_M2_55140_54060 0.988200
R6851 n1_M2_55140_54060 n1_M2_56220_54060 0.988200
R6852 n1_M2_56220_54060 n1_M2_57300_54060 0.988200
R6853 n1_M2_57300_54060 n1_M2_58380_54060 0.988200
R6854 n1_M2_58380_54060 n1_M2_59460_54060 0.988200
R6855 n1_M2_59460_54060 n1_M2_60540_54060 0.988200
R6856 n1_M2_60540_54060 n1_M2_61620_54060 0.988200
R6857 n1_M2_61620_54060 n1_M2_62700_54060 0.988200
R6858 n1_M2_62700_54060 n1_M2_63780_54060 0.988200
R6859 n1_M2_63780_54060 n1_M2_64860_54060 0.988200
R6860 n1_M2_64860_54060 n1_M2_65940_54060 0.988200
R6861 n1_M2_65940_54060 n1_M2_67020_54060 0.988200
R6862 n1_M2_67020_54060 n1_M2_68100_54060 0.988200
R6863 n1_M2_68100_54060 n1_M2_69180_54060 0.988200
R6864 n1_M2_69180_54060 n1_M2_70260_54060 0.988200
R6865 n1_M2_70260_54060 n1_M2_71340_54060 0.988200
R6866 n1_M2_71340_54060 n1_M2_72420_54060 0.988200
R6867 n1_M2_72420_54060 n1_M2_73500_54060 0.988200
R6868 n1_M2_73500_54060 n1_M2_74580_54060 0.988200
R6869 n1_M2_74580_54060 n1_M2_75660_54060 0.988200
R6870 n1_M2_75660_54060 n1_M2_76740_54060 0.988200
R6871 n1_M2_76740_54060 n1_M2_77820_54060 0.988200
R6872 n1_M2_77820_54060 n1_M2_78900_54060 0.988200
R6873 n1_M2_78900_54060 n1_M2_79980_54060 0.988200
R6874 n1_M2_79980_54060 n1_M2_81060_54060 0.988200
R6875 n1_M2_81060_54060 n1_M2_82140_54060 0.988200
R6876 n1_M2_82140_54060 n1_M2_83220_54060 0.988200
R6877 n1_M2_83220_54060 n1_M2_84300_54060 0.988200
R6878 n1_M2_84300_54060 n1_M2_85380_54060 0.988200
R6879 n1_M2_85380_54060 n1_M2_86460_54060 0.988200
R6880 n1_M2_86460_54060 n1_M2_87540_54060 0.988200
R6881 n1_M2_87540_54060 n1_M2_88620_54060 0.988200
R6882 n1_M2_88620_54060 n1_M2_89700_54060 0.988200
R6883 n1_M2_89700_54060 n1_M2_90780_54060 0.988200
R6884 n1_M2_90780_54060 n1_M2_91860_54060 0.988200
R6885 n1_M2_91860_54060 n1_M2_92940_54060 0.988200
R6886 n1_M2_92940_54060 n1_M2_94020_54060 0.988200
R6887 n1_M2_94020_54060 n1_M2_95100_54060 0.988200
R6888 n1_M2_95100_54060 n1_M2_96180_54060 0.988200
R6889 n1_M2_96180_54060 n1_M2_97260_54060 0.988200
R6890 n1_M2_97260_54060 n1_M2_98340_54060 0.988200
R6891 n1_M2_98340_54060 n1_M2_99420_54060 0.988200
R6892 n1_M2_99420_54060 n1_M2_100500_54060 0.988200
R6893 n1_M2_100500_54060 n1_M2_101580_54060 0.988200
R6894 n1_M2_101580_54060 n1_M2_102660_54060 0.988200
R6895 n1_M2_102660_54060 n1_M2_103740_54060 0.988200
R6896 n1_M2_103740_54060 n1_M2_104820_54060 0.988200
R6897 n1_M2_104820_54060 n1_M2_105900_54060 0.988200
R6898 n1_M2_105900_54060 n1_M2_106980_54060 0.988200
R6899 n1_M2_106980_54060 n1_M2_108060_54060 0.988200
R6900 n1_M2_108060_54060 n1_M2_109140_54060 0.988200
R6901 n1_M2_109140_54060 n1_M2_110220_54060 0.988200
R6902 n1_M2_110220_54060 n1_M2_111300_54060 0.988200
R6903 n1_M2_111300_54060 n1_M2_112380_54060 0.988200
R6904 n1_M2_112380_54060 n1_M2_113460_54060 0.988200
R6905 n1_M2_113460_54060 n1_M2_114540_54060 0.988200
R6906 n1_M2_114540_54060 n1_M2_115620_54060 0.988200
R6907 n1_M2_115620_54060 n1_M2_116700_54060 0.988200
R6908 n1_M2_116700_54060 n1_M2_117780_54060 0.988200
R6909 n1_M2_117780_54060 n1_M2_118860_54060 0.988200
R6910 n1_M2_118860_54060 n1_M2_119940_54060 0.988200
R6911 n1_M2_119940_54060 n1_M2_121020_54060 0.988200
R6912 n1_M2_121020_54060 n1_M2_122100_54060 0.988200
R6913 n1_M2_122100_54060 n1_M2_123180_54060 0.988200
R6914 n1_M2_123180_54060 n1_M2_124260_54060 0.988200
R6915 n1_M2_124260_54060 n1_M2_125340_54060 0.988200
R6916 n1_M2_125340_54060 n1_M2_126420_54060 0.988200
R6917 n1_M2_126420_54060 n1_M2_127500_54060 0.988200
R6918 n1_M2_127500_54060 n1_M2_128580_54060 0.988200
R6919 n1_M2_128580_54060 n1_M2_129660_54060 0.988200
R6920 n1_M2_129660_54060 n1_M2_130740_54060 0.988200
R6921 n1_M2_130740_54060 n1_M2_131820_54060 0.988200
R6922 n1_M2_131820_54060 n1_M2_132900_54060 0.988200
R6923 n1_M2_132900_54060 n1_M2_133980_54060 0.988200
R6924 n1_M2_133980_54060 n1_M2_135060_54060 0.988200
R6925 n1_M2_135060_54060 n1_M2_136140_54060 0.988200
R6926 n1_M2_136140_54060 n1_M2_137220_54060 0.988200
R6927 n1_M2_137220_54060 n1_M2_138300_54060 0.988200
R6928 n1_M2_138300_54060 n1_M2_139380_54060 0.988200
R6929 n1_M2_139380_54060 n1_M2_140460_54060 0.988200
R6930 n1_M2_140460_54060 n1_M2_141540_54060 0.988200
R6931 n1_M2_141540_54060 n1_M2_142620_54060 0.988200
R6932 n1_M2_142620_54060 n1_M2_143700_54060 0.988200
R6933 n1_M2_143700_54060 n1_M2_144780_54060 0.988200
R6934 n1_M2_144780_54060 n1_M2_145860_54060 0.988200
R6935 n1_M2_145860_54060 n1_M2_146940_54060 0.988200
R6936 n1_M2_60_55140 n1_M2_1140_55140 0.988200
R6937 n1_M2_1140_55140 n1_M2_2220_55140 0.988200
R6938 n1_M2_2220_55140 n1_M2_3300_55140 0.988200
R6939 n1_M2_3300_55140 n1_M2_4380_55140 0.988200
R6940 n1_M2_4380_55140 n1_M2_5460_55140 0.988200
R6941 n1_M2_5460_55140 n1_M2_6540_55140 0.988200
R6942 n1_M2_6540_55140 n1_M2_7620_55140 0.988200
R6943 n1_M2_7620_55140 n1_M2_8700_55140 0.988200
R6944 n1_M2_8700_55140 n1_M2_9780_55140 0.988200
R6945 n1_M2_9780_55140 n1_M2_10860_55140 0.988200
R6946 n1_M2_10860_55140 n1_M2_11940_55140 0.988200
R6947 n1_M2_11940_55140 n1_M2_13020_55140 0.988200
R6948 n1_M2_13020_55140 n1_M2_14100_55140 0.988200
R6949 n1_M2_14100_55140 n1_M2_15180_55140 0.988200
R6950 n1_M2_15180_55140 n1_M2_16260_55140 0.988200
R6951 n1_M2_16260_55140 n1_M2_17340_55140 0.988200
R6952 n1_M2_17340_55140 n1_M2_18420_55140 0.988200
R6953 n1_M2_18420_55140 n1_M2_19500_55140 0.988200
R6954 n1_M2_19500_55140 n1_M2_20580_55140 0.988200
R6955 n1_M2_20580_55140 n1_M2_21660_55140 0.988200
R6956 n1_M2_21660_55140 n1_M2_22740_55140 0.988200
R6957 n1_M2_22740_55140 n1_M2_23820_55140 0.988200
R6958 n1_M2_23820_55140 n1_M2_24900_55140 0.988200
R6959 n1_M2_24900_55140 n1_M2_25980_55140 0.988200
R6960 n1_M2_25980_55140 n1_M2_27060_55140 0.988200
R6961 n1_M2_27060_55140 n1_M2_28140_55140 0.988200
R6962 n1_M2_28140_55140 n1_M2_29220_55140 0.988200
R6963 n1_M2_29220_55140 n1_M2_30300_55140 0.988200
R6964 n1_M2_30300_55140 n1_M2_31380_55140 0.988200
R6965 n1_M2_31380_55140 n1_M2_32460_55140 0.988200
R6966 n1_M2_32460_55140 n1_M2_33540_55140 0.988200
R6967 n1_M2_33540_55140 n1_M2_34620_55140 0.988200
R6968 n1_M2_34620_55140 n1_M2_35700_55140 0.988200
R6969 n1_M2_35700_55140 n1_M2_36780_55140 0.988200
R6970 n1_M2_36780_55140 n1_M2_37860_55140 0.988200
R6971 n1_M2_37860_55140 n1_M2_38940_55140 0.988200
R6972 n1_M2_38940_55140 n1_M2_40020_55140 0.988200
R6973 n1_M2_40020_55140 n1_M2_41100_55140 0.988200
R6974 n1_M2_41100_55140 n1_M2_42180_55140 0.988200
R6975 n1_M2_42180_55140 n1_M2_43260_55140 0.988200
R6976 n1_M2_43260_55140 n1_M2_44340_55140 0.988200
R6977 n1_M2_44340_55140 n1_M2_45420_55140 0.988200
R6978 n1_M2_45420_55140 n1_M2_46500_55140 0.988200
R6979 n1_M2_46500_55140 n1_M2_47580_55140 0.988200
R6980 n1_M2_47580_55140 n1_M2_48660_55140 0.988200
R6981 n1_M2_48660_55140 n1_M2_49740_55140 0.988200
R6982 n1_M2_49740_55140 n1_M2_50820_55140 0.988200
R6983 n1_M2_50820_55140 n1_M2_51900_55140 0.988200
R6984 n1_M2_51900_55140 n1_M2_52980_55140 0.988200
R6985 n1_M2_52980_55140 n1_M2_54060_55140 0.988200
R6986 n1_M2_54060_55140 n1_M2_55140_55140 0.988200
R6987 n1_M2_55140_55140 n1_M2_56220_55140 0.988200
R6988 n1_M2_56220_55140 n1_M2_57300_55140 0.988200
R6989 n1_M2_57300_55140 n1_M2_58380_55140 0.988200
R6990 n1_M2_58380_55140 n1_M2_59460_55140 0.988200
R6991 n1_M2_59460_55140 n1_M2_60540_55140 0.988200
R6992 n1_M2_60540_55140 n1_M2_61620_55140 0.988200
R6993 n1_M2_61620_55140 n1_M2_62700_55140 0.988200
R6994 n1_M2_62700_55140 n1_M2_63780_55140 0.988200
R6995 n1_M2_63780_55140 n1_M2_64860_55140 0.988200
R6996 n1_M2_64860_55140 n1_M2_65940_55140 0.988200
R6997 n1_M2_65940_55140 n1_M2_67020_55140 0.988200
R6998 n1_M2_67020_55140 n1_M2_68100_55140 0.988200
R6999 n1_M2_68100_55140 n1_M2_69180_55140 0.988200
R7000 n1_M2_69180_55140 n1_M2_70260_55140 0.988200
R7001 n1_M2_70260_55140 n1_M2_71340_55140 0.988200
R7002 n1_M2_71340_55140 n1_M2_72420_55140 0.988200
R7003 n1_M2_72420_55140 n1_M2_73500_55140 0.988200
R7004 n1_M2_73500_55140 n1_M2_74580_55140 0.988200
R7005 n1_M2_74580_55140 n1_M2_75660_55140 0.988200
R7006 n1_M2_75660_55140 n1_M2_76740_55140 0.988200
R7007 n1_M2_76740_55140 n1_M2_77820_55140 0.988200
R7008 n1_M2_77820_55140 n1_M2_78900_55140 0.988200
R7009 n1_M2_78900_55140 n1_M2_79980_55140 0.988200
R7010 n1_M2_79980_55140 n1_M2_81060_55140 0.988200
R7011 n1_M2_81060_55140 n1_M2_82140_55140 0.988200
R7012 n1_M2_82140_55140 n1_M2_83220_55140 0.988200
R7013 n1_M2_83220_55140 n1_M2_84300_55140 0.988200
R7014 n1_M2_84300_55140 n1_M2_85380_55140 0.988200
R7015 n1_M2_85380_55140 n1_M2_86460_55140 0.988200
R7016 n1_M2_86460_55140 n1_M2_87540_55140 0.988200
R7017 n1_M2_87540_55140 n1_M2_88620_55140 0.988200
R7018 n1_M2_88620_55140 n1_M2_89700_55140 0.988200
R7019 n1_M2_89700_55140 n1_M2_90780_55140 0.988200
R7020 n1_M2_90780_55140 n1_M2_91860_55140 0.988200
R7021 n1_M2_91860_55140 n1_M2_92940_55140 0.988200
R7022 n1_M2_92940_55140 n1_M2_94020_55140 0.988200
R7023 n1_M2_94020_55140 n1_M2_95100_55140 0.988200
R7024 n1_M2_95100_55140 n1_M2_96180_55140 0.988200
R7025 n1_M2_96180_55140 n1_M2_97260_55140 0.988200
R7026 n1_M2_97260_55140 n1_M2_98340_55140 0.988200
R7027 n1_M2_98340_55140 n1_M2_99420_55140 0.988200
R7028 n1_M2_99420_55140 n1_M2_100500_55140 0.988200
R7029 n1_M2_100500_55140 n1_M2_101580_55140 0.988200
R7030 n1_M2_101580_55140 n1_M2_102660_55140 0.988200
R7031 n1_M2_102660_55140 n1_M2_103740_55140 0.988200
R7032 n1_M2_103740_55140 n1_M2_104820_55140 0.988200
R7033 n1_M2_104820_55140 n1_M2_105900_55140 0.988200
R7034 n1_M2_105900_55140 n1_M2_106980_55140 0.988200
R7035 n1_M2_106980_55140 n1_M2_108060_55140 0.988200
R7036 n1_M2_108060_55140 n1_M2_109140_55140 0.988200
R7037 n1_M2_109140_55140 n1_M2_110220_55140 0.988200
R7038 n1_M2_110220_55140 n1_M2_111300_55140 0.988200
R7039 n1_M2_111300_55140 n1_M2_112380_55140 0.988200
R7040 n1_M2_112380_55140 n1_M2_113460_55140 0.988200
R7041 n1_M2_113460_55140 n1_M2_114540_55140 0.988200
R7042 n1_M2_114540_55140 n1_M2_115620_55140 0.988200
R7043 n1_M2_115620_55140 n1_M2_116700_55140 0.988200
R7044 n1_M2_116700_55140 n1_M2_117780_55140 0.988200
R7045 n1_M2_117780_55140 n1_M2_118860_55140 0.988200
R7046 n1_M2_118860_55140 n1_M2_119940_55140 0.988200
R7047 n1_M2_119940_55140 n1_M2_121020_55140 0.988200
R7048 n1_M2_121020_55140 n1_M2_122100_55140 0.988200
R7049 n1_M2_122100_55140 n1_M2_123180_55140 0.988200
R7050 n1_M2_123180_55140 n1_M2_124260_55140 0.988200
R7051 n1_M2_124260_55140 n1_M2_125340_55140 0.988200
R7052 n1_M2_125340_55140 n1_M2_126420_55140 0.988200
R7053 n1_M2_126420_55140 n1_M2_127500_55140 0.988200
R7054 n1_M2_127500_55140 n1_M2_128580_55140 0.988200
R7055 n1_M2_128580_55140 n1_M2_129660_55140 0.988200
R7056 n1_M2_129660_55140 n1_M2_130740_55140 0.988200
R7057 n1_M2_130740_55140 n1_M2_131820_55140 0.988200
R7058 n1_M2_131820_55140 n1_M2_132900_55140 0.988200
R7059 n1_M2_132900_55140 n1_M2_133980_55140 0.988200
R7060 n1_M2_133980_55140 n1_M2_135060_55140 0.988200
R7061 n1_M2_135060_55140 n1_M2_136140_55140 0.988200
R7062 n1_M2_136140_55140 n1_M2_137220_55140 0.988200
R7063 n1_M2_137220_55140 n1_M2_138300_55140 0.988200
R7064 n1_M2_138300_55140 n1_M2_139380_55140 0.988200
R7065 n1_M2_139380_55140 n1_M2_140460_55140 0.988200
R7066 n1_M2_140460_55140 n1_M2_141540_55140 0.988200
R7067 n1_M2_141540_55140 n1_M2_142620_55140 0.988200
R7068 n1_M2_142620_55140 n1_M2_143700_55140 0.988200
R7069 n1_M2_143700_55140 n1_M2_144780_55140 0.988200
R7070 n1_M2_144780_55140 n1_M2_145860_55140 0.988200
R7071 n1_M2_145860_55140 n1_M2_146940_55140 0.988200
R7072 n1_M2_60_56220 n1_M2_1140_56220 0.988200
R7073 n1_M2_1140_56220 n1_M2_2220_56220 0.988200
R7074 n1_M2_2220_56220 n1_M2_3300_56220 0.988200
R7075 n1_M2_3300_56220 n1_M2_4380_56220 0.988200
R7076 n1_M2_4380_56220 n1_M2_5460_56220 0.988200
R7077 n1_M2_5460_56220 n1_M2_6540_56220 0.988200
R7078 n1_M2_6540_56220 n1_M2_7620_56220 0.988200
R7079 n1_M2_7620_56220 n1_M2_8700_56220 0.988200
R7080 n1_M2_8700_56220 n1_M2_9780_56220 0.988200
R7081 n1_M2_9780_56220 n1_M2_10860_56220 0.988200
R7082 n1_M2_10860_56220 n1_M2_11940_56220 0.988200
R7083 n1_M2_11940_56220 n1_M2_13020_56220 0.988200
R7084 n1_M2_13020_56220 n1_M2_14100_56220 0.988200
R7085 n1_M2_14100_56220 n1_M2_15180_56220 0.988200
R7086 n1_M2_15180_56220 n1_M2_16260_56220 0.988200
R7087 n1_M2_16260_56220 n1_M2_17340_56220 0.988200
R7088 n1_M2_17340_56220 n1_M2_18420_56220 0.988200
R7089 n1_M2_18420_56220 n1_M2_19500_56220 0.988200
R7090 n1_M2_19500_56220 n1_M2_20580_56220 0.988200
R7091 n1_M2_20580_56220 n1_M2_21660_56220 0.988200
R7092 n1_M2_21660_56220 n1_M2_22740_56220 0.988200
R7093 n1_M2_22740_56220 n1_M2_23820_56220 0.988200
R7094 n1_M2_23820_56220 n1_M2_24900_56220 0.988200
R7095 n1_M2_24900_56220 n1_M2_25980_56220 0.988200
R7096 n1_M2_25980_56220 n1_M2_27060_56220 0.988200
R7097 n1_M2_27060_56220 n1_M2_28140_56220 0.988200
R7098 n1_M2_28140_56220 n1_M2_29220_56220 0.988200
R7099 n1_M2_29220_56220 n1_M2_30300_56220 0.988200
R7100 n1_M2_30300_56220 n1_M2_31380_56220 0.988200
R7101 n1_M2_31380_56220 n1_M2_32460_56220 0.988200
R7102 n1_M2_32460_56220 n1_M2_33540_56220 0.988200
R7103 n1_M2_33540_56220 n1_M2_34620_56220 0.988200
R7104 n1_M2_34620_56220 n1_M2_35700_56220 0.988200
R7105 n1_M2_35700_56220 n1_M2_36780_56220 0.988200
R7106 n1_M2_36780_56220 n1_M2_37860_56220 0.988200
R7107 n1_M2_37860_56220 n1_M2_38940_56220 0.988200
R7108 n1_M2_38940_56220 n1_M2_40020_56220 0.988200
R7109 n1_M2_40020_56220 n1_M2_41100_56220 0.988200
R7110 n1_M2_41100_56220 n1_M2_42180_56220 0.988200
R7111 n1_M2_42180_56220 n1_M2_43260_56220 0.988200
R7112 n1_M2_43260_56220 n1_M2_44340_56220 0.988200
R7113 n1_M2_44340_56220 n1_M2_45420_56220 0.988200
R7114 n1_M2_45420_56220 n1_M2_46500_56220 0.988200
R7115 n1_M2_46500_56220 n1_M2_47580_56220 0.988200
R7116 n1_M2_47580_56220 n1_M2_48660_56220 0.988200
R7117 n1_M2_48660_56220 n1_M2_49740_56220 0.988200
R7118 n1_M2_49740_56220 n1_M2_50820_56220 0.988200
R7119 n1_M2_50820_56220 n1_M2_51900_56220 0.988200
R7120 n1_M2_51900_56220 n1_M2_52980_56220 0.988200
R7121 n1_M2_52980_56220 n1_M2_54060_56220 0.988200
R7122 n1_M2_54060_56220 n1_M2_55140_56220 0.988200
R7123 n1_M2_55140_56220 n1_M2_56220_56220 0.988200
R7124 n1_M2_56220_56220 n1_M2_57300_56220 0.988200
R7125 n1_M2_57300_56220 n1_M2_58380_56220 0.988200
R7126 n1_M2_58380_56220 n1_M2_59460_56220 0.988200
R7127 n1_M2_59460_56220 n1_M2_60540_56220 0.988200
R7128 n1_M2_60540_56220 n1_M2_61620_56220 0.988200
R7129 n1_M2_61620_56220 n1_M2_62700_56220 0.988200
R7130 n1_M2_62700_56220 n1_M2_63780_56220 0.988200
R7131 n1_M2_63780_56220 n1_M2_64860_56220 0.988200
R7132 n1_M2_64860_56220 n1_M2_65940_56220 0.988200
R7133 n1_M2_65940_56220 n1_M2_67020_56220 0.988200
R7134 n1_M2_67020_56220 n1_M2_68100_56220 0.988200
R7135 n1_M2_68100_56220 n1_M2_69180_56220 0.988200
R7136 n1_M2_69180_56220 n1_M2_70260_56220 0.988200
R7137 n1_M2_70260_56220 n1_M2_71340_56220 0.988200
R7138 n1_M2_71340_56220 n1_M2_72420_56220 0.988200
R7139 n1_M2_72420_56220 n1_M2_73500_56220 0.988200
R7140 n1_M2_73500_56220 n1_M2_74580_56220 0.988200
R7141 n1_M2_74580_56220 n1_M2_75660_56220 0.988200
R7142 n1_M2_75660_56220 n1_M2_76740_56220 0.988200
R7143 n1_M2_76740_56220 n1_M2_77820_56220 0.988200
R7144 n1_M2_77820_56220 n1_M2_78900_56220 0.988200
R7145 n1_M2_78900_56220 n1_M2_79980_56220 0.988200
R7146 n1_M2_79980_56220 n1_M2_81060_56220 0.988200
R7147 n1_M2_81060_56220 n1_M2_82140_56220 0.988200
R7148 n1_M2_82140_56220 n1_M2_83220_56220 0.988200
R7149 n1_M2_83220_56220 n1_M2_84300_56220 0.988200
R7150 n1_M2_84300_56220 n1_M2_85380_56220 0.988200
R7151 n1_M2_85380_56220 n1_M2_86460_56220 0.988200
R7152 n1_M2_86460_56220 n1_M2_87540_56220 0.988200
R7153 n1_M2_87540_56220 n1_M2_88620_56220 0.988200
R7154 n1_M2_88620_56220 n1_M2_89700_56220 0.988200
R7155 n1_M2_89700_56220 n1_M2_90780_56220 0.988200
R7156 n1_M2_90780_56220 n1_M2_91860_56220 0.988200
R7157 n1_M2_91860_56220 n1_M2_92940_56220 0.988200
R7158 n1_M2_92940_56220 n1_M2_94020_56220 0.988200
R7159 n1_M2_94020_56220 n1_M2_95100_56220 0.988200
R7160 n1_M2_95100_56220 n1_M2_96180_56220 0.988200
R7161 n1_M2_96180_56220 n1_M2_97260_56220 0.988200
R7162 n1_M2_97260_56220 n1_M2_98340_56220 0.988200
R7163 n1_M2_98340_56220 n1_M2_99420_56220 0.988200
R7164 n1_M2_99420_56220 n1_M2_100500_56220 0.988200
R7165 n1_M2_100500_56220 n1_M2_101580_56220 0.988200
R7166 n1_M2_101580_56220 n1_M2_102660_56220 0.988200
R7167 n1_M2_102660_56220 n1_M2_103740_56220 0.988200
R7168 n1_M2_103740_56220 n1_M2_104820_56220 0.988200
R7169 n1_M2_104820_56220 n1_M2_105900_56220 0.988200
R7170 n1_M2_105900_56220 n1_M2_106980_56220 0.988200
R7171 n1_M2_106980_56220 n1_M2_108060_56220 0.988200
R7172 n1_M2_108060_56220 n1_M2_109140_56220 0.988200
R7173 n1_M2_109140_56220 n1_M2_110220_56220 0.988200
R7174 n1_M2_110220_56220 n1_M2_111300_56220 0.988200
R7175 n1_M2_111300_56220 n1_M2_112380_56220 0.988200
R7176 n1_M2_112380_56220 n1_M2_113460_56220 0.988200
R7177 n1_M2_113460_56220 n1_M2_114540_56220 0.988200
R7178 n1_M2_114540_56220 n1_M2_115620_56220 0.988200
R7179 n1_M2_115620_56220 n1_M2_116700_56220 0.988200
R7180 n1_M2_116700_56220 n1_M2_117780_56220 0.988200
R7181 n1_M2_117780_56220 n1_M2_118860_56220 0.988200
R7182 n1_M2_118860_56220 n1_M2_119940_56220 0.988200
R7183 n1_M2_119940_56220 n1_M2_121020_56220 0.988200
R7184 n1_M2_121020_56220 n1_M2_122100_56220 0.988200
R7185 n1_M2_122100_56220 n1_M2_123180_56220 0.988200
R7186 n1_M2_123180_56220 n1_M2_124260_56220 0.988200
R7187 n1_M2_124260_56220 n1_M2_125340_56220 0.988200
R7188 n1_M2_125340_56220 n1_M2_126420_56220 0.988200
R7189 n1_M2_126420_56220 n1_M2_127500_56220 0.988200
R7190 n1_M2_127500_56220 n1_M2_128580_56220 0.988200
R7191 n1_M2_128580_56220 n1_M2_129660_56220 0.988200
R7192 n1_M2_129660_56220 n1_M2_130740_56220 0.988200
R7193 n1_M2_130740_56220 n1_M2_131820_56220 0.988200
R7194 n1_M2_131820_56220 n1_M2_132900_56220 0.988200
R7195 n1_M2_132900_56220 n1_M2_133980_56220 0.988200
R7196 n1_M2_133980_56220 n1_M2_135060_56220 0.988200
R7197 n1_M2_135060_56220 n1_M2_136140_56220 0.988200
R7198 n1_M2_136140_56220 n1_M2_137220_56220 0.988200
R7199 n1_M2_137220_56220 n1_M2_138300_56220 0.988200
R7200 n1_M2_138300_56220 n1_M2_139380_56220 0.988200
R7201 n1_M2_139380_56220 n1_M2_140460_56220 0.988200
R7202 n1_M2_140460_56220 n1_M2_141540_56220 0.988200
R7203 n1_M2_141540_56220 n1_M2_142620_56220 0.988200
R7204 n1_M2_142620_56220 n1_M2_143700_56220 0.988200
R7205 n1_M2_143700_56220 n1_M2_144780_56220 0.988200
R7206 n1_M2_144780_56220 n1_M2_145860_56220 0.988200
R7207 n1_M2_145860_56220 n1_M2_146940_56220 0.988200
R7208 n1_M2_60_57300 n1_M2_1140_57300 0.988200
R7209 n1_M2_1140_57300 n1_M2_2220_57300 0.988200
R7210 n1_M2_2220_57300 n1_M2_3300_57300 0.988200
R7211 n1_M2_3300_57300 n1_M2_4380_57300 0.988200
R7212 n1_M2_4380_57300 n1_M2_5460_57300 0.988200
R7213 n1_M2_5460_57300 n1_M2_6540_57300 0.988200
R7214 n1_M2_6540_57300 n1_M2_7620_57300 0.988200
R7215 n1_M2_7620_57300 n1_M2_8700_57300 0.988200
R7216 n1_M2_8700_57300 n1_M2_9780_57300 0.988200
R7217 n1_M2_9780_57300 n1_M2_10860_57300 0.988200
R7218 n1_M2_10860_57300 n1_M2_11940_57300 0.988200
R7219 n1_M2_11940_57300 n1_M2_13020_57300 0.988200
R7220 n1_M2_13020_57300 n1_M2_14100_57300 0.988200
R7221 n1_M2_14100_57300 n1_M2_15180_57300 0.988200
R7222 n1_M2_15180_57300 n1_M2_16260_57300 0.988200
R7223 n1_M2_16260_57300 n1_M2_17340_57300 0.988200
R7224 n1_M2_17340_57300 n1_M2_18420_57300 0.988200
R7225 n1_M2_18420_57300 n1_M2_19500_57300 0.988200
R7226 n1_M2_19500_57300 n1_M2_20580_57300 0.988200
R7227 n1_M2_20580_57300 n1_M2_21660_57300 0.988200
R7228 n1_M2_21660_57300 n1_M2_22740_57300 0.988200
R7229 n1_M2_22740_57300 n1_M2_23820_57300 0.988200
R7230 n1_M2_23820_57300 n1_M2_24900_57300 0.988200
R7231 n1_M2_24900_57300 n1_M2_25980_57300 0.988200
R7232 n1_M2_25980_57300 n1_M2_27060_57300 0.988200
R7233 n1_M2_27060_57300 n1_M2_28140_57300 0.988200
R7234 n1_M2_28140_57300 n1_M2_29220_57300 0.988200
R7235 n1_M2_29220_57300 n1_M2_30300_57300 0.988200
R7236 n1_M2_30300_57300 n1_M2_31380_57300 0.988200
R7237 n1_M2_31380_57300 n1_M2_32460_57300 0.988200
R7238 n1_M2_32460_57300 n1_M2_33540_57300 0.988200
R7239 n1_M2_33540_57300 n1_M2_34620_57300 0.988200
R7240 n1_M2_34620_57300 n1_M2_35700_57300 0.988200
R7241 n1_M2_35700_57300 n1_M2_36780_57300 0.988200
R7242 n1_M2_36780_57300 n1_M2_37860_57300 0.988200
R7243 n1_M2_37860_57300 n1_M2_38940_57300 0.988200
R7244 n1_M2_38940_57300 n1_M2_40020_57300 0.988200
R7245 n1_M2_40020_57300 n1_M2_41100_57300 0.988200
R7246 n1_M2_41100_57300 n1_M2_42180_57300 0.988200
R7247 n1_M2_42180_57300 n1_M2_43260_57300 0.988200
R7248 n1_M2_43260_57300 n1_M2_44340_57300 0.988200
R7249 n1_M2_44340_57300 n1_M2_45420_57300 0.988200
R7250 n1_M2_45420_57300 n1_M2_46500_57300 0.988200
R7251 n1_M2_46500_57300 n1_M2_47580_57300 0.988200
R7252 n1_M2_47580_57300 n1_M2_48660_57300 0.988200
R7253 n1_M2_48660_57300 n1_M2_49740_57300 0.988200
R7254 n1_M2_49740_57300 n1_M2_50820_57300 0.988200
R7255 n1_M2_50820_57300 n1_M2_51900_57300 0.988200
R7256 n1_M2_51900_57300 n1_M2_52980_57300 0.988200
R7257 n1_M2_52980_57300 n1_M2_54060_57300 0.988200
R7258 n1_M2_54060_57300 n1_M2_55140_57300 0.988200
R7259 n1_M2_55140_57300 n1_M2_56220_57300 0.988200
R7260 n1_M2_56220_57300 n1_M2_57300_57300 0.988200
R7261 n1_M2_57300_57300 n1_M2_58380_57300 0.988200
R7262 n1_M2_58380_57300 n1_M2_59460_57300 0.988200
R7263 n1_M2_59460_57300 n1_M2_60540_57300 0.988200
R7264 n1_M2_60540_57300 n1_M2_61620_57300 0.988200
R7265 n1_M2_61620_57300 n1_M2_62700_57300 0.988200
R7266 n1_M2_62700_57300 n1_M2_63780_57300 0.988200
R7267 n1_M2_63780_57300 n1_M2_64860_57300 0.988200
R7268 n1_M2_64860_57300 n1_M2_65940_57300 0.988200
R7269 n1_M2_65940_57300 n1_M2_67020_57300 0.988200
R7270 n1_M2_67020_57300 n1_M2_68100_57300 0.988200
R7271 n1_M2_68100_57300 n1_M2_69180_57300 0.988200
R7272 n1_M2_69180_57300 n1_M2_70260_57300 0.988200
R7273 n1_M2_70260_57300 n1_M2_71340_57300 0.988200
R7274 n1_M2_71340_57300 n1_M2_72420_57300 0.988200
R7275 n1_M2_72420_57300 n1_M2_73500_57300 0.988200
R7276 n1_M2_73500_57300 n1_M2_74580_57300 0.988200
R7277 n1_M2_74580_57300 n1_M2_75660_57300 0.988200
R7278 n1_M2_75660_57300 n1_M2_76740_57300 0.988200
R7279 n1_M2_76740_57300 n1_M2_77820_57300 0.988200
R7280 n1_M2_77820_57300 n1_M2_78900_57300 0.988200
R7281 n1_M2_78900_57300 n1_M2_79980_57300 0.988200
R7282 n1_M2_79980_57300 n1_M2_81060_57300 0.988200
R7283 n1_M2_81060_57300 n1_M2_82140_57300 0.988200
R7284 n1_M2_82140_57300 n1_M2_83220_57300 0.988200
R7285 n1_M2_83220_57300 n1_M2_84300_57300 0.988200
R7286 n1_M2_84300_57300 n1_M2_85380_57300 0.988200
R7287 n1_M2_85380_57300 n1_M2_86460_57300 0.988200
R7288 n1_M2_86460_57300 n1_M2_87540_57300 0.988200
R7289 n1_M2_87540_57300 n1_M2_88620_57300 0.988200
R7290 n1_M2_88620_57300 n1_M2_89700_57300 0.988200
R7291 n1_M2_89700_57300 n1_M2_90780_57300 0.988200
R7292 n1_M2_90780_57300 n1_M2_91860_57300 0.988200
R7293 n1_M2_91860_57300 n1_M2_92940_57300 0.988200
R7294 n1_M2_92940_57300 n1_M2_94020_57300 0.988200
R7295 n1_M2_94020_57300 n1_M2_95100_57300 0.988200
R7296 n1_M2_95100_57300 n1_M2_96180_57300 0.988200
R7297 n1_M2_96180_57300 n1_M2_97260_57300 0.988200
R7298 n1_M2_97260_57300 n1_M2_98340_57300 0.988200
R7299 n1_M2_98340_57300 n1_M2_99420_57300 0.988200
R7300 n1_M2_99420_57300 n1_M2_100500_57300 0.988200
R7301 n1_M2_100500_57300 n1_M2_101580_57300 0.988200
R7302 n1_M2_101580_57300 n1_M2_102660_57300 0.988200
R7303 n1_M2_102660_57300 n1_M2_103740_57300 0.988200
R7304 n1_M2_103740_57300 n1_M2_104820_57300 0.988200
R7305 n1_M2_104820_57300 n1_M2_105900_57300 0.988200
R7306 n1_M2_105900_57300 n1_M2_106980_57300 0.988200
R7307 n1_M2_106980_57300 n1_M2_108060_57300 0.988200
R7308 n1_M2_108060_57300 n1_M2_109140_57300 0.988200
R7309 n1_M2_109140_57300 n1_M2_110220_57300 0.988200
R7310 n1_M2_110220_57300 n1_M2_111300_57300 0.988200
R7311 n1_M2_111300_57300 n1_M2_112380_57300 0.988200
R7312 n1_M2_112380_57300 n1_M2_113460_57300 0.988200
R7313 n1_M2_113460_57300 n1_M2_114540_57300 0.988200
R7314 n1_M2_114540_57300 n1_M2_115620_57300 0.988200
R7315 n1_M2_115620_57300 n1_M2_116700_57300 0.988200
R7316 n1_M2_116700_57300 n1_M2_117780_57300 0.988200
R7317 n1_M2_117780_57300 n1_M2_118860_57300 0.988200
R7318 n1_M2_118860_57300 n1_M2_119940_57300 0.988200
R7319 n1_M2_119940_57300 n1_M2_121020_57300 0.988200
R7320 n1_M2_121020_57300 n1_M2_122100_57300 0.988200
R7321 n1_M2_122100_57300 n1_M2_123180_57300 0.988200
R7322 n1_M2_123180_57300 n1_M2_124260_57300 0.988200
R7323 n1_M2_124260_57300 n1_M2_125340_57300 0.988200
R7324 n1_M2_125340_57300 n1_M2_126420_57300 0.988200
R7325 n1_M2_126420_57300 n1_M2_127500_57300 0.988200
R7326 n1_M2_127500_57300 n1_M2_128580_57300 0.988200
R7327 n1_M2_128580_57300 n1_M2_129660_57300 0.988200
R7328 n1_M2_129660_57300 n1_M2_130740_57300 0.988200
R7329 n1_M2_130740_57300 n1_M2_131820_57300 0.988200
R7330 n1_M2_131820_57300 n1_M2_132900_57300 0.988200
R7331 n1_M2_132900_57300 n1_M2_133980_57300 0.988200
R7332 n1_M2_133980_57300 n1_M2_135060_57300 0.988200
R7333 n1_M2_135060_57300 n1_M2_136140_57300 0.988200
R7334 n1_M2_136140_57300 n1_M2_137220_57300 0.988200
R7335 n1_M2_137220_57300 n1_M2_138300_57300 0.988200
R7336 n1_M2_138300_57300 n1_M2_139380_57300 0.988200
R7337 n1_M2_139380_57300 n1_M2_140460_57300 0.988200
R7338 n1_M2_140460_57300 n1_M2_141540_57300 0.988200
R7339 n1_M2_141540_57300 n1_M2_142620_57300 0.988200
R7340 n1_M2_142620_57300 n1_M2_143700_57300 0.988200
R7341 n1_M2_143700_57300 n1_M2_144780_57300 0.988200
R7342 n1_M2_144780_57300 n1_M2_145860_57300 0.988200
R7343 n1_M2_145860_57300 n1_M2_146940_57300 0.988200
R7344 n1_M2_60_58380 n1_M2_1140_58380 0.988200
R7345 n1_M2_1140_58380 n1_M2_2220_58380 0.988200
R7346 n1_M2_2220_58380 n1_M2_3300_58380 0.988200
R7347 n1_M2_3300_58380 n1_M2_4380_58380 0.988200
R7348 n1_M2_4380_58380 n1_M2_5460_58380 0.988200
R7349 n1_M2_5460_58380 n1_M2_6540_58380 0.988200
R7350 n1_M2_6540_58380 n1_M2_7620_58380 0.988200
R7351 n1_M2_7620_58380 n1_M2_8700_58380 0.988200
R7352 n1_M2_8700_58380 n1_M2_9780_58380 0.988200
R7353 n1_M2_9780_58380 n1_M2_10860_58380 0.988200
R7354 n1_M2_10860_58380 n1_M2_11940_58380 0.988200
R7355 n1_M2_11940_58380 n1_M2_13020_58380 0.988200
R7356 n1_M2_13020_58380 n1_M2_14100_58380 0.988200
R7357 n1_M2_14100_58380 n1_M2_15180_58380 0.988200
R7358 n1_M2_15180_58380 n1_M2_16260_58380 0.988200
R7359 n1_M2_16260_58380 n1_M2_17340_58380 0.988200
R7360 n1_M2_17340_58380 n1_M2_18420_58380 0.988200
R7361 n1_M2_18420_58380 n1_M2_19500_58380 0.988200
R7362 n1_M2_19500_58380 n1_M2_20580_58380 0.988200
R7363 n1_M2_20580_58380 n1_M2_21660_58380 0.988200
R7364 n1_M2_21660_58380 n1_M2_22740_58380 0.988200
R7365 n1_M2_22740_58380 n1_M2_23820_58380 0.988200
R7366 n1_M2_23820_58380 n1_M2_24900_58380 0.988200
R7367 n1_M2_24900_58380 n1_M2_25980_58380 0.988200
R7368 n1_M2_25980_58380 n1_M2_27060_58380 0.988200
R7369 n1_M2_27060_58380 n1_M2_28140_58380 0.988200
R7370 n1_M2_28140_58380 n1_M2_29220_58380 0.988200
R7371 n1_M2_29220_58380 n1_M2_30300_58380 0.988200
R7372 n1_M2_30300_58380 n1_M2_31380_58380 0.988200
R7373 n1_M2_31380_58380 n1_M2_32460_58380 0.988200
R7374 n1_M2_32460_58380 n1_M2_33540_58380 0.988200
R7375 n1_M2_33540_58380 n1_M2_34620_58380 0.988200
R7376 n1_M2_34620_58380 n1_M2_35700_58380 0.988200
R7377 n1_M2_35700_58380 n1_M2_36780_58380 0.988200
R7378 n1_M2_36780_58380 n1_M2_37860_58380 0.988200
R7379 n1_M2_37860_58380 n1_M2_38940_58380 0.988200
R7380 n1_M2_38940_58380 n1_M2_40020_58380 0.988200
R7381 n1_M2_40020_58380 n1_M2_41100_58380 0.988200
R7382 n1_M2_41100_58380 n1_M2_42180_58380 0.988200
R7383 n1_M2_42180_58380 n1_M2_43260_58380 0.988200
R7384 n1_M2_43260_58380 n1_M2_44340_58380 0.988200
R7385 n1_M2_44340_58380 n1_M2_45420_58380 0.988200
R7386 n1_M2_45420_58380 n1_M2_46500_58380 0.988200
R7387 n1_M2_46500_58380 n1_M2_47580_58380 0.988200
R7388 n1_M2_47580_58380 n1_M2_48660_58380 0.988200
R7389 n1_M2_48660_58380 n1_M2_49740_58380 0.988200
R7390 n1_M2_49740_58380 n1_M2_50820_58380 0.988200
R7391 n1_M2_50820_58380 n1_M2_51900_58380 0.988200
R7392 n1_M2_51900_58380 n1_M2_52980_58380 0.988200
R7393 n1_M2_52980_58380 n1_M2_54060_58380 0.988200
R7394 n1_M2_54060_58380 n1_M2_55140_58380 0.988200
R7395 n1_M2_55140_58380 n1_M2_56220_58380 0.988200
R7396 n1_M2_56220_58380 n1_M2_57300_58380 0.988200
R7397 n1_M2_57300_58380 n1_M2_58380_58380 0.988200
R7398 n1_M2_58380_58380 n1_M2_59460_58380 0.988200
R7399 n1_M2_59460_58380 n1_M2_60540_58380 0.988200
R7400 n1_M2_60540_58380 n1_M2_61620_58380 0.988200
R7401 n1_M2_61620_58380 n1_M2_62700_58380 0.988200
R7402 n1_M2_62700_58380 n1_M2_63780_58380 0.988200
R7403 n1_M2_63780_58380 n1_M2_64860_58380 0.988200
R7404 n1_M2_64860_58380 n1_M2_65940_58380 0.988200
R7405 n1_M2_65940_58380 n1_M2_67020_58380 0.988200
R7406 n1_M2_67020_58380 n1_M2_68100_58380 0.988200
R7407 n1_M2_68100_58380 n1_M2_69180_58380 0.988200
R7408 n1_M2_69180_58380 n1_M2_70260_58380 0.988200
R7409 n1_M2_70260_58380 n1_M2_71340_58380 0.988200
R7410 n1_M2_71340_58380 n1_M2_72420_58380 0.988200
R7411 n1_M2_72420_58380 n1_M2_73500_58380 0.988200
R7412 n1_M2_73500_58380 n1_M2_74580_58380 0.988200
R7413 n1_M2_74580_58380 n1_M2_75660_58380 0.988200
R7414 n1_M2_75660_58380 n1_M2_76740_58380 0.988200
R7415 n1_M2_76740_58380 n1_M2_77820_58380 0.988200
R7416 n1_M2_77820_58380 n1_M2_78900_58380 0.988200
R7417 n1_M2_78900_58380 n1_M2_79980_58380 0.988200
R7418 n1_M2_79980_58380 n1_M2_81060_58380 0.988200
R7419 n1_M2_81060_58380 n1_M2_82140_58380 0.988200
R7420 n1_M2_82140_58380 n1_M2_83220_58380 0.988200
R7421 n1_M2_83220_58380 n1_M2_84300_58380 0.988200
R7422 n1_M2_84300_58380 n1_M2_85380_58380 0.988200
R7423 n1_M2_85380_58380 n1_M2_86460_58380 0.988200
R7424 n1_M2_86460_58380 n1_M2_87540_58380 0.988200
R7425 n1_M2_87540_58380 n1_M2_88620_58380 0.988200
R7426 n1_M2_88620_58380 n1_M2_89700_58380 0.988200
R7427 n1_M2_89700_58380 n1_M2_90780_58380 0.988200
R7428 n1_M2_90780_58380 n1_M2_91860_58380 0.988200
R7429 n1_M2_91860_58380 n1_M2_92940_58380 0.988200
R7430 n1_M2_92940_58380 n1_M2_94020_58380 0.988200
R7431 n1_M2_94020_58380 n1_M2_95100_58380 0.988200
R7432 n1_M2_95100_58380 n1_M2_96180_58380 0.988200
R7433 n1_M2_96180_58380 n1_M2_97260_58380 0.988200
R7434 n1_M2_97260_58380 n1_M2_98340_58380 0.988200
R7435 n1_M2_98340_58380 n1_M2_99420_58380 0.988200
R7436 n1_M2_99420_58380 n1_M2_100500_58380 0.988200
R7437 n1_M2_100500_58380 n1_M2_101580_58380 0.988200
R7438 n1_M2_101580_58380 n1_M2_102660_58380 0.988200
R7439 n1_M2_102660_58380 n1_M2_103740_58380 0.988200
R7440 n1_M2_103740_58380 n1_M2_104820_58380 0.988200
R7441 n1_M2_104820_58380 n1_M2_105900_58380 0.988200
R7442 n1_M2_105900_58380 n1_M2_106980_58380 0.988200
R7443 n1_M2_106980_58380 n1_M2_108060_58380 0.988200
R7444 n1_M2_108060_58380 n1_M2_109140_58380 0.988200
R7445 n1_M2_109140_58380 n1_M2_110220_58380 0.988200
R7446 n1_M2_110220_58380 n1_M2_111300_58380 0.988200
R7447 n1_M2_111300_58380 n1_M2_112380_58380 0.988200
R7448 n1_M2_112380_58380 n1_M2_113460_58380 0.988200
R7449 n1_M2_113460_58380 n1_M2_114540_58380 0.988200
R7450 n1_M2_114540_58380 n1_M2_115620_58380 0.988200
R7451 n1_M2_115620_58380 n1_M2_116700_58380 0.988200
R7452 n1_M2_116700_58380 n1_M2_117780_58380 0.988200
R7453 n1_M2_117780_58380 n1_M2_118860_58380 0.988200
R7454 n1_M2_118860_58380 n1_M2_119940_58380 0.988200
R7455 n1_M2_119940_58380 n1_M2_121020_58380 0.988200
R7456 n1_M2_121020_58380 n1_M2_122100_58380 0.988200
R7457 n1_M2_122100_58380 n1_M2_123180_58380 0.988200
R7458 n1_M2_123180_58380 n1_M2_124260_58380 0.988200
R7459 n1_M2_124260_58380 n1_M2_125340_58380 0.988200
R7460 n1_M2_125340_58380 n1_M2_126420_58380 0.988200
R7461 n1_M2_126420_58380 n1_M2_127500_58380 0.988200
R7462 n1_M2_127500_58380 n1_M2_128580_58380 0.988200
R7463 n1_M2_128580_58380 n1_M2_129660_58380 0.988200
R7464 n1_M2_129660_58380 n1_M2_130740_58380 0.988200
R7465 n1_M2_130740_58380 n1_M2_131820_58380 0.988200
R7466 n1_M2_131820_58380 n1_M2_132900_58380 0.988200
R7467 n1_M2_132900_58380 n1_M2_133980_58380 0.988200
R7468 n1_M2_133980_58380 n1_M2_135060_58380 0.988200
R7469 n1_M2_135060_58380 n1_M2_136140_58380 0.988200
R7470 n1_M2_136140_58380 n1_M2_137220_58380 0.988200
R7471 n1_M2_137220_58380 n1_M2_138300_58380 0.988200
R7472 n1_M2_138300_58380 n1_M2_139380_58380 0.988200
R7473 n1_M2_139380_58380 n1_M2_140460_58380 0.988200
R7474 n1_M2_140460_58380 n1_M2_141540_58380 0.988200
R7475 n1_M2_141540_58380 n1_M2_142620_58380 0.988200
R7476 n1_M2_142620_58380 n1_M2_143700_58380 0.988200
R7477 n1_M2_143700_58380 n1_M2_144780_58380 0.988200
R7478 n1_M2_144780_58380 n1_M2_145860_58380 0.988200
R7479 n1_M2_145860_58380 n1_M2_146940_58380 0.988200
R7480 n1_M2_60_59460 n1_M2_1140_59460 0.988200
R7481 n1_M2_1140_59460 n1_M2_2220_59460 0.988200
R7482 n1_M2_2220_59460 n1_M2_3300_59460 0.988200
R7483 n1_M2_3300_59460 n1_M2_4380_59460 0.988200
R7484 n1_M2_4380_59460 n1_M2_5460_59460 0.988200
R7485 n1_M2_5460_59460 n1_M2_6540_59460 0.988200
R7486 n1_M2_6540_59460 n1_M2_7620_59460 0.988200
R7487 n1_M2_7620_59460 n1_M2_8700_59460 0.988200
R7488 n1_M2_8700_59460 n1_M2_9780_59460 0.988200
R7489 n1_M2_9780_59460 n1_M2_10860_59460 0.988200
R7490 n1_M2_10860_59460 n1_M2_11940_59460 0.988200
R7491 n1_M2_11940_59460 n1_M2_13020_59460 0.988200
R7492 n1_M2_13020_59460 n1_M2_14100_59460 0.988200
R7493 n1_M2_14100_59460 n1_M2_15180_59460 0.988200
R7494 n1_M2_15180_59460 n1_M2_16260_59460 0.988200
R7495 n1_M2_16260_59460 n1_M2_17340_59460 0.988200
R7496 n1_M2_17340_59460 n1_M2_18420_59460 0.988200
R7497 n1_M2_18420_59460 n1_M2_19500_59460 0.988200
R7498 n1_M2_19500_59460 n1_M2_20580_59460 0.988200
R7499 n1_M2_20580_59460 n1_M2_21660_59460 0.988200
R7500 n1_M2_21660_59460 n1_M2_22740_59460 0.988200
R7501 n1_M2_22740_59460 n1_M2_23820_59460 0.988200
R7502 n1_M2_23820_59460 n1_M2_24900_59460 0.988200
R7503 n1_M2_24900_59460 n1_M2_25980_59460 0.988200
R7504 n1_M2_25980_59460 n1_M2_27060_59460 0.988200
R7505 n1_M2_27060_59460 n1_M2_28140_59460 0.988200
R7506 n1_M2_28140_59460 n1_M2_29220_59460 0.988200
R7507 n1_M2_29220_59460 n1_M2_30300_59460 0.988200
R7508 n1_M2_30300_59460 n1_M2_31380_59460 0.988200
R7509 n1_M2_31380_59460 n1_M2_32460_59460 0.988200
R7510 n1_M2_32460_59460 n1_M2_33540_59460 0.988200
R7511 n1_M2_33540_59460 n1_M2_34620_59460 0.988200
R7512 n1_M2_34620_59460 n1_M2_35700_59460 0.988200
R7513 n1_M2_35700_59460 n1_M2_36780_59460 0.988200
R7514 n1_M2_36780_59460 n1_M2_37860_59460 0.988200
R7515 n1_M2_37860_59460 n1_M2_38940_59460 0.988200
R7516 n1_M2_38940_59460 n1_M2_40020_59460 0.988200
R7517 n1_M2_40020_59460 n1_M2_41100_59460 0.988200
R7518 n1_M2_41100_59460 n1_M2_42180_59460 0.988200
R7519 n1_M2_42180_59460 n1_M2_43260_59460 0.988200
R7520 n1_M2_43260_59460 n1_M2_44340_59460 0.988200
R7521 n1_M2_44340_59460 n1_M2_45420_59460 0.988200
R7522 n1_M2_45420_59460 n1_M2_46500_59460 0.988200
R7523 n1_M2_46500_59460 n1_M2_47580_59460 0.988200
R7524 n1_M2_47580_59460 n1_M2_48660_59460 0.988200
R7525 n1_M2_48660_59460 n1_M2_49740_59460 0.988200
R7526 n1_M2_49740_59460 n1_M2_50820_59460 0.988200
R7527 n1_M2_50820_59460 n1_M2_51900_59460 0.988200
R7528 n1_M2_51900_59460 n1_M2_52980_59460 0.988200
R7529 n1_M2_52980_59460 n1_M2_54060_59460 0.988200
R7530 n1_M2_54060_59460 n1_M2_55140_59460 0.988200
R7531 n1_M2_55140_59460 n1_M2_56220_59460 0.988200
R7532 n1_M2_56220_59460 n1_M2_57300_59460 0.988200
R7533 n1_M2_57300_59460 n1_M2_58380_59460 0.988200
R7534 n1_M2_58380_59460 n1_M2_59460_59460 0.988200
R7535 n1_M2_59460_59460 n1_M2_60540_59460 0.988200
R7536 n1_M2_60540_59460 n1_M2_61620_59460 0.988200
R7537 n1_M2_61620_59460 n1_M2_62700_59460 0.988200
R7538 n1_M2_62700_59460 n1_M2_63780_59460 0.988200
R7539 n1_M2_63780_59460 n1_M2_64860_59460 0.988200
R7540 n1_M2_64860_59460 n1_M2_65940_59460 0.988200
R7541 n1_M2_65940_59460 n1_M2_67020_59460 0.988200
R7542 n1_M2_67020_59460 n1_M2_68100_59460 0.988200
R7543 n1_M2_68100_59460 n1_M2_69180_59460 0.988200
R7544 n1_M2_69180_59460 n1_M2_70260_59460 0.988200
R7545 n1_M2_70260_59460 n1_M2_71340_59460 0.988200
R7546 n1_M2_71340_59460 n1_M2_72420_59460 0.988200
R7547 n1_M2_72420_59460 n1_M2_73500_59460 0.988200
R7548 n1_M2_73500_59460 n1_M2_74580_59460 0.988200
R7549 n1_M2_74580_59460 n1_M2_75660_59460 0.988200
R7550 n1_M2_75660_59460 n1_M2_76740_59460 0.988200
R7551 n1_M2_76740_59460 n1_M2_77820_59460 0.988200
R7552 n1_M2_77820_59460 n1_M2_78900_59460 0.988200
R7553 n1_M2_78900_59460 n1_M2_79980_59460 0.988200
R7554 n1_M2_79980_59460 n1_M2_81060_59460 0.988200
R7555 n1_M2_81060_59460 n1_M2_82140_59460 0.988200
R7556 n1_M2_82140_59460 n1_M2_83220_59460 0.988200
R7557 n1_M2_83220_59460 n1_M2_84300_59460 0.988200
R7558 n1_M2_84300_59460 n1_M2_85380_59460 0.988200
R7559 n1_M2_85380_59460 n1_M2_86460_59460 0.988200
R7560 n1_M2_86460_59460 n1_M2_87540_59460 0.988200
R7561 n1_M2_87540_59460 n1_M2_88620_59460 0.988200
R7562 n1_M2_88620_59460 n1_M2_89700_59460 0.988200
R7563 n1_M2_89700_59460 n1_M2_90780_59460 0.988200
R7564 n1_M2_90780_59460 n1_M2_91860_59460 0.988200
R7565 n1_M2_91860_59460 n1_M2_92940_59460 0.988200
R7566 n1_M2_92940_59460 n1_M2_94020_59460 0.988200
R7567 n1_M2_94020_59460 n1_M2_95100_59460 0.988200
R7568 n1_M2_95100_59460 n1_M2_96180_59460 0.988200
R7569 n1_M2_96180_59460 n1_M2_97260_59460 0.988200
R7570 n1_M2_97260_59460 n1_M2_98340_59460 0.988200
R7571 n1_M2_98340_59460 n1_M2_99420_59460 0.988200
R7572 n1_M2_99420_59460 n1_M2_100500_59460 0.988200
R7573 n1_M2_100500_59460 n1_M2_101580_59460 0.988200
R7574 n1_M2_101580_59460 n1_M2_102660_59460 0.988200
R7575 n1_M2_102660_59460 n1_M2_103740_59460 0.988200
R7576 n1_M2_103740_59460 n1_M2_104820_59460 0.988200
R7577 n1_M2_104820_59460 n1_M2_105900_59460 0.988200
R7578 n1_M2_105900_59460 n1_M2_106980_59460 0.988200
R7579 n1_M2_106980_59460 n1_M2_108060_59460 0.988200
R7580 n1_M2_108060_59460 n1_M2_109140_59460 0.988200
R7581 n1_M2_109140_59460 n1_M2_110220_59460 0.988200
R7582 n1_M2_110220_59460 n1_M2_111300_59460 0.988200
R7583 n1_M2_111300_59460 n1_M2_112380_59460 0.988200
R7584 n1_M2_112380_59460 n1_M2_113460_59460 0.988200
R7585 n1_M2_113460_59460 n1_M2_114540_59460 0.988200
R7586 n1_M2_114540_59460 n1_M2_115620_59460 0.988200
R7587 n1_M2_115620_59460 n1_M2_116700_59460 0.988200
R7588 n1_M2_116700_59460 n1_M2_117780_59460 0.988200
R7589 n1_M2_117780_59460 n1_M2_118860_59460 0.988200
R7590 n1_M2_118860_59460 n1_M2_119940_59460 0.988200
R7591 n1_M2_119940_59460 n1_M2_121020_59460 0.988200
R7592 n1_M2_121020_59460 n1_M2_122100_59460 0.988200
R7593 n1_M2_122100_59460 n1_M2_123180_59460 0.988200
R7594 n1_M2_123180_59460 n1_M2_124260_59460 0.988200
R7595 n1_M2_124260_59460 n1_M2_125340_59460 0.988200
R7596 n1_M2_125340_59460 n1_M2_126420_59460 0.988200
R7597 n1_M2_126420_59460 n1_M2_127500_59460 0.988200
R7598 n1_M2_127500_59460 n1_M2_128580_59460 0.988200
R7599 n1_M2_128580_59460 n1_M2_129660_59460 0.988200
R7600 n1_M2_129660_59460 n1_M2_130740_59460 0.988200
R7601 n1_M2_130740_59460 n1_M2_131820_59460 0.988200
R7602 n1_M2_131820_59460 n1_M2_132900_59460 0.988200
R7603 n1_M2_132900_59460 n1_M2_133980_59460 0.988200
R7604 n1_M2_133980_59460 n1_M2_135060_59460 0.988200
R7605 n1_M2_135060_59460 n1_M2_136140_59460 0.988200
R7606 n1_M2_136140_59460 n1_M2_137220_59460 0.988200
R7607 n1_M2_137220_59460 n1_M2_138300_59460 0.988200
R7608 n1_M2_138300_59460 n1_M2_139380_59460 0.988200
R7609 n1_M2_139380_59460 n1_M2_140460_59460 0.988200
R7610 n1_M2_140460_59460 n1_M2_141540_59460 0.988200
R7611 n1_M2_141540_59460 n1_M2_142620_59460 0.988200
R7612 n1_M2_142620_59460 n1_M2_143700_59460 0.988200
R7613 n1_M2_143700_59460 n1_M2_144780_59460 0.988200
R7614 n1_M2_144780_59460 n1_M2_145860_59460 0.988200
R7615 n1_M2_145860_59460 n1_M2_146940_59460 0.988200
R7616 n1_M2_60_60540 n1_M2_1140_60540 0.988200
R7617 n1_M2_1140_60540 n1_M2_2220_60540 0.988200
R7618 n1_M2_2220_60540 n1_M2_3300_60540 0.988200
R7619 n1_M2_3300_60540 n1_M2_4380_60540 0.988200
R7620 n1_M2_4380_60540 n1_M2_5460_60540 0.988200
R7621 n1_M2_5460_60540 n1_M2_6540_60540 0.988200
R7622 n1_M2_6540_60540 n1_M2_7620_60540 0.988200
R7623 n1_M2_7620_60540 n1_M2_8700_60540 0.988200
R7624 n1_M2_8700_60540 n1_M2_9780_60540 0.988200
R7625 n1_M2_9780_60540 n1_M2_10860_60540 0.988200
R7626 n1_M2_10860_60540 n1_M2_11940_60540 0.988200
R7627 n1_M2_11940_60540 n1_M2_13020_60540 0.988200
R7628 n1_M2_13020_60540 n1_M2_14100_60540 0.988200
R7629 n1_M2_14100_60540 n1_M2_15180_60540 0.988200
R7630 n1_M2_15180_60540 n1_M2_16260_60540 0.988200
R7631 n1_M2_16260_60540 n1_M2_17340_60540 0.988200
R7632 n1_M2_17340_60540 n1_M2_18420_60540 0.988200
R7633 n1_M2_18420_60540 n1_M2_19500_60540 0.988200
R7634 n1_M2_19500_60540 n1_M2_20580_60540 0.988200
R7635 n1_M2_20580_60540 n1_M2_21660_60540 0.988200
R7636 n1_M2_21660_60540 n1_M2_22740_60540 0.988200
R7637 n1_M2_22740_60540 n1_M2_23820_60540 0.988200
R7638 n1_M2_23820_60540 n1_M2_24900_60540 0.988200
R7639 n1_M2_24900_60540 n1_M2_25980_60540 0.988200
R7640 n1_M2_25980_60540 n1_M2_27060_60540 0.988200
R7641 n1_M2_27060_60540 n1_M2_28140_60540 0.988200
R7642 n1_M2_28140_60540 n1_M2_29220_60540 0.988200
R7643 n1_M2_29220_60540 n1_M2_30300_60540 0.988200
R7644 n1_M2_30300_60540 n1_M2_31380_60540 0.988200
R7645 n1_M2_31380_60540 n1_M2_32460_60540 0.988200
R7646 n1_M2_32460_60540 n1_M2_33540_60540 0.988200
R7647 n1_M2_33540_60540 n1_M2_34620_60540 0.988200
R7648 n1_M2_34620_60540 n1_M2_35700_60540 0.988200
R7649 n1_M2_35700_60540 n1_M2_36780_60540 0.988200
R7650 n1_M2_36780_60540 n1_M2_37860_60540 0.988200
R7651 n1_M2_37860_60540 n1_M2_38940_60540 0.988200
R7652 n1_M2_38940_60540 n1_M2_40020_60540 0.988200
R7653 n1_M2_40020_60540 n1_M2_41100_60540 0.988200
R7654 n1_M2_41100_60540 n1_M2_42180_60540 0.988200
R7655 n1_M2_42180_60540 n1_M2_43260_60540 0.988200
R7656 n1_M2_43260_60540 n1_M2_44340_60540 0.988200
R7657 n1_M2_44340_60540 n1_M2_45420_60540 0.988200
R7658 n1_M2_45420_60540 n1_M2_46500_60540 0.988200
R7659 n1_M2_46500_60540 n1_M2_47580_60540 0.988200
R7660 n1_M2_47580_60540 n1_M2_48660_60540 0.988200
R7661 n1_M2_48660_60540 n1_M2_49740_60540 0.988200
R7662 n1_M2_49740_60540 n1_M2_50820_60540 0.988200
R7663 n1_M2_50820_60540 n1_M2_51900_60540 0.988200
R7664 n1_M2_51900_60540 n1_M2_52980_60540 0.988200
R7665 n1_M2_52980_60540 n1_M2_54060_60540 0.988200
R7666 n1_M2_54060_60540 n1_M2_55140_60540 0.988200
R7667 n1_M2_55140_60540 n1_M2_56220_60540 0.988200
R7668 n1_M2_56220_60540 n1_M2_57300_60540 0.988200
R7669 n1_M2_57300_60540 n1_M2_58380_60540 0.988200
R7670 n1_M2_58380_60540 n1_M2_59460_60540 0.988200
R7671 n1_M2_59460_60540 n1_M2_60540_60540 0.988200
R7672 n1_M2_60540_60540 n1_M2_61620_60540 0.988200
R7673 n1_M2_61620_60540 n1_M2_62700_60540 0.988200
R7674 n1_M2_62700_60540 n1_M2_63780_60540 0.988200
R7675 n1_M2_63780_60540 n1_M2_64860_60540 0.988200
R7676 n1_M2_64860_60540 n1_M2_65940_60540 0.988200
R7677 n1_M2_65940_60540 n1_M2_67020_60540 0.988200
R7678 n1_M2_67020_60540 n1_M2_68100_60540 0.988200
R7679 n1_M2_68100_60540 n1_M2_69180_60540 0.988200
R7680 n1_M2_69180_60540 n1_M2_70260_60540 0.988200
R7681 n1_M2_70260_60540 n1_M2_71340_60540 0.988200
R7682 n1_M2_71340_60540 n1_M2_72420_60540 0.988200
R7683 n1_M2_72420_60540 n1_M2_73500_60540 0.988200
R7684 n1_M2_73500_60540 n1_M2_74580_60540 0.988200
R7685 n1_M2_74580_60540 n1_M2_75660_60540 0.988200
R7686 n1_M2_75660_60540 n1_M2_76740_60540 0.988200
R7687 n1_M2_76740_60540 n1_M2_77820_60540 0.988200
R7688 n1_M2_77820_60540 n1_M2_78900_60540 0.988200
R7689 n1_M2_78900_60540 n1_M2_79980_60540 0.988200
R7690 n1_M2_79980_60540 n1_M2_81060_60540 0.988200
R7691 n1_M2_81060_60540 n1_M2_82140_60540 0.988200
R7692 n1_M2_82140_60540 n1_M2_83220_60540 0.988200
R7693 n1_M2_83220_60540 n1_M2_84300_60540 0.988200
R7694 n1_M2_84300_60540 n1_M2_85380_60540 0.988200
R7695 n1_M2_85380_60540 n1_M2_86460_60540 0.988200
R7696 n1_M2_86460_60540 n1_M2_87540_60540 0.988200
R7697 n1_M2_87540_60540 n1_M2_88620_60540 0.988200
R7698 n1_M2_88620_60540 n1_M2_89700_60540 0.988200
R7699 n1_M2_89700_60540 n1_M2_90780_60540 0.988200
R7700 n1_M2_90780_60540 n1_M2_91860_60540 0.988200
R7701 n1_M2_91860_60540 n1_M2_92940_60540 0.988200
R7702 n1_M2_92940_60540 n1_M2_94020_60540 0.988200
R7703 n1_M2_94020_60540 n1_M2_95100_60540 0.988200
R7704 n1_M2_95100_60540 n1_M2_96180_60540 0.988200
R7705 n1_M2_96180_60540 n1_M2_97260_60540 0.988200
R7706 n1_M2_97260_60540 n1_M2_98340_60540 0.988200
R7707 n1_M2_98340_60540 n1_M2_99420_60540 0.988200
R7708 n1_M2_99420_60540 n1_M2_100500_60540 0.988200
R7709 n1_M2_100500_60540 n1_M2_101580_60540 0.988200
R7710 n1_M2_101580_60540 n1_M2_102660_60540 0.988200
R7711 n1_M2_102660_60540 n1_M2_103740_60540 0.988200
R7712 n1_M2_103740_60540 n1_M2_104820_60540 0.988200
R7713 n1_M2_104820_60540 n1_M2_105900_60540 0.988200
R7714 n1_M2_105900_60540 n1_M2_106980_60540 0.988200
R7715 n1_M2_106980_60540 n1_M2_108060_60540 0.988200
R7716 n1_M2_108060_60540 n1_M2_109140_60540 0.988200
R7717 n1_M2_109140_60540 n1_M2_110220_60540 0.988200
R7718 n1_M2_110220_60540 n1_M2_111300_60540 0.988200
R7719 n1_M2_111300_60540 n1_M2_112380_60540 0.988200
R7720 n1_M2_112380_60540 n1_M2_113460_60540 0.988200
R7721 n1_M2_113460_60540 n1_M2_114540_60540 0.988200
R7722 n1_M2_114540_60540 n1_M2_115620_60540 0.988200
R7723 n1_M2_115620_60540 n1_M2_116700_60540 0.988200
R7724 n1_M2_116700_60540 n1_M2_117780_60540 0.988200
R7725 n1_M2_117780_60540 n1_M2_118860_60540 0.988200
R7726 n1_M2_118860_60540 n1_M2_119940_60540 0.988200
R7727 n1_M2_119940_60540 n1_M2_121020_60540 0.988200
R7728 n1_M2_121020_60540 n1_M2_122100_60540 0.988200
R7729 n1_M2_122100_60540 n1_M2_123180_60540 0.988200
R7730 n1_M2_123180_60540 n1_M2_124260_60540 0.988200
R7731 n1_M2_124260_60540 n1_M2_125340_60540 0.988200
R7732 n1_M2_125340_60540 n1_M2_126420_60540 0.988200
R7733 n1_M2_126420_60540 n1_M2_127500_60540 0.988200
R7734 n1_M2_127500_60540 n1_M2_128580_60540 0.988200
R7735 n1_M2_128580_60540 n1_M2_129660_60540 0.988200
R7736 n1_M2_129660_60540 n1_M2_130740_60540 0.988200
R7737 n1_M2_130740_60540 n1_M2_131820_60540 0.988200
R7738 n1_M2_131820_60540 n1_M2_132900_60540 0.988200
R7739 n1_M2_132900_60540 n1_M2_133980_60540 0.988200
R7740 n1_M2_133980_60540 n1_M2_135060_60540 0.988200
R7741 n1_M2_135060_60540 n1_M2_136140_60540 0.988200
R7742 n1_M2_136140_60540 n1_M2_137220_60540 0.988200
R7743 n1_M2_137220_60540 n1_M2_138300_60540 0.988200
R7744 n1_M2_138300_60540 n1_M2_139380_60540 0.988200
R7745 n1_M2_139380_60540 n1_M2_140460_60540 0.988200
R7746 n1_M2_140460_60540 n1_M2_141540_60540 0.988200
R7747 n1_M2_141540_60540 n1_M2_142620_60540 0.988200
R7748 n1_M2_142620_60540 n1_M2_143700_60540 0.988200
R7749 n1_M2_143700_60540 n1_M2_144780_60540 0.988200
R7750 n1_M2_144780_60540 n1_M2_145860_60540 0.988200
R7751 n1_M2_145860_60540 n1_M2_146940_60540 0.988200
R7752 n1_M2_60_61620 n1_M2_1140_61620 0.988200
R7753 n1_M2_1140_61620 n1_M2_2220_61620 0.988200
R7754 n1_M2_2220_61620 n1_M2_3300_61620 0.988200
R7755 n1_M2_3300_61620 n1_M2_4380_61620 0.988200
R7756 n1_M2_4380_61620 n1_M2_5460_61620 0.988200
R7757 n1_M2_5460_61620 n1_M2_6540_61620 0.988200
R7758 n1_M2_6540_61620 n1_M2_7620_61620 0.988200
R7759 n1_M2_7620_61620 n1_M2_8700_61620 0.988200
R7760 n1_M2_8700_61620 n1_M2_9780_61620 0.988200
R7761 n1_M2_9780_61620 n1_M2_10860_61620 0.988200
R7762 n1_M2_10860_61620 n1_M2_11940_61620 0.988200
R7763 n1_M2_11940_61620 n1_M2_13020_61620 0.988200
R7764 n1_M2_13020_61620 n1_M2_14100_61620 0.988200
R7765 n1_M2_14100_61620 n1_M2_15180_61620 0.988200
R7766 n1_M2_15180_61620 n1_M2_16260_61620 0.988200
R7767 n1_M2_16260_61620 n1_M2_17340_61620 0.988200
R7768 n1_M2_17340_61620 n1_M2_18420_61620 0.988200
R7769 n1_M2_18420_61620 n1_M2_19500_61620 0.988200
R7770 n1_M2_19500_61620 n1_M2_20580_61620 0.988200
R7771 n1_M2_20580_61620 n1_M2_21660_61620 0.988200
R7772 n1_M2_21660_61620 n1_M2_22740_61620 0.988200
R7773 n1_M2_22740_61620 n1_M2_23820_61620 0.988200
R7774 n1_M2_23820_61620 n1_M2_24900_61620 0.988200
R7775 n1_M2_24900_61620 n1_M2_25980_61620 0.988200
R7776 n1_M2_25980_61620 n1_M2_27060_61620 0.988200
R7777 n1_M2_27060_61620 n1_M2_28140_61620 0.988200
R7778 n1_M2_28140_61620 n1_M2_29220_61620 0.988200
R7779 n1_M2_29220_61620 n1_M2_30300_61620 0.988200
R7780 n1_M2_30300_61620 n1_M2_31380_61620 0.988200
R7781 n1_M2_31380_61620 n1_M2_32460_61620 0.988200
R7782 n1_M2_32460_61620 n1_M2_33540_61620 0.988200
R7783 n1_M2_33540_61620 n1_M2_34620_61620 0.988200
R7784 n1_M2_34620_61620 n1_M2_35700_61620 0.988200
R7785 n1_M2_35700_61620 n1_M2_36780_61620 0.988200
R7786 n1_M2_36780_61620 n1_M2_37860_61620 0.988200
R7787 n1_M2_37860_61620 n1_M2_38940_61620 0.988200
R7788 n1_M2_38940_61620 n1_M2_40020_61620 0.988200
R7789 n1_M2_40020_61620 n1_M2_41100_61620 0.988200
R7790 n1_M2_41100_61620 n1_M2_42180_61620 0.988200
R7791 n1_M2_42180_61620 n1_M2_43260_61620 0.988200
R7792 n1_M2_43260_61620 n1_M2_44340_61620 0.988200
R7793 n1_M2_44340_61620 n1_M2_45420_61620 0.988200
R7794 n1_M2_45420_61620 n1_M2_46500_61620 0.988200
R7795 n1_M2_46500_61620 n1_M2_47580_61620 0.988200
R7796 n1_M2_47580_61620 n1_M2_48660_61620 0.988200
R7797 n1_M2_48660_61620 n1_M2_49740_61620 0.988200
R7798 n1_M2_49740_61620 n1_M2_50820_61620 0.988200
R7799 n1_M2_50820_61620 n1_M2_51900_61620 0.988200
R7800 n1_M2_51900_61620 n1_M2_52980_61620 0.988200
R7801 n1_M2_52980_61620 n1_M2_54060_61620 0.988200
R7802 n1_M2_54060_61620 n1_M2_55140_61620 0.988200
R7803 n1_M2_55140_61620 n1_M2_56220_61620 0.988200
R7804 n1_M2_56220_61620 n1_M2_57300_61620 0.988200
R7805 n1_M2_57300_61620 n1_M2_58380_61620 0.988200
R7806 n1_M2_58380_61620 n1_M2_59460_61620 0.988200
R7807 n1_M2_59460_61620 n1_M2_60540_61620 0.988200
R7808 n1_M2_60540_61620 n1_M2_61620_61620 0.988200
R7809 n1_M2_61620_61620 n1_M2_62700_61620 0.988200
R7810 n1_M2_62700_61620 n1_M2_63780_61620 0.988200
R7811 n1_M2_63780_61620 n1_M2_64860_61620 0.988200
R7812 n1_M2_64860_61620 n1_M2_65940_61620 0.988200
R7813 n1_M2_65940_61620 n1_M2_67020_61620 0.988200
R7814 n1_M2_67020_61620 n1_M2_68100_61620 0.988200
R7815 n1_M2_68100_61620 n1_M2_69180_61620 0.988200
R7816 n1_M2_69180_61620 n1_M2_70260_61620 0.988200
R7817 n1_M2_70260_61620 n1_M2_71340_61620 0.988200
R7818 n1_M2_71340_61620 n1_M2_72420_61620 0.988200
R7819 n1_M2_72420_61620 n1_M2_73500_61620 0.988200
R7820 n1_M2_73500_61620 n1_M2_74580_61620 0.988200
R7821 n1_M2_74580_61620 n1_M2_75660_61620 0.988200
R7822 n1_M2_75660_61620 n1_M2_76740_61620 0.988200
R7823 n1_M2_76740_61620 n1_M2_77820_61620 0.988200
R7824 n1_M2_77820_61620 n1_M2_78900_61620 0.988200
R7825 n1_M2_78900_61620 n1_M2_79980_61620 0.988200
R7826 n1_M2_79980_61620 n1_M2_81060_61620 0.988200
R7827 n1_M2_81060_61620 n1_M2_82140_61620 0.988200
R7828 n1_M2_82140_61620 n1_M2_83220_61620 0.988200
R7829 n1_M2_83220_61620 n1_M2_84300_61620 0.988200
R7830 n1_M2_84300_61620 n1_M2_85380_61620 0.988200
R7831 n1_M2_85380_61620 n1_M2_86460_61620 0.988200
R7832 n1_M2_86460_61620 n1_M2_87540_61620 0.988200
R7833 n1_M2_87540_61620 n1_M2_88620_61620 0.988200
R7834 n1_M2_88620_61620 n1_M2_89700_61620 0.988200
R7835 n1_M2_89700_61620 n1_M2_90780_61620 0.988200
R7836 n1_M2_90780_61620 n1_M2_91860_61620 0.988200
R7837 n1_M2_91860_61620 n1_M2_92940_61620 0.988200
R7838 n1_M2_92940_61620 n1_M2_94020_61620 0.988200
R7839 n1_M2_94020_61620 n1_M2_95100_61620 0.988200
R7840 n1_M2_95100_61620 n1_M2_96180_61620 0.988200
R7841 n1_M2_96180_61620 n1_M2_97260_61620 0.988200
R7842 n1_M2_97260_61620 n1_M2_98340_61620 0.988200
R7843 n1_M2_98340_61620 n1_M2_99420_61620 0.988200
R7844 n1_M2_99420_61620 n1_M2_100500_61620 0.988200
R7845 n1_M2_100500_61620 n1_M2_101580_61620 0.988200
R7846 n1_M2_101580_61620 n1_M2_102660_61620 0.988200
R7847 n1_M2_102660_61620 n1_M2_103740_61620 0.988200
R7848 n1_M2_103740_61620 n1_M2_104820_61620 0.988200
R7849 n1_M2_104820_61620 n1_M2_105900_61620 0.988200
R7850 n1_M2_105900_61620 n1_M2_106980_61620 0.988200
R7851 n1_M2_106980_61620 n1_M2_108060_61620 0.988200
R7852 n1_M2_108060_61620 n1_M2_109140_61620 0.988200
R7853 n1_M2_109140_61620 n1_M2_110220_61620 0.988200
R7854 n1_M2_110220_61620 n1_M2_111300_61620 0.988200
R7855 n1_M2_111300_61620 n1_M2_112380_61620 0.988200
R7856 n1_M2_112380_61620 n1_M2_113460_61620 0.988200
R7857 n1_M2_113460_61620 n1_M2_114540_61620 0.988200
R7858 n1_M2_114540_61620 n1_M2_115620_61620 0.988200
R7859 n1_M2_115620_61620 n1_M2_116700_61620 0.988200
R7860 n1_M2_116700_61620 n1_M2_117780_61620 0.988200
R7861 n1_M2_117780_61620 n1_M2_118860_61620 0.988200
R7862 n1_M2_118860_61620 n1_M2_119940_61620 0.988200
R7863 n1_M2_119940_61620 n1_M2_121020_61620 0.988200
R7864 n1_M2_121020_61620 n1_M2_122100_61620 0.988200
R7865 n1_M2_122100_61620 n1_M2_123180_61620 0.988200
R7866 n1_M2_123180_61620 n1_M2_124260_61620 0.988200
R7867 n1_M2_124260_61620 n1_M2_125340_61620 0.988200
R7868 n1_M2_125340_61620 n1_M2_126420_61620 0.988200
R7869 n1_M2_126420_61620 n1_M2_127500_61620 0.988200
R7870 n1_M2_127500_61620 n1_M2_128580_61620 0.988200
R7871 n1_M2_128580_61620 n1_M2_129660_61620 0.988200
R7872 n1_M2_129660_61620 n1_M2_130740_61620 0.988200
R7873 n1_M2_130740_61620 n1_M2_131820_61620 0.988200
R7874 n1_M2_131820_61620 n1_M2_132900_61620 0.988200
R7875 n1_M2_132900_61620 n1_M2_133980_61620 0.988200
R7876 n1_M2_133980_61620 n1_M2_135060_61620 0.988200
R7877 n1_M2_135060_61620 n1_M2_136140_61620 0.988200
R7878 n1_M2_136140_61620 n1_M2_137220_61620 0.988200
R7879 n1_M2_137220_61620 n1_M2_138300_61620 0.988200
R7880 n1_M2_138300_61620 n1_M2_139380_61620 0.988200
R7881 n1_M2_139380_61620 n1_M2_140460_61620 0.988200
R7882 n1_M2_140460_61620 n1_M2_141540_61620 0.988200
R7883 n1_M2_141540_61620 n1_M2_142620_61620 0.988200
R7884 n1_M2_142620_61620 n1_M2_143700_61620 0.988200
R7885 n1_M2_143700_61620 n1_M2_144780_61620 0.988200
R7886 n1_M2_144780_61620 n1_M2_145860_61620 0.988200
R7887 n1_M2_145860_61620 n1_M2_146940_61620 0.988200
R7888 n1_M2_60_62700 n1_M2_1140_62700 0.988200
R7889 n1_M2_1140_62700 n1_M2_2220_62700 0.988200
R7890 n1_M2_2220_62700 n1_M2_3300_62700 0.988200
R7891 n1_M2_3300_62700 n1_M2_4380_62700 0.988200
R7892 n1_M2_4380_62700 n1_M2_5460_62700 0.988200
R7893 n1_M2_5460_62700 n1_M2_6540_62700 0.988200
R7894 n1_M2_6540_62700 n1_M2_7620_62700 0.988200
R7895 n1_M2_7620_62700 n1_M2_8700_62700 0.988200
R7896 n1_M2_8700_62700 n1_M2_9780_62700 0.988200
R7897 n1_M2_9780_62700 n1_M2_10860_62700 0.988200
R7898 n1_M2_10860_62700 n1_M2_11940_62700 0.988200
R7899 n1_M2_11940_62700 n1_M2_13020_62700 0.988200
R7900 n1_M2_13020_62700 n1_M2_14100_62700 0.988200
R7901 n1_M2_14100_62700 n1_M2_15180_62700 0.988200
R7902 n1_M2_15180_62700 n1_M2_16260_62700 0.988200
R7903 n1_M2_16260_62700 n1_M2_17340_62700 0.988200
R7904 n1_M2_17340_62700 n1_M2_18420_62700 0.988200
R7905 n1_M2_18420_62700 n1_M2_19500_62700 0.988200
R7906 n1_M2_19500_62700 n1_M2_20580_62700 0.988200
R7907 n1_M2_20580_62700 n1_M2_21660_62700 0.988200
R7908 n1_M2_21660_62700 n1_M2_22740_62700 0.988200
R7909 n1_M2_22740_62700 n1_M2_23820_62700 0.988200
R7910 n1_M2_23820_62700 n1_M2_24900_62700 0.988200
R7911 n1_M2_24900_62700 n1_M2_25980_62700 0.988200
R7912 n1_M2_25980_62700 n1_M2_27060_62700 0.988200
R7913 n1_M2_27060_62700 n1_M2_28140_62700 0.988200
R7914 n1_M2_28140_62700 n1_M2_29220_62700 0.988200
R7915 n1_M2_29220_62700 n1_M2_30300_62700 0.988200
R7916 n1_M2_30300_62700 n1_M2_31380_62700 0.988200
R7917 n1_M2_31380_62700 n1_M2_32460_62700 0.988200
R7918 n1_M2_32460_62700 n1_M2_33540_62700 0.988200
R7919 n1_M2_33540_62700 n1_M2_34620_62700 0.988200
R7920 n1_M2_34620_62700 n1_M2_35700_62700 0.988200
R7921 n1_M2_35700_62700 n1_M2_36780_62700 0.988200
R7922 n1_M2_36780_62700 n1_M2_37860_62700 0.988200
R7923 n1_M2_37860_62700 n1_M2_38940_62700 0.988200
R7924 n1_M2_38940_62700 n1_M2_40020_62700 0.988200
R7925 n1_M2_40020_62700 n1_M2_41100_62700 0.988200
R7926 n1_M2_41100_62700 n1_M2_42180_62700 0.988200
R7927 n1_M2_42180_62700 n1_M2_43260_62700 0.988200
R7928 n1_M2_43260_62700 n1_M2_44340_62700 0.988200
R7929 n1_M2_44340_62700 n1_M2_45420_62700 0.988200
R7930 n1_M2_45420_62700 n1_M2_46500_62700 0.988200
R7931 n1_M2_46500_62700 n1_M2_47580_62700 0.988200
R7932 n1_M2_47580_62700 n1_M2_48660_62700 0.988200
R7933 n1_M2_48660_62700 n1_M2_49740_62700 0.988200
R7934 n1_M2_49740_62700 n1_M2_50820_62700 0.988200
R7935 n1_M2_50820_62700 n1_M2_51900_62700 0.988200
R7936 n1_M2_51900_62700 n1_M2_52980_62700 0.988200
R7937 n1_M2_52980_62700 n1_M2_54060_62700 0.988200
R7938 n1_M2_54060_62700 n1_M2_55140_62700 0.988200
R7939 n1_M2_55140_62700 n1_M2_56220_62700 0.988200
R7940 n1_M2_56220_62700 n1_M2_57300_62700 0.988200
R7941 n1_M2_57300_62700 n1_M2_58380_62700 0.988200
R7942 n1_M2_58380_62700 n1_M2_59460_62700 0.988200
R7943 n1_M2_59460_62700 n1_M2_60540_62700 0.988200
R7944 n1_M2_60540_62700 n1_M2_61620_62700 0.988200
R7945 n1_M2_61620_62700 n1_M2_62700_62700 0.988200
R7946 n1_M2_62700_62700 n1_M2_63780_62700 0.988200
R7947 n1_M2_63780_62700 n1_M2_64860_62700 0.988200
R7948 n1_M2_64860_62700 n1_M2_65940_62700 0.988200
R7949 n1_M2_65940_62700 n1_M2_67020_62700 0.988200
R7950 n1_M2_67020_62700 n1_M2_68100_62700 0.988200
R7951 n1_M2_68100_62700 n1_M2_69180_62700 0.988200
R7952 n1_M2_69180_62700 n1_M2_70260_62700 0.988200
R7953 n1_M2_70260_62700 n1_M2_71340_62700 0.988200
R7954 n1_M2_71340_62700 n1_M2_72420_62700 0.988200
R7955 n1_M2_72420_62700 n1_M2_73500_62700 0.988200
R7956 n1_M2_73500_62700 n1_M2_74580_62700 0.988200
R7957 n1_M2_74580_62700 n1_M2_75660_62700 0.988200
R7958 n1_M2_75660_62700 n1_M2_76740_62700 0.988200
R7959 n1_M2_76740_62700 n1_M2_77820_62700 0.988200
R7960 n1_M2_77820_62700 n1_M2_78900_62700 0.988200
R7961 n1_M2_78900_62700 n1_M2_79980_62700 0.988200
R7962 n1_M2_79980_62700 n1_M2_81060_62700 0.988200
R7963 n1_M2_81060_62700 n1_M2_82140_62700 0.988200
R7964 n1_M2_82140_62700 n1_M2_83220_62700 0.988200
R7965 n1_M2_83220_62700 n1_M2_84300_62700 0.988200
R7966 n1_M2_84300_62700 n1_M2_85380_62700 0.988200
R7967 n1_M2_85380_62700 n1_M2_86460_62700 0.988200
R7968 n1_M2_86460_62700 n1_M2_87540_62700 0.988200
R7969 n1_M2_87540_62700 n1_M2_88620_62700 0.988200
R7970 n1_M2_88620_62700 n1_M2_89700_62700 0.988200
R7971 n1_M2_89700_62700 n1_M2_90780_62700 0.988200
R7972 n1_M2_90780_62700 n1_M2_91860_62700 0.988200
R7973 n1_M2_91860_62700 n1_M2_92940_62700 0.988200
R7974 n1_M2_92940_62700 n1_M2_94020_62700 0.988200
R7975 n1_M2_94020_62700 n1_M2_95100_62700 0.988200
R7976 n1_M2_95100_62700 n1_M2_96180_62700 0.988200
R7977 n1_M2_96180_62700 n1_M2_97260_62700 0.988200
R7978 n1_M2_97260_62700 n1_M2_98340_62700 0.988200
R7979 n1_M2_98340_62700 n1_M2_99420_62700 0.988200
R7980 n1_M2_99420_62700 n1_M2_100500_62700 0.988200
R7981 n1_M2_100500_62700 n1_M2_101580_62700 0.988200
R7982 n1_M2_101580_62700 n1_M2_102660_62700 0.988200
R7983 n1_M2_102660_62700 n1_M2_103740_62700 0.988200
R7984 n1_M2_103740_62700 n1_M2_104820_62700 0.988200
R7985 n1_M2_104820_62700 n1_M2_105900_62700 0.988200
R7986 n1_M2_105900_62700 n1_M2_106980_62700 0.988200
R7987 n1_M2_106980_62700 n1_M2_108060_62700 0.988200
R7988 n1_M2_108060_62700 n1_M2_109140_62700 0.988200
R7989 n1_M2_109140_62700 n1_M2_110220_62700 0.988200
R7990 n1_M2_110220_62700 n1_M2_111300_62700 0.988200
R7991 n1_M2_111300_62700 n1_M2_112380_62700 0.988200
R7992 n1_M2_112380_62700 n1_M2_113460_62700 0.988200
R7993 n1_M2_113460_62700 n1_M2_114540_62700 0.988200
R7994 n1_M2_114540_62700 n1_M2_115620_62700 0.988200
R7995 n1_M2_115620_62700 n1_M2_116700_62700 0.988200
R7996 n1_M2_116700_62700 n1_M2_117780_62700 0.988200
R7997 n1_M2_117780_62700 n1_M2_118860_62700 0.988200
R7998 n1_M2_118860_62700 n1_M2_119940_62700 0.988200
R7999 n1_M2_119940_62700 n1_M2_121020_62700 0.988200
R8000 n1_M2_121020_62700 n1_M2_122100_62700 0.988200
R8001 n1_M2_122100_62700 n1_M2_123180_62700 0.988200
R8002 n1_M2_123180_62700 n1_M2_124260_62700 0.988200
R8003 n1_M2_124260_62700 n1_M2_125340_62700 0.988200
R8004 n1_M2_125340_62700 n1_M2_126420_62700 0.988200
R8005 n1_M2_126420_62700 n1_M2_127500_62700 0.988200
R8006 n1_M2_127500_62700 n1_M2_128580_62700 0.988200
R8007 n1_M2_128580_62700 n1_M2_129660_62700 0.988200
R8008 n1_M2_129660_62700 n1_M2_130740_62700 0.988200
R8009 n1_M2_130740_62700 n1_M2_131820_62700 0.988200
R8010 n1_M2_131820_62700 n1_M2_132900_62700 0.988200
R8011 n1_M2_132900_62700 n1_M2_133980_62700 0.988200
R8012 n1_M2_133980_62700 n1_M2_135060_62700 0.988200
R8013 n1_M2_135060_62700 n1_M2_136140_62700 0.988200
R8014 n1_M2_136140_62700 n1_M2_137220_62700 0.988200
R8015 n1_M2_137220_62700 n1_M2_138300_62700 0.988200
R8016 n1_M2_138300_62700 n1_M2_139380_62700 0.988200
R8017 n1_M2_139380_62700 n1_M2_140460_62700 0.988200
R8018 n1_M2_140460_62700 n1_M2_141540_62700 0.988200
R8019 n1_M2_141540_62700 n1_M2_142620_62700 0.988200
R8020 n1_M2_142620_62700 n1_M2_143700_62700 0.988200
R8021 n1_M2_143700_62700 n1_M2_144780_62700 0.988200
R8022 n1_M2_144780_62700 n1_M2_145860_62700 0.988200
R8023 n1_M2_145860_62700 n1_M2_146940_62700 0.988200
R8024 n1_M2_60_63780 n1_M2_1140_63780 0.988200
R8025 n1_M2_1140_63780 n1_M2_2220_63780 0.988200
R8026 n1_M2_2220_63780 n1_M2_3300_63780 0.988200
R8027 n1_M2_3300_63780 n1_M2_4380_63780 0.988200
R8028 n1_M2_4380_63780 n1_M2_5460_63780 0.988200
R8029 n1_M2_5460_63780 n1_M2_6540_63780 0.988200
R8030 n1_M2_6540_63780 n1_M2_7620_63780 0.988200
R8031 n1_M2_7620_63780 n1_M2_8700_63780 0.988200
R8032 n1_M2_8700_63780 n1_M2_9780_63780 0.988200
R8033 n1_M2_9780_63780 n1_M2_10860_63780 0.988200
R8034 n1_M2_10860_63780 n1_M2_11940_63780 0.988200
R8035 n1_M2_11940_63780 n1_M2_13020_63780 0.988200
R8036 n1_M2_13020_63780 n1_M2_14100_63780 0.988200
R8037 n1_M2_14100_63780 n1_M2_15180_63780 0.988200
R8038 n1_M2_15180_63780 n1_M2_16260_63780 0.988200
R8039 n1_M2_16260_63780 n1_M2_17340_63780 0.988200
R8040 n1_M2_17340_63780 n1_M2_18420_63780 0.988200
R8041 n1_M2_18420_63780 n1_M2_19500_63780 0.988200
R8042 n1_M2_19500_63780 n1_M2_20580_63780 0.988200
R8043 n1_M2_20580_63780 n1_M2_21660_63780 0.988200
R8044 n1_M2_21660_63780 n1_M2_22740_63780 0.988200
R8045 n1_M2_22740_63780 n1_M2_23820_63780 0.988200
R8046 n1_M2_23820_63780 n1_M2_24900_63780 0.988200
R8047 n1_M2_24900_63780 n1_M2_25980_63780 0.988200
R8048 n1_M2_25980_63780 n1_M2_27060_63780 0.988200
R8049 n1_M2_27060_63780 n1_M2_28140_63780 0.988200
R8050 n1_M2_28140_63780 n1_M2_29220_63780 0.988200
R8051 n1_M2_29220_63780 n1_M2_30300_63780 0.988200
R8052 n1_M2_30300_63780 n1_M2_31380_63780 0.988200
R8053 n1_M2_31380_63780 n1_M2_32460_63780 0.988200
R8054 n1_M2_32460_63780 n1_M2_33540_63780 0.988200
R8055 n1_M2_33540_63780 n1_M2_34620_63780 0.988200
R8056 n1_M2_34620_63780 n1_M2_35700_63780 0.988200
R8057 n1_M2_35700_63780 n1_M2_36780_63780 0.988200
R8058 n1_M2_36780_63780 n1_M2_37860_63780 0.988200
R8059 n1_M2_37860_63780 n1_M2_38940_63780 0.988200
R8060 n1_M2_38940_63780 n1_M2_40020_63780 0.988200
R8061 n1_M2_40020_63780 n1_M2_41100_63780 0.988200
R8062 n1_M2_41100_63780 n1_M2_42180_63780 0.988200
R8063 n1_M2_42180_63780 n1_M2_43260_63780 0.988200
R8064 n1_M2_43260_63780 n1_M2_44340_63780 0.988200
R8065 n1_M2_44340_63780 n1_M2_45420_63780 0.988200
R8066 n1_M2_45420_63780 n1_M2_46500_63780 0.988200
R8067 n1_M2_46500_63780 n1_M2_47580_63780 0.988200
R8068 n1_M2_47580_63780 n1_M2_48660_63780 0.988200
R8069 n1_M2_48660_63780 n1_M2_49740_63780 0.988200
R8070 n1_M2_49740_63780 n1_M2_50820_63780 0.988200
R8071 n1_M2_50820_63780 n1_M2_51900_63780 0.988200
R8072 n1_M2_51900_63780 n1_M2_52980_63780 0.988200
R8073 n1_M2_52980_63780 n1_M2_54060_63780 0.988200
R8074 n1_M2_54060_63780 n1_M2_55140_63780 0.988200
R8075 n1_M2_55140_63780 n1_M2_56220_63780 0.988200
R8076 n1_M2_56220_63780 n1_M2_57300_63780 0.988200
R8077 n1_M2_57300_63780 n1_M2_58380_63780 0.988200
R8078 n1_M2_58380_63780 n1_M2_59460_63780 0.988200
R8079 n1_M2_59460_63780 n1_M2_60540_63780 0.988200
R8080 n1_M2_60540_63780 n1_M2_61620_63780 0.988200
R8081 n1_M2_61620_63780 n1_M2_62700_63780 0.988200
R8082 n1_M2_62700_63780 n1_M2_63780_63780 0.988200
R8083 n1_M2_63780_63780 n1_M2_64860_63780 0.988200
R8084 n1_M2_64860_63780 n1_M2_65940_63780 0.988200
R8085 n1_M2_65940_63780 n1_M2_67020_63780 0.988200
R8086 n1_M2_67020_63780 n1_M2_68100_63780 0.988200
R8087 n1_M2_68100_63780 n1_M2_69180_63780 0.988200
R8088 n1_M2_69180_63780 n1_M2_70260_63780 0.988200
R8089 n1_M2_70260_63780 n1_M2_71340_63780 0.988200
R8090 n1_M2_71340_63780 n1_M2_72420_63780 0.988200
R8091 n1_M2_72420_63780 n1_M2_73500_63780 0.988200
R8092 n1_M2_73500_63780 n1_M2_74580_63780 0.988200
R8093 n1_M2_74580_63780 n1_M2_75660_63780 0.988200
R8094 n1_M2_75660_63780 n1_M2_76740_63780 0.988200
R8095 n1_M2_76740_63780 n1_M2_77820_63780 0.988200
R8096 n1_M2_77820_63780 n1_M2_78900_63780 0.988200
R8097 n1_M2_78900_63780 n1_M2_79980_63780 0.988200
R8098 n1_M2_79980_63780 n1_M2_81060_63780 0.988200
R8099 n1_M2_81060_63780 n1_M2_82140_63780 0.988200
R8100 n1_M2_82140_63780 n1_M2_83220_63780 0.988200
R8101 n1_M2_83220_63780 n1_M2_84300_63780 0.988200
R8102 n1_M2_84300_63780 n1_M2_85380_63780 0.988200
R8103 n1_M2_85380_63780 n1_M2_86460_63780 0.988200
R8104 n1_M2_86460_63780 n1_M2_87540_63780 0.988200
R8105 n1_M2_87540_63780 n1_M2_88620_63780 0.988200
R8106 n1_M2_88620_63780 n1_M2_89700_63780 0.988200
R8107 n1_M2_89700_63780 n1_M2_90780_63780 0.988200
R8108 n1_M2_90780_63780 n1_M2_91860_63780 0.988200
R8109 n1_M2_91860_63780 n1_M2_92940_63780 0.988200
R8110 n1_M2_92940_63780 n1_M2_94020_63780 0.988200
R8111 n1_M2_94020_63780 n1_M2_95100_63780 0.988200
R8112 n1_M2_95100_63780 n1_M2_96180_63780 0.988200
R8113 n1_M2_96180_63780 n1_M2_97260_63780 0.988200
R8114 n1_M2_97260_63780 n1_M2_98340_63780 0.988200
R8115 n1_M2_98340_63780 n1_M2_99420_63780 0.988200
R8116 n1_M2_99420_63780 n1_M2_100500_63780 0.988200
R8117 n1_M2_100500_63780 n1_M2_101580_63780 0.988200
R8118 n1_M2_101580_63780 n1_M2_102660_63780 0.988200
R8119 n1_M2_102660_63780 n1_M2_103740_63780 0.988200
R8120 n1_M2_103740_63780 n1_M2_104820_63780 0.988200
R8121 n1_M2_104820_63780 n1_M2_105900_63780 0.988200
R8122 n1_M2_105900_63780 n1_M2_106980_63780 0.988200
R8123 n1_M2_106980_63780 n1_M2_108060_63780 0.988200
R8124 n1_M2_108060_63780 n1_M2_109140_63780 0.988200
R8125 n1_M2_109140_63780 n1_M2_110220_63780 0.988200
R8126 n1_M2_110220_63780 n1_M2_111300_63780 0.988200
R8127 n1_M2_111300_63780 n1_M2_112380_63780 0.988200
R8128 n1_M2_112380_63780 n1_M2_113460_63780 0.988200
R8129 n1_M2_113460_63780 n1_M2_114540_63780 0.988200
R8130 n1_M2_114540_63780 n1_M2_115620_63780 0.988200
R8131 n1_M2_115620_63780 n1_M2_116700_63780 0.988200
R8132 n1_M2_116700_63780 n1_M2_117780_63780 0.988200
R8133 n1_M2_117780_63780 n1_M2_118860_63780 0.988200
R8134 n1_M2_118860_63780 n1_M2_119940_63780 0.988200
R8135 n1_M2_119940_63780 n1_M2_121020_63780 0.988200
R8136 n1_M2_121020_63780 n1_M2_122100_63780 0.988200
R8137 n1_M2_122100_63780 n1_M2_123180_63780 0.988200
R8138 n1_M2_123180_63780 n1_M2_124260_63780 0.988200
R8139 n1_M2_124260_63780 n1_M2_125340_63780 0.988200
R8140 n1_M2_125340_63780 n1_M2_126420_63780 0.988200
R8141 n1_M2_126420_63780 n1_M2_127500_63780 0.988200
R8142 n1_M2_127500_63780 n1_M2_128580_63780 0.988200
R8143 n1_M2_128580_63780 n1_M2_129660_63780 0.988200
R8144 n1_M2_129660_63780 n1_M2_130740_63780 0.988200
R8145 n1_M2_130740_63780 n1_M2_131820_63780 0.988200
R8146 n1_M2_131820_63780 n1_M2_132900_63780 0.988200
R8147 n1_M2_132900_63780 n1_M2_133980_63780 0.988200
R8148 n1_M2_133980_63780 n1_M2_135060_63780 0.988200
R8149 n1_M2_135060_63780 n1_M2_136140_63780 0.988200
R8150 n1_M2_136140_63780 n1_M2_137220_63780 0.988200
R8151 n1_M2_137220_63780 n1_M2_138300_63780 0.988200
R8152 n1_M2_138300_63780 n1_M2_139380_63780 0.988200
R8153 n1_M2_139380_63780 n1_M2_140460_63780 0.988200
R8154 n1_M2_140460_63780 n1_M2_141540_63780 0.988200
R8155 n1_M2_141540_63780 n1_M2_142620_63780 0.988200
R8156 n1_M2_142620_63780 n1_M2_143700_63780 0.988200
R8157 n1_M2_143700_63780 n1_M2_144780_63780 0.988200
R8158 n1_M2_144780_63780 n1_M2_145860_63780 0.988200
R8159 n1_M2_145860_63780 n1_M2_146940_63780 0.988200
R8160 n1_M2_60_64860 n1_M2_1140_64860 0.988200
R8161 n1_M2_1140_64860 n1_M2_2220_64860 0.988200
R8162 n1_M2_2220_64860 n1_M2_3300_64860 0.988200
R8163 n1_M2_3300_64860 n1_M2_4380_64860 0.988200
R8164 n1_M2_4380_64860 n1_M2_5460_64860 0.988200
R8165 n1_M2_5460_64860 n1_M2_6540_64860 0.988200
R8166 n1_M2_6540_64860 n1_M2_7620_64860 0.988200
R8167 n1_M2_7620_64860 n1_M2_8700_64860 0.988200
R8168 n1_M2_8700_64860 n1_M2_9780_64860 0.988200
R8169 n1_M2_9780_64860 n1_M2_10860_64860 0.988200
R8170 n1_M2_10860_64860 n1_M2_11940_64860 0.988200
R8171 n1_M2_11940_64860 n1_M2_13020_64860 0.988200
R8172 n1_M2_13020_64860 n1_M2_14100_64860 0.988200
R8173 n1_M2_14100_64860 n1_M2_15180_64860 0.988200
R8174 n1_M2_15180_64860 n1_M2_16260_64860 0.988200
R8175 n1_M2_16260_64860 n1_M2_17340_64860 0.988200
R8176 n1_M2_17340_64860 n1_M2_18420_64860 0.988200
R8177 n1_M2_18420_64860 n1_M2_19500_64860 0.988200
R8178 n1_M2_19500_64860 n1_M2_20580_64860 0.988200
R8179 n1_M2_20580_64860 n1_M2_21660_64860 0.988200
R8180 n1_M2_21660_64860 n1_M2_22740_64860 0.988200
R8181 n1_M2_22740_64860 n1_M2_23820_64860 0.988200
R8182 n1_M2_23820_64860 n1_M2_24900_64860 0.988200
R8183 n1_M2_24900_64860 n1_M2_25980_64860 0.988200
R8184 n1_M2_25980_64860 n1_M2_27060_64860 0.988200
R8185 n1_M2_27060_64860 n1_M2_28140_64860 0.988200
R8186 n1_M2_28140_64860 n1_M2_29220_64860 0.988200
R8187 n1_M2_29220_64860 n1_M2_30300_64860 0.988200
R8188 n1_M2_30300_64860 n1_M2_31380_64860 0.988200
R8189 n1_M2_31380_64860 n1_M2_32460_64860 0.988200
R8190 n1_M2_32460_64860 n1_M2_33540_64860 0.988200
R8191 n1_M2_33540_64860 n1_M2_34620_64860 0.988200
R8192 n1_M2_34620_64860 n1_M2_35700_64860 0.988200
R8193 n1_M2_35700_64860 n1_M2_36780_64860 0.988200
R8194 n1_M2_36780_64860 n1_M2_37860_64860 0.988200
R8195 n1_M2_37860_64860 n1_M2_38940_64860 0.988200
R8196 n1_M2_38940_64860 n1_M2_40020_64860 0.988200
R8197 n1_M2_40020_64860 n1_M2_41100_64860 0.988200
R8198 n1_M2_41100_64860 n1_M2_42180_64860 0.988200
R8199 n1_M2_42180_64860 n1_M2_43260_64860 0.988200
R8200 n1_M2_43260_64860 n1_M2_44340_64860 0.988200
R8201 n1_M2_44340_64860 n1_M2_45420_64860 0.988200
R8202 n1_M2_45420_64860 n1_M2_46500_64860 0.988200
R8203 n1_M2_46500_64860 n1_M2_47580_64860 0.988200
R8204 n1_M2_47580_64860 n1_M2_48660_64860 0.988200
R8205 n1_M2_48660_64860 n1_M2_49740_64860 0.988200
R8206 n1_M2_49740_64860 n1_M2_50820_64860 0.988200
R8207 n1_M2_50820_64860 n1_M2_51900_64860 0.988200
R8208 n1_M2_51900_64860 n1_M2_52980_64860 0.988200
R8209 n1_M2_52980_64860 n1_M2_54060_64860 0.988200
R8210 n1_M2_54060_64860 n1_M2_55140_64860 0.988200
R8211 n1_M2_55140_64860 n1_M2_56220_64860 0.988200
R8212 n1_M2_56220_64860 n1_M2_57300_64860 0.988200
R8213 n1_M2_57300_64860 n1_M2_58380_64860 0.988200
R8214 n1_M2_58380_64860 n1_M2_59460_64860 0.988200
R8215 n1_M2_59460_64860 n1_M2_60540_64860 0.988200
R8216 n1_M2_60540_64860 n1_M2_61620_64860 0.988200
R8217 n1_M2_61620_64860 n1_M2_62700_64860 0.988200
R8218 n1_M2_62700_64860 n1_M2_63780_64860 0.988200
R8219 n1_M2_63780_64860 n1_M2_64860_64860 0.988200
R8220 n1_M2_64860_64860 n1_M2_65940_64860 0.988200
R8221 n1_M2_65940_64860 n1_M2_67020_64860 0.988200
R8222 n1_M2_67020_64860 n1_M2_68100_64860 0.988200
R8223 n1_M2_68100_64860 n1_M2_69180_64860 0.988200
R8224 n1_M2_69180_64860 n1_M2_70260_64860 0.988200
R8225 n1_M2_70260_64860 n1_M2_71340_64860 0.988200
R8226 n1_M2_71340_64860 n1_M2_72420_64860 0.988200
R8227 n1_M2_72420_64860 n1_M2_73500_64860 0.988200
R8228 n1_M2_73500_64860 n1_M2_74580_64860 0.988200
R8229 n1_M2_74580_64860 n1_M2_75660_64860 0.988200
R8230 n1_M2_75660_64860 n1_M2_76740_64860 0.988200
R8231 n1_M2_76740_64860 n1_M2_77820_64860 0.988200
R8232 n1_M2_77820_64860 n1_M2_78900_64860 0.988200
R8233 n1_M2_78900_64860 n1_M2_79980_64860 0.988200
R8234 n1_M2_79980_64860 n1_M2_81060_64860 0.988200
R8235 n1_M2_81060_64860 n1_M2_82140_64860 0.988200
R8236 n1_M2_82140_64860 n1_M2_83220_64860 0.988200
R8237 n1_M2_83220_64860 n1_M2_84300_64860 0.988200
R8238 n1_M2_84300_64860 n1_M2_85380_64860 0.988200
R8239 n1_M2_85380_64860 n1_M2_86460_64860 0.988200
R8240 n1_M2_86460_64860 n1_M2_87540_64860 0.988200
R8241 n1_M2_87540_64860 n1_M2_88620_64860 0.988200
R8242 n1_M2_88620_64860 n1_M2_89700_64860 0.988200
R8243 n1_M2_89700_64860 n1_M2_90780_64860 0.988200
R8244 n1_M2_90780_64860 n1_M2_91860_64860 0.988200
R8245 n1_M2_91860_64860 n1_M2_92940_64860 0.988200
R8246 n1_M2_92940_64860 n1_M2_94020_64860 0.988200
R8247 n1_M2_94020_64860 n1_M2_95100_64860 0.988200
R8248 n1_M2_95100_64860 n1_M2_96180_64860 0.988200
R8249 n1_M2_96180_64860 n1_M2_97260_64860 0.988200
R8250 n1_M2_97260_64860 n1_M2_98340_64860 0.988200
R8251 n1_M2_98340_64860 n1_M2_99420_64860 0.988200
R8252 n1_M2_99420_64860 n1_M2_100500_64860 0.988200
R8253 n1_M2_100500_64860 n1_M2_101580_64860 0.988200
R8254 n1_M2_101580_64860 n1_M2_102660_64860 0.988200
R8255 n1_M2_102660_64860 n1_M2_103740_64860 0.988200
R8256 n1_M2_103740_64860 n1_M2_104820_64860 0.988200
R8257 n1_M2_104820_64860 n1_M2_105900_64860 0.988200
R8258 n1_M2_105900_64860 n1_M2_106980_64860 0.988200
R8259 n1_M2_106980_64860 n1_M2_108060_64860 0.988200
R8260 n1_M2_108060_64860 n1_M2_109140_64860 0.988200
R8261 n1_M2_109140_64860 n1_M2_110220_64860 0.988200
R8262 n1_M2_110220_64860 n1_M2_111300_64860 0.988200
R8263 n1_M2_111300_64860 n1_M2_112380_64860 0.988200
R8264 n1_M2_112380_64860 n1_M2_113460_64860 0.988200
R8265 n1_M2_113460_64860 n1_M2_114540_64860 0.988200
R8266 n1_M2_114540_64860 n1_M2_115620_64860 0.988200
R8267 n1_M2_115620_64860 n1_M2_116700_64860 0.988200
R8268 n1_M2_116700_64860 n1_M2_117780_64860 0.988200
R8269 n1_M2_117780_64860 n1_M2_118860_64860 0.988200
R8270 n1_M2_118860_64860 n1_M2_119940_64860 0.988200
R8271 n1_M2_119940_64860 n1_M2_121020_64860 0.988200
R8272 n1_M2_121020_64860 n1_M2_122100_64860 0.988200
R8273 n1_M2_122100_64860 n1_M2_123180_64860 0.988200
R8274 n1_M2_123180_64860 n1_M2_124260_64860 0.988200
R8275 n1_M2_124260_64860 n1_M2_125340_64860 0.988200
R8276 n1_M2_125340_64860 n1_M2_126420_64860 0.988200
R8277 n1_M2_126420_64860 n1_M2_127500_64860 0.988200
R8278 n1_M2_127500_64860 n1_M2_128580_64860 0.988200
R8279 n1_M2_128580_64860 n1_M2_129660_64860 0.988200
R8280 n1_M2_129660_64860 n1_M2_130740_64860 0.988200
R8281 n1_M2_130740_64860 n1_M2_131820_64860 0.988200
R8282 n1_M2_131820_64860 n1_M2_132900_64860 0.988200
R8283 n1_M2_132900_64860 n1_M2_133980_64860 0.988200
R8284 n1_M2_133980_64860 n1_M2_135060_64860 0.988200
R8285 n1_M2_135060_64860 n1_M2_136140_64860 0.988200
R8286 n1_M2_136140_64860 n1_M2_137220_64860 0.988200
R8287 n1_M2_137220_64860 n1_M2_138300_64860 0.988200
R8288 n1_M2_138300_64860 n1_M2_139380_64860 0.988200
R8289 n1_M2_139380_64860 n1_M2_140460_64860 0.988200
R8290 n1_M2_140460_64860 n1_M2_141540_64860 0.988200
R8291 n1_M2_141540_64860 n1_M2_142620_64860 0.988200
R8292 n1_M2_142620_64860 n1_M2_143700_64860 0.988200
R8293 n1_M2_143700_64860 n1_M2_144780_64860 0.988200
R8294 n1_M2_144780_64860 n1_M2_145860_64860 0.988200
R8295 n1_M2_145860_64860 n1_M2_146940_64860 0.988200
R8296 n1_M2_60_65940 n1_M2_1140_65940 0.988200
R8297 n1_M2_1140_65940 n1_M2_2220_65940 0.988200
R8298 n1_M2_2220_65940 n1_M2_3300_65940 0.988200
R8299 n1_M2_3300_65940 n1_M2_4380_65940 0.988200
R8300 n1_M2_4380_65940 n1_M2_5460_65940 0.988200
R8301 n1_M2_5460_65940 n1_M2_6540_65940 0.988200
R8302 n1_M2_6540_65940 n1_M2_7620_65940 0.988200
R8303 n1_M2_7620_65940 n1_M2_8700_65940 0.988200
R8304 n1_M2_8700_65940 n1_M2_9780_65940 0.988200
R8305 n1_M2_9780_65940 n1_M2_10860_65940 0.988200
R8306 n1_M2_10860_65940 n1_M2_11940_65940 0.988200
R8307 n1_M2_11940_65940 n1_M2_13020_65940 0.988200
R8308 n1_M2_13020_65940 n1_M2_14100_65940 0.988200
R8309 n1_M2_14100_65940 n1_M2_15180_65940 0.988200
R8310 n1_M2_15180_65940 n1_M2_16260_65940 0.988200
R8311 n1_M2_16260_65940 n1_M2_17340_65940 0.988200
R8312 n1_M2_17340_65940 n1_M2_18420_65940 0.988200
R8313 n1_M2_18420_65940 n1_M2_19500_65940 0.988200
R8314 n1_M2_19500_65940 n1_M2_20580_65940 0.988200
R8315 n1_M2_20580_65940 n1_M2_21660_65940 0.988200
R8316 n1_M2_21660_65940 n1_M2_22740_65940 0.988200
R8317 n1_M2_22740_65940 n1_M2_23820_65940 0.988200
R8318 n1_M2_23820_65940 n1_M2_24900_65940 0.988200
R8319 n1_M2_24900_65940 n1_M2_25980_65940 0.988200
R8320 n1_M2_25980_65940 n1_M2_27060_65940 0.988200
R8321 n1_M2_27060_65940 n1_M2_28140_65940 0.988200
R8322 n1_M2_28140_65940 n1_M2_29220_65940 0.988200
R8323 n1_M2_29220_65940 n1_M2_30300_65940 0.988200
R8324 n1_M2_30300_65940 n1_M2_31380_65940 0.988200
R8325 n1_M2_31380_65940 n1_M2_32460_65940 0.988200
R8326 n1_M2_32460_65940 n1_M2_33540_65940 0.988200
R8327 n1_M2_33540_65940 n1_M2_34620_65940 0.988200
R8328 n1_M2_34620_65940 n1_M2_35700_65940 0.988200
R8329 n1_M2_35700_65940 n1_M2_36780_65940 0.988200
R8330 n1_M2_36780_65940 n1_M2_37860_65940 0.988200
R8331 n1_M2_37860_65940 n1_M2_38940_65940 0.988200
R8332 n1_M2_38940_65940 n1_M2_40020_65940 0.988200
R8333 n1_M2_40020_65940 n1_M2_41100_65940 0.988200
R8334 n1_M2_41100_65940 n1_M2_42180_65940 0.988200
R8335 n1_M2_42180_65940 n1_M2_43260_65940 0.988200
R8336 n1_M2_43260_65940 n1_M2_44340_65940 0.988200
R8337 n1_M2_44340_65940 n1_M2_45420_65940 0.988200
R8338 n1_M2_45420_65940 n1_M2_46500_65940 0.988200
R8339 n1_M2_46500_65940 n1_M2_47580_65940 0.988200
R8340 n1_M2_47580_65940 n1_M2_48660_65940 0.988200
R8341 n1_M2_48660_65940 n1_M2_49740_65940 0.988200
R8342 n1_M2_49740_65940 n1_M2_50820_65940 0.988200
R8343 n1_M2_50820_65940 n1_M2_51900_65940 0.988200
R8344 n1_M2_51900_65940 n1_M2_52980_65940 0.988200
R8345 n1_M2_52980_65940 n1_M2_54060_65940 0.988200
R8346 n1_M2_54060_65940 n1_M2_55140_65940 0.988200
R8347 n1_M2_55140_65940 n1_M2_56220_65940 0.988200
R8348 n1_M2_56220_65940 n1_M2_57300_65940 0.988200
R8349 n1_M2_57300_65940 n1_M2_58380_65940 0.988200
R8350 n1_M2_58380_65940 n1_M2_59460_65940 0.988200
R8351 n1_M2_59460_65940 n1_M2_60540_65940 0.988200
R8352 n1_M2_60540_65940 n1_M2_61620_65940 0.988200
R8353 n1_M2_61620_65940 n1_M2_62700_65940 0.988200
R8354 n1_M2_62700_65940 n1_M2_63780_65940 0.988200
R8355 n1_M2_63780_65940 n1_M2_64860_65940 0.988200
R8356 n1_M2_64860_65940 n1_M2_65940_65940 0.988200
R8357 n1_M2_65940_65940 n1_M2_67020_65940 0.988200
R8358 n1_M2_67020_65940 n1_M2_68100_65940 0.988200
R8359 n1_M2_68100_65940 n1_M2_69180_65940 0.988200
R8360 n1_M2_69180_65940 n1_M2_70260_65940 0.988200
R8361 n1_M2_70260_65940 n1_M2_71340_65940 0.988200
R8362 n1_M2_71340_65940 n1_M2_72420_65940 0.988200
R8363 n1_M2_72420_65940 n1_M2_73500_65940 0.988200
R8364 n1_M2_73500_65940 n1_M2_74580_65940 0.988200
R8365 n1_M2_74580_65940 n1_M2_75660_65940 0.988200
R8366 n1_M2_75660_65940 n1_M2_76740_65940 0.988200
R8367 n1_M2_76740_65940 n1_M2_77820_65940 0.988200
R8368 n1_M2_77820_65940 n1_M2_78900_65940 0.988200
R8369 n1_M2_78900_65940 n1_M2_79980_65940 0.988200
R8370 n1_M2_79980_65940 n1_M2_81060_65940 0.988200
R8371 n1_M2_81060_65940 n1_M2_82140_65940 0.988200
R8372 n1_M2_82140_65940 n1_M2_83220_65940 0.988200
R8373 n1_M2_83220_65940 n1_M2_84300_65940 0.988200
R8374 n1_M2_84300_65940 n1_M2_85380_65940 0.988200
R8375 n1_M2_85380_65940 n1_M2_86460_65940 0.988200
R8376 n1_M2_86460_65940 n1_M2_87540_65940 0.988200
R8377 n1_M2_87540_65940 n1_M2_88620_65940 0.988200
R8378 n1_M2_88620_65940 n1_M2_89700_65940 0.988200
R8379 n1_M2_89700_65940 n1_M2_90780_65940 0.988200
R8380 n1_M2_90780_65940 n1_M2_91860_65940 0.988200
R8381 n1_M2_91860_65940 n1_M2_92940_65940 0.988200
R8382 n1_M2_92940_65940 n1_M2_94020_65940 0.988200
R8383 n1_M2_94020_65940 n1_M2_95100_65940 0.988200
R8384 n1_M2_95100_65940 n1_M2_96180_65940 0.988200
R8385 n1_M2_96180_65940 n1_M2_97260_65940 0.988200
R8386 n1_M2_97260_65940 n1_M2_98340_65940 0.988200
R8387 n1_M2_98340_65940 n1_M2_99420_65940 0.988200
R8388 n1_M2_99420_65940 n1_M2_100500_65940 0.988200
R8389 n1_M2_100500_65940 n1_M2_101580_65940 0.988200
R8390 n1_M2_101580_65940 n1_M2_102660_65940 0.988200
R8391 n1_M2_102660_65940 n1_M2_103740_65940 0.988200
R8392 n1_M2_103740_65940 n1_M2_104820_65940 0.988200
R8393 n1_M2_104820_65940 n1_M2_105900_65940 0.988200
R8394 n1_M2_105900_65940 n1_M2_106980_65940 0.988200
R8395 n1_M2_106980_65940 n1_M2_108060_65940 0.988200
R8396 n1_M2_108060_65940 n1_M2_109140_65940 0.988200
R8397 n1_M2_109140_65940 n1_M2_110220_65940 0.988200
R8398 n1_M2_110220_65940 n1_M2_111300_65940 0.988200
R8399 n1_M2_111300_65940 n1_M2_112380_65940 0.988200
R8400 n1_M2_112380_65940 n1_M2_113460_65940 0.988200
R8401 n1_M2_113460_65940 n1_M2_114540_65940 0.988200
R8402 n1_M2_114540_65940 n1_M2_115620_65940 0.988200
R8403 n1_M2_115620_65940 n1_M2_116700_65940 0.988200
R8404 n1_M2_116700_65940 n1_M2_117780_65940 0.988200
R8405 n1_M2_117780_65940 n1_M2_118860_65940 0.988200
R8406 n1_M2_118860_65940 n1_M2_119940_65940 0.988200
R8407 n1_M2_119940_65940 n1_M2_121020_65940 0.988200
R8408 n1_M2_121020_65940 n1_M2_122100_65940 0.988200
R8409 n1_M2_122100_65940 n1_M2_123180_65940 0.988200
R8410 n1_M2_123180_65940 n1_M2_124260_65940 0.988200
R8411 n1_M2_124260_65940 n1_M2_125340_65940 0.988200
R8412 n1_M2_125340_65940 n1_M2_126420_65940 0.988200
R8413 n1_M2_126420_65940 n1_M2_127500_65940 0.988200
R8414 n1_M2_127500_65940 n1_M2_128580_65940 0.988200
R8415 n1_M2_128580_65940 n1_M2_129660_65940 0.988200
R8416 n1_M2_129660_65940 n1_M2_130740_65940 0.988200
R8417 n1_M2_130740_65940 n1_M2_131820_65940 0.988200
R8418 n1_M2_131820_65940 n1_M2_132900_65940 0.988200
R8419 n1_M2_132900_65940 n1_M2_133980_65940 0.988200
R8420 n1_M2_133980_65940 n1_M2_135060_65940 0.988200
R8421 n1_M2_135060_65940 n1_M2_136140_65940 0.988200
R8422 n1_M2_136140_65940 n1_M2_137220_65940 0.988200
R8423 n1_M2_137220_65940 n1_M2_138300_65940 0.988200
R8424 n1_M2_138300_65940 n1_M2_139380_65940 0.988200
R8425 n1_M2_139380_65940 n1_M2_140460_65940 0.988200
R8426 n1_M2_140460_65940 n1_M2_141540_65940 0.988200
R8427 n1_M2_141540_65940 n1_M2_142620_65940 0.988200
R8428 n1_M2_142620_65940 n1_M2_143700_65940 0.988200
R8429 n1_M2_143700_65940 n1_M2_144780_65940 0.988200
R8430 n1_M2_144780_65940 n1_M2_145860_65940 0.988200
R8431 n1_M2_145860_65940 n1_M2_146940_65940 0.988200
R8432 n1_M2_60_67020 n1_M2_1140_67020 0.988200
R8433 n1_M2_1140_67020 n1_M2_2220_67020 0.988200
R8434 n1_M2_2220_67020 n1_M2_3300_67020 0.988200
R8435 n1_M2_3300_67020 n1_M2_4380_67020 0.988200
R8436 n1_M2_4380_67020 n1_M2_5460_67020 0.988200
R8437 n1_M2_5460_67020 n1_M2_6540_67020 0.988200
R8438 n1_M2_6540_67020 n1_M2_7620_67020 0.988200
R8439 n1_M2_7620_67020 n1_M2_8700_67020 0.988200
R8440 n1_M2_8700_67020 n1_M2_9780_67020 0.988200
R8441 n1_M2_9780_67020 n1_M2_10860_67020 0.988200
R8442 n1_M2_10860_67020 n1_M2_11940_67020 0.988200
R8443 n1_M2_11940_67020 n1_M2_13020_67020 0.988200
R8444 n1_M2_13020_67020 n1_M2_14100_67020 0.988200
R8445 n1_M2_14100_67020 n1_M2_15180_67020 0.988200
R8446 n1_M2_15180_67020 n1_M2_16260_67020 0.988200
R8447 n1_M2_16260_67020 n1_M2_17340_67020 0.988200
R8448 n1_M2_17340_67020 n1_M2_18420_67020 0.988200
R8449 n1_M2_18420_67020 n1_M2_19500_67020 0.988200
R8450 n1_M2_19500_67020 n1_M2_20580_67020 0.988200
R8451 n1_M2_20580_67020 n1_M2_21660_67020 0.988200
R8452 n1_M2_21660_67020 n1_M2_22740_67020 0.988200
R8453 n1_M2_22740_67020 n1_M2_23820_67020 0.988200
R8454 n1_M2_23820_67020 n1_M2_24900_67020 0.988200
R8455 n1_M2_24900_67020 n1_M2_25980_67020 0.988200
R8456 n1_M2_25980_67020 n1_M2_27060_67020 0.988200
R8457 n1_M2_27060_67020 n1_M2_28140_67020 0.988200
R8458 n1_M2_28140_67020 n1_M2_29220_67020 0.988200
R8459 n1_M2_29220_67020 n1_M2_30300_67020 0.988200
R8460 n1_M2_30300_67020 n1_M2_31380_67020 0.988200
R8461 n1_M2_31380_67020 n1_M2_32460_67020 0.988200
R8462 n1_M2_32460_67020 n1_M2_33540_67020 0.988200
R8463 n1_M2_33540_67020 n1_M2_34620_67020 0.988200
R8464 n1_M2_34620_67020 n1_M2_35700_67020 0.988200
R8465 n1_M2_35700_67020 n1_M2_36780_67020 0.988200
R8466 n1_M2_36780_67020 n1_M2_37860_67020 0.988200
R8467 n1_M2_37860_67020 n1_M2_38940_67020 0.988200
R8468 n1_M2_38940_67020 n1_M2_40020_67020 0.988200
R8469 n1_M2_40020_67020 n1_M2_41100_67020 0.988200
R8470 n1_M2_41100_67020 n1_M2_42180_67020 0.988200
R8471 n1_M2_42180_67020 n1_M2_43260_67020 0.988200
R8472 n1_M2_43260_67020 n1_M2_44340_67020 0.988200
R8473 n1_M2_44340_67020 n1_M2_45420_67020 0.988200
R8474 n1_M2_45420_67020 n1_M2_46500_67020 0.988200
R8475 n1_M2_46500_67020 n1_M2_47580_67020 0.988200
R8476 n1_M2_47580_67020 n1_M2_48660_67020 0.988200
R8477 n1_M2_48660_67020 n1_M2_49740_67020 0.988200
R8478 n1_M2_49740_67020 n1_M2_50820_67020 0.988200
R8479 n1_M2_50820_67020 n1_M2_51900_67020 0.988200
R8480 n1_M2_51900_67020 n1_M2_52980_67020 0.988200
R8481 n1_M2_52980_67020 n1_M2_54060_67020 0.988200
R8482 n1_M2_54060_67020 n1_M2_55140_67020 0.988200
R8483 n1_M2_55140_67020 n1_M2_56220_67020 0.988200
R8484 n1_M2_56220_67020 n1_M2_57300_67020 0.988200
R8485 n1_M2_57300_67020 n1_M2_58380_67020 0.988200
R8486 n1_M2_58380_67020 n1_M2_59460_67020 0.988200
R8487 n1_M2_59460_67020 n1_M2_60540_67020 0.988200
R8488 n1_M2_60540_67020 n1_M2_61620_67020 0.988200
R8489 n1_M2_61620_67020 n1_M2_62700_67020 0.988200
R8490 n1_M2_62700_67020 n1_M2_63780_67020 0.988200
R8491 n1_M2_63780_67020 n1_M2_64860_67020 0.988200
R8492 n1_M2_64860_67020 n1_M2_65940_67020 0.988200
R8493 n1_M2_65940_67020 n1_M2_67020_67020 0.988200
R8494 n1_M2_67020_67020 n1_M2_68100_67020 0.988200
R8495 n1_M2_68100_67020 n1_M2_69180_67020 0.988200
R8496 n1_M2_69180_67020 n1_M2_70260_67020 0.988200
R8497 n1_M2_70260_67020 n1_M2_71340_67020 0.988200
R8498 n1_M2_71340_67020 n1_M2_72420_67020 0.988200
R8499 n1_M2_72420_67020 n1_M2_73500_67020 0.988200
R8500 n1_M2_73500_67020 n1_M2_74580_67020 0.988200
R8501 n1_M2_74580_67020 n1_M2_75660_67020 0.988200
R8502 n1_M2_75660_67020 n1_M2_76740_67020 0.988200
R8503 n1_M2_76740_67020 n1_M2_77820_67020 0.988200
R8504 n1_M2_77820_67020 n1_M2_78900_67020 0.988200
R8505 n1_M2_78900_67020 n1_M2_79980_67020 0.988200
R8506 n1_M2_79980_67020 n1_M2_81060_67020 0.988200
R8507 n1_M2_81060_67020 n1_M2_82140_67020 0.988200
R8508 n1_M2_82140_67020 n1_M2_83220_67020 0.988200
R8509 n1_M2_83220_67020 n1_M2_84300_67020 0.988200
R8510 n1_M2_84300_67020 n1_M2_85380_67020 0.988200
R8511 n1_M2_85380_67020 n1_M2_86460_67020 0.988200
R8512 n1_M2_86460_67020 n1_M2_87540_67020 0.988200
R8513 n1_M2_87540_67020 n1_M2_88620_67020 0.988200
R8514 n1_M2_88620_67020 n1_M2_89700_67020 0.988200
R8515 n1_M2_89700_67020 n1_M2_90780_67020 0.988200
R8516 n1_M2_90780_67020 n1_M2_91860_67020 0.988200
R8517 n1_M2_91860_67020 n1_M2_92940_67020 0.988200
R8518 n1_M2_92940_67020 n1_M2_94020_67020 0.988200
R8519 n1_M2_94020_67020 n1_M2_95100_67020 0.988200
R8520 n1_M2_95100_67020 n1_M2_96180_67020 0.988200
R8521 n1_M2_96180_67020 n1_M2_97260_67020 0.988200
R8522 n1_M2_97260_67020 n1_M2_98340_67020 0.988200
R8523 n1_M2_98340_67020 n1_M2_99420_67020 0.988200
R8524 n1_M2_99420_67020 n1_M2_100500_67020 0.988200
R8525 n1_M2_100500_67020 n1_M2_101580_67020 0.988200
R8526 n1_M2_101580_67020 n1_M2_102660_67020 0.988200
R8527 n1_M2_102660_67020 n1_M2_103740_67020 0.988200
R8528 n1_M2_103740_67020 n1_M2_104820_67020 0.988200
R8529 n1_M2_104820_67020 n1_M2_105900_67020 0.988200
R8530 n1_M2_105900_67020 n1_M2_106980_67020 0.988200
R8531 n1_M2_106980_67020 n1_M2_108060_67020 0.988200
R8532 n1_M2_108060_67020 n1_M2_109140_67020 0.988200
R8533 n1_M2_109140_67020 n1_M2_110220_67020 0.988200
R8534 n1_M2_110220_67020 n1_M2_111300_67020 0.988200
R8535 n1_M2_111300_67020 n1_M2_112380_67020 0.988200
R8536 n1_M2_112380_67020 n1_M2_113460_67020 0.988200
R8537 n1_M2_113460_67020 n1_M2_114540_67020 0.988200
R8538 n1_M2_114540_67020 n1_M2_115620_67020 0.988200
R8539 n1_M2_115620_67020 n1_M2_116700_67020 0.988200
R8540 n1_M2_116700_67020 n1_M2_117780_67020 0.988200
R8541 n1_M2_117780_67020 n1_M2_118860_67020 0.988200
R8542 n1_M2_118860_67020 n1_M2_119940_67020 0.988200
R8543 n1_M2_119940_67020 n1_M2_121020_67020 0.988200
R8544 n1_M2_121020_67020 n1_M2_122100_67020 0.988200
R8545 n1_M2_122100_67020 n1_M2_123180_67020 0.988200
R8546 n1_M2_123180_67020 n1_M2_124260_67020 0.988200
R8547 n1_M2_124260_67020 n1_M2_125340_67020 0.988200
R8548 n1_M2_125340_67020 n1_M2_126420_67020 0.988200
R8549 n1_M2_126420_67020 n1_M2_127500_67020 0.988200
R8550 n1_M2_127500_67020 n1_M2_128580_67020 0.988200
R8551 n1_M2_128580_67020 n1_M2_129660_67020 0.988200
R8552 n1_M2_129660_67020 n1_M2_130740_67020 0.988200
R8553 n1_M2_130740_67020 n1_M2_131820_67020 0.988200
R8554 n1_M2_131820_67020 n1_M2_132900_67020 0.988200
R8555 n1_M2_132900_67020 n1_M2_133980_67020 0.988200
R8556 n1_M2_133980_67020 n1_M2_135060_67020 0.988200
R8557 n1_M2_135060_67020 n1_M2_136140_67020 0.988200
R8558 n1_M2_136140_67020 n1_M2_137220_67020 0.988200
R8559 n1_M2_137220_67020 n1_M2_138300_67020 0.988200
R8560 n1_M2_138300_67020 n1_M2_139380_67020 0.988200
R8561 n1_M2_139380_67020 n1_M2_140460_67020 0.988200
R8562 n1_M2_140460_67020 n1_M2_141540_67020 0.988200
R8563 n1_M2_141540_67020 n1_M2_142620_67020 0.988200
R8564 n1_M2_142620_67020 n1_M2_143700_67020 0.988200
R8565 n1_M2_143700_67020 n1_M2_144780_67020 0.988200
R8566 n1_M2_144780_67020 n1_M2_145860_67020 0.988200
R8567 n1_M2_145860_67020 n1_M2_146940_67020 0.988200
R8568 n1_M2_60_68100 n1_M2_1140_68100 0.988200
R8569 n1_M2_1140_68100 n1_M2_2220_68100 0.988200
R8570 n1_M2_2220_68100 n1_M2_3300_68100 0.988200
R8571 n1_M2_3300_68100 n1_M2_4380_68100 0.988200
R8572 n1_M2_4380_68100 n1_M2_5460_68100 0.988200
R8573 n1_M2_5460_68100 n1_M2_6540_68100 0.988200
R8574 n1_M2_6540_68100 n1_M2_7620_68100 0.988200
R8575 n1_M2_7620_68100 n1_M2_8700_68100 0.988200
R8576 n1_M2_8700_68100 n1_M2_9780_68100 0.988200
R8577 n1_M2_9780_68100 n1_M2_10860_68100 0.988200
R8578 n1_M2_10860_68100 n1_M2_11940_68100 0.988200
R8579 n1_M2_11940_68100 n1_M2_13020_68100 0.988200
R8580 n1_M2_13020_68100 n1_M2_14100_68100 0.988200
R8581 n1_M2_14100_68100 n1_M2_15180_68100 0.988200
R8582 n1_M2_15180_68100 n1_M2_16260_68100 0.988200
R8583 n1_M2_16260_68100 n1_M2_17340_68100 0.988200
R8584 n1_M2_17340_68100 n1_M2_18420_68100 0.988200
R8585 n1_M2_18420_68100 n1_M2_19500_68100 0.988200
R8586 n1_M2_19500_68100 n1_M2_20580_68100 0.988200
R8587 n1_M2_20580_68100 n1_M2_21660_68100 0.988200
R8588 n1_M2_21660_68100 n1_M2_22740_68100 0.988200
R8589 n1_M2_22740_68100 n1_M2_23820_68100 0.988200
R8590 n1_M2_23820_68100 n1_M2_24900_68100 0.988200
R8591 n1_M2_24900_68100 n1_M2_25980_68100 0.988200
R8592 n1_M2_25980_68100 n1_M2_27060_68100 0.988200
R8593 n1_M2_27060_68100 n1_M2_28140_68100 0.988200
R8594 n1_M2_28140_68100 n1_M2_29220_68100 0.988200
R8595 n1_M2_29220_68100 n1_M2_30300_68100 0.988200
R8596 n1_M2_30300_68100 n1_M2_31380_68100 0.988200
R8597 n1_M2_31380_68100 n1_M2_32460_68100 0.988200
R8598 n1_M2_32460_68100 n1_M2_33540_68100 0.988200
R8599 n1_M2_33540_68100 n1_M2_34620_68100 0.988200
R8600 n1_M2_34620_68100 n1_M2_35700_68100 0.988200
R8601 n1_M2_35700_68100 n1_M2_36780_68100 0.988200
R8602 n1_M2_36780_68100 n1_M2_37860_68100 0.988200
R8603 n1_M2_37860_68100 n1_M2_38940_68100 0.988200
R8604 n1_M2_38940_68100 n1_M2_40020_68100 0.988200
R8605 n1_M2_40020_68100 n1_M2_41100_68100 0.988200
R8606 n1_M2_41100_68100 n1_M2_42180_68100 0.988200
R8607 n1_M2_42180_68100 n1_M2_43260_68100 0.988200
R8608 n1_M2_43260_68100 n1_M2_44340_68100 0.988200
R8609 n1_M2_44340_68100 n1_M2_45420_68100 0.988200
R8610 n1_M2_45420_68100 n1_M2_46500_68100 0.988200
R8611 n1_M2_46500_68100 n1_M2_47580_68100 0.988200
R8612 n1_M2_47580_68100 n1_M2_48660_68100 0.988200
R8613 n1_M2_48660_68100 n1_M2_49740_68100 0.988200
R8614 n1_M2_49740_68100 n1_M2_50820_68100 0.988200
R8615 n1_M2_50820_68100 n1_M2_51900_68100 0.988200
R8616 n1_M2_51900_68100 n1_M2_52980_68100 0.988200
R8617 n1_M2_52980_68100 n1_M2_54060_68100 0.988200
R8618 n1_M2_54060_68100 n1_M2_55140_68100 0.988200
R8619 n1_M2_55140_68100 n1_M2_56220_68100 0.988200
R8620 n1_M2_56220_68100 n1_M2_57300_68100 0.988200
R8621 n1_M2_57300_68100 n1_M2_58380_68100 0.988200
R8622 n1_M2_58380_68100 n1_M2_59460_68100 0.988200
R8623 n1_M2_59460_68100 n1_M2_60540_68100 0.988200
R8624 n1_M2_60540_68100 n1_M2_61620_68100 0.988200
R8625 n1_M2_61620_68100 n1_M2_62700_68100 0.988200
R8626 n1_M2_62700_68100 n1_M2_63780_68100 0.988200
R8627 n1_M2_63780_68100 n1_M2_64860_68100 0.988200
R8628 n1_M2_64860_68100 n1_M2_65940_68100 0.988200
R8629 n1_M2_65940_68100 n1_M2_67020_68100 0.988200
R8630 n1_M2_67020_68100 n1_M2_68100_68100 0.988200
R8631 n1_M2_68100_68100 n1_M2_69180_68100 0.988200
R8632 n1_M2_69180_68100 n1_M2_70260_68100 0.988200
R8633 n1_M2_70260_68100 n1_M2_71340_68100 0.988200
R8634 n1_M2_71340_68100 n1_M2_72420_68100 0.988200
R8635 n1_M2_72420_68100 n1_M2_73500_68100 0.988200
R8636 n1_M2_73500_68100 n1_M2_74580_68100 0.988200
R8637 n1_M2_74580_68100 n1_M2_75660_68100 0.988200
R8638 n1_M2_75660_68100 n1_M2_76740_68100 0.988200
R8639 n1_M2_76740_68100 n1_M2_77820_68100 0.988200
R8640 n1_M2_77820_68100 n1_M2_78900_68100 0.988200
R8641 n1_M2_78900_68100 n1_M2_79980_68100 0.988200
R8642 n1_M2_79980_68100 n1_M2_81060_68100 0.988200
R8643 n1_M2_81060_68100 n1_M2_82140_68100 0.988200
R8644 n1_M2_82140_68100 n1_M2_83220_68100 0.988200
R8645 n1_M2_83220_68100 n1_M2_84300_68100 0.988200
R8646 n1_M2_84300_68100 n1_M2_85380_68100 0.988200
R8647 n1_M2_85380_68100 n1_M2_86460_68100 0.988200
R8648 n1_M2_86460_68100 n1_M2_87540_68100 0.988200
R8649 n1_M2_87540_68100 n1_M2_88620_68100 0.988200
R8650 n1_M2_88620_68100 n1_M2_89700_68100 0.988200
R8651 n1_M2_89700_68100 n1_M2_90780_68100 0.988200
R8652 n1_M2_90780_68100 n1_M2_91860_68100 0.988200
R8653 n1_M2_91860_68100 n1_M2_92940_68100 0.988200
R8654 n1_M2_92940_68100 n1_M2_94020_68100 0.988200
R8655 n1_M2_94020_68100 n1_M2_95100_68100 0.988200
R8656 n1_M2_95100_68100 n1_M2_96180_68100 0.988200
R8657 n1_M2_96180_68100 n1_M2_97260_68100 0.988200
R8658 n1_M2_97260_68100 n1_M2_98340_68100 0.988200
R8659 n1_M2_98340_68100 n1_M2_99420_68100 0.988200
R8660 n1_M2_99420_68100 n1_M2_100500_68100 0.988200
R8661 n1_M2_100500_68100 n1_M2_101580_68100 0.988200
R8662 n1_M2_101580_68100 n1_M2_102660_68100 0.988200
R8663 n1_M2_102660_68100 n1_M2_103740_68100 0.988200
R8664 n1_M2_103740_68100 n1_M2_104820_68100 0.988200
R8665 n1_M2_104820_68100 n1_M2_105900_68100 0.988200
R8666 n1_M2_105900_68100 n1_M2_106980_68100 0.988200
R8667 n1_M2_106980_68100 n1_M2_108060_68100 0.988200
R8668 n1_M2_108060_68100 n1_M2_109140_68100 0.988200
R8669 n1_M2_109140_68100 n1_M2_110220_68100 0.988200
R8670 n1_M2_110220_68100 n1_M2_111300_68100 0.988200
R8671 n1_M2_111300_68100 n1_M2_112380_68100 0.988200
R8672 n1_M2_112380_68100 n1_M2_113460_68100 0.988200
R8673 n1_M2_113460_68100 n1_M2_114540_68100 0.988200
R8674 n1_M2_114540_68100 n1_M2_115620_68100 0.988200
R8675 n1_M2_115620_68100 n1_M2_116700_68100 0.988200
R8676 n1_M2_116700_68100 n1_M2_117780_68100 0.988200
R8677 n1_M2_117780_68100 n1_M2_118860_68100 0.988200
R8678 n1_M2_118860_68100 n1_M2_119940_68100 0.988200
R8679 n1_M2_119940_68100 n1_M2_121020_68100 0.988200
R8680 n1_M2_121020_68100 n1_M2_122100_68100 0.988200
R8681 n1_M2_122100_68100 n1_M2_123180_68100 0.988200
R8682 n1_M2_123180_68100 n1_M2_124260_68100 0.988200
R8683 n1_M2_124260_68100 n1_M2_125340_68100 0.988200
R8684 n1_M2_125340_68100 n1_M2_126420_68100 0.988200
R8685 n1_M2_126420_68100 n1_M2_127500_68100 0.988200
R8686 n1_M2_127500_68100 n1_M2_128580_68100 0.988200
R8687 n1_M2_128580_68100 n1_M2_129660_68100 0.988200
R8688 n1_M2_129660_68100 n1_M2_130740_68100 0.988200
R8689 n1_M2_130740_68100 n1_M2_131820_68100 0.988200
R8690 n1_M2_131820_68100 n1_M2_132900_68100 0.988200
R8691 n1_M2_132900_68100 n1_M2_133980_68100 0.988200
R8692 n1_M2_133980_68100 n1_M2_135060_68100 0.988200
R8693 n1_M2_135060_68100 n1_M2_136140_68100 0.988200
R8694 n1_M2_136140_68100 n1_M2_137220_68100 0.988200
R8695 n1_M2_137220_68100 n1_M2_138300_68100 0.988200
R8696 n1_M2_138300_68100 n1_M2_139380_68100 0.988200
R8697 n1_M2_139380_68100 n1_M2_140460_68100 0.988200
R8698 n1_M2_140460_68100 n1_M2_141540_68100 0.988200
R8699 n1_M2_141540_68100 n1_M2_142620_68100 0.988200
R8700 n1_M2_142620_68100 n1_M2_143700_68100 0.988200
R8701 n1_M2_143700_68100 n1_M2_144780_68100 0.988200
R8702 n1_M2_144780_68100 n1_M2_145860_68100 0.988200
R8703 n1_M2_145860_68100 n1_M2_146940_68100 0.988200
R8704 n1_M2_60_69180 n1_M2_1140_69180 0.988200
R8705 n1_M2_1140_69180 n1_M2_2220_69180 0.988200
R8706 n1_M2_2220_69180 n1_M2_3300_69180 0.988200
R8707 n1_M2_3300_69180 n1_M2_4380_69180 0.988200
R8708 n1_M2_4380_69180 n1_M2_5460_69180 0.988200
R8709 n1_M2_5460_69180 n1_M2_6540_69180 0.988200
R8710 n1_M2_6540_69180 n1_M2_7620_69180 0.988200
R8711 n1_M2_7620_69180 n1_M2_8700_69180 0.988200
R8712 n1_M2_8700_69180 n1_M2_9780_69180 0.988200
R8713 n1_M2_9780_69180 n1_M2_10860_69180 0.988200
R8714 n1_M2_10860_69180 n1_M2_11940_69180 0.988200
R8715 n1_M2_11940_69180 n1_M2_13020_69180 0.988200
R8716 n1_M2_13020_69180 n1_M2_14100_69180 0.988200
R8717 n1_M2_14100_69180 n1_M2_15180_69180 0.988200
R8718 n1_M2_15180_69180 n1_M2_16260_69180 0.988200
R8719 n1_M2_16260_69180 n1_M2_17340_69180 0.988200
R8720 n1_M2_17340_69180 n1_M2_18420_69180 0.988200
R8721 n1_M2_18420_69180 n1_M2_19500_69180 0.988200
R8722 n1_M2_19500_69180 n1_M2_20580_69180 0.988200
R8723 n1_M2_20580_69180 n1_M2_21660_69180 0.988200
R8724 n1_M2_21660_69180 n1_M2_22740_69180 0.988200
R8725 n1_M2_22740_69180 n1_M2_23820_69180 0.988200
R8726 n1_M2_23820_69180 n1_M2_24900_69180 0.988200
R8727 n1_M2_24900_69180 n1_M2_25980_69180 0.988200
R8728 n1_M2_25980_69180 n1_M2_27060_69180 0.988200
R8729 n1_M2_27060_69180 n1_M2_28140_69180 0.988200
R8730 n1_M2_28140_69180 n1_M2_29220_69180 0.988200
R8731 n1_M2_29220_69180 n1_M2_30300_69180 0.988200
R8732 n1_M2_30300_69180 n1_M2_31380_69180 0.988200
R8733 n1_M2_31380_69180 n1_M2_32460_69180 0.988200
R8734 n1_M2_32460_69180 n1_M2_33540_69180 0.988200
R8735 n1_M2_33540_69180 n1_M2_34620_69180 0.988200
R8736 n1_M2_34620_69180 n1_M2_35700_69180 0.988200
R8737 n1_M2_35700_69180 n1_M2_36780_69180 0.988200
R8738 n1_M2_36780_69180 n1_M2_37860_69180 0.988200
R8739 n1_M2_37860_69180 n1_M2_38940_69180 0.988200
R8740 n1_M2_38940_69180 n1_M2_40020_69180 0.988200
R8741 n1_M2_40020_69180 n1_M2_41100_69180 0.988200
R8742 n1_M2_41100_69180 n1_M2_42180_69180 0.988200
R8743 n1_M2_42180_69180 n1_M2_43260_69180 0.988200
R8744 n1_M2_43260_69180 n1_M2_44340_69180 0.988200
R8745 n1_M2_44340_69180 n1_M2_45420_69180 0.988200
R8746 n1_M2_45420_69180 n1_M2_46500_69180 0.988200
R8747 n1_M2_46500_69180 n1_M2_47580_69180 0.988200
R8748 n1_M2_47580_69180 n1_M2_48660_69180 0.988200
R8749 n1_M2_48660_69180 n1_M2_49740_69180 0.988200
R8750 n1_M2_49740_69180 n1_M2_50820_69180 0.988200
R8751 n1_M2_50820_69180 n1_M2_51900_69180 0.988200
R8752 n1_M2_51900_69180 n1_M2_52980_69180 0.988200
R8753 n1_M2_52980_69180 n1_M2_54060_69180 0.988200
R8754 n1_M2_54060_69180 n1_M2_55140_69180 0.988200
R8755 n1_M2_55140_69180 n1_M2_56220_69180 0.988200
R8756 n1_M2_56220_69180 n1_M2_57300_69180 0.988200
R8757 n1_M2_57300_69180 n1_M2_58380_69180 0.988200
R8758 n1_M2_58380_69180 n1_M2_59460_69180 0.988200
R8759 n1_M2_59460_69180 n1_M2_60540_69180 0.988200
R8760 n1_M2_60540_69180 n1_M2_61620_69180 0.988200
R8761 n1_M2_61620_69180 n1_M2_62700_69180 0.988200
R8762 n1_M2_62700_69180 n1_M2_63780_69180 0.988200
R8763 n1_M2_63780_69180 n1_M2_64860_69180 0.988200
R8764 n1_M2_64860_69180 n1_M2_65940_69180 0.988200
R8765 n1_M2_65940_69180 n1_M2_67020_69180 0.988200
R8766 n1_M2_67020_69180 n1_M2_68100_69180 0.988200
R8767 n1_M2_68100_69180 n1_M2_69180_69180 0.988200
R8768 n1_M2_69180_69180 n1_M2_70260_69180 0.988200
R8769 n1_M2_70260_69180 n1_M2_71340_69180 0.988200
R8770 n1_M2_71340_69180 n1_M2_72420_69180 0.988200
R8771 n1_M2_72420_69180 n1_M2_73500_69180 0.988200
R8772 n1_M2_73500_69180 n1_M2_74580_69180 0.988200
R8773 n1_M2_74580_69180 n1_M2_75660_69180 0.988200
R8774 n1_M2_75660_69180 n1_M2_76740_69180 0.988200
R8775 n1_M2_76740_69180 n1_M2_77820_69180 0.988200
R8776 n1_M2_77820_69180 n1_M2_78900_69180 0.988200
R8777 n1_M2_78900_69180 n1_M2_79980_69180 0.988200
R8778 n1_M2_79980_69180 n1_M2_81060_69180 0.988200
R8779 n1_M2_81060_69180 n1_M2_82140_69180 0.988200
R8780 n1_M2_82140_69180 n1_M2_83220_69180 0.988200
R8781 n1_M2_83220_69180 n1_M2_84300_69180 0.988200
R8782 n1_M2_84300_69180 n1_M2_85380_69180 0.988200
R8783 n1_M2_85380_69180 n1_M2_86460_69180 0.988200
R8784 n1_M2_86460_69180 n1_M2_87540_69180 0.988200
R8785 n1_M2_87540_69180 n1_M2_88620_69180 0.988200
R8786 n1_M2_88620_69180 n1_M2_89700_69180 0.988200
R8787 n1_M2_89700_69180 n1_M2_90780_69180 0.988200
R8788 n1_M2_90780_69180 n1_M2_91860_69180 0.988200
R8789 n1_M2_91860_69180 n1_M2_92940_69180 0.988200
R8790 n1_M2_92940_69180 n1_M2_94020_69180 0.988200
R8791 n1_M2_94020_69180 n1_M2_95100_69180 0.988200
R8792 n1_M2_95100_69180 n1_M2_96180_69180 0.988200
R8793 n1_M2_96180_69180 n1_M2_97260_69180 0.988200
R8794 n1_M2_97260_69180 n1_M2_98340_69180 0.988200
R8795 n1_M2_98340_69180 n1_M2_99420_69180 0.988200
R8796 n1_M2_99420_69180 n1_M2_100500_69180 0.988200
R8797 n1_M2_100500_69180 n1_M2_101580_69180 0.988200
R8798 n1_M2_101580_69180 n1_M2_102660_69180 0.988200
R8799 n1_M2_102660_69180 n1_M2_103740_69180 0.988200
R8800 n1_M2_103740_69180 n1_M2_104820_69180 0.988200
R8801 n1_M2_104820_69180 n1_M2_105900_69180 0.988200
R8802 n1_M2_105900_69180 n1_M2_106980_69180 0.988200
R8803 n1_M2_106980_69180 n1_M2_108060_69180 0.988200
R8804 n1_M2_108060_69180 n1_M2_109140_69180 0.988200
R8805 n1_M2_109140_69180 n1_M2_110220_69180 0.988200
R8806 n1_M2_110220_69180 n1_M2_111300_69180 0.988200
R8807 n1_M2_111300_69180 n1_M2_112380_69180 0.988200
R8808 n1_M2_112380_69180 n1_M2_113460_69180 0.988200
R8809 n1_M2_113460_69180 n1_M2_114540_69180 0.988200
R8810 n1_M2_114540_69180 n1_M2_115620_69180 0.988200
R8811 n1_M2_115620_69180 n1_M2_116700_69180 0.988200
R8812 n1_M2_116700_69180 n1_M2_117780_69180 0.988200
R8813 n1_M2_117780_69180 n1_M2_118860_69180 0.988200
R8814 n1_M2_118860_69180 n1_M2_119940_69180 0.988200
R8815 n1_M2_119940_69180 n1_M2_121020_69180 0.988200
R8816 n1_M2_121020_69180 n1_M2_122100_69180 0.988200
R8817 n1_M2_122100_69180 n1_M2_123180_69180 0.988200
R8818 n1_M2_123180_69180 n1_M2_124260_69180 0.988200
R8819 n1_M2_124260_69180 n1_M2_125340_69180 0.988200
R8820 n1_M2_125340_69180 n1_M2_126420_69180 0.988200
R8821 n1_M2_126420_69180 n1_M2_127500_69180 0.988200
R8822 n1_M2_127500_69180 n1_M2_128580_69180 0.988200
R8823 n1_M2_128580_69180 n1_M2_129660_69180 0.988200
R8824 n1_M2_129660_69180 n1_M2_130740_69180 0.988200
R8825 n1_M2_130740_69180 n1_M2_131820_69180 0.988200
R8826 n1_M2_131820_69180 n1_M2_132900_69180 0.988200
R8827 n1_M2_132900_69180 n1_M2_133980_69180 0.988200
R8828 n1_M2_133980_69180 n1_M2_135060_69180 0.988200
R8829 n1_M2_135060_69180 n1_M2_136140_69180 0.988200
R8830 n1_M2_136140_69180 n1_M2_137220_69180 0.988200
R8831 n1_M2_137220_69180 n1_M2_138300_69180 0.988200
R8832 n1_M2_138300_69180 n1_M2_139380_69180 0.988200
R8833 n1_M2_139380_69180 n1_M2_140460_69180 0.988200
R8834 n1_M2_140460_69180 n1_M2_141540_69180 0.988200
R8835 n1_M2_141540_69180 n1_M2_142620_69180 0.988200
R8836 n1_M2_142620_69180 n1_M2_143700_69180 0.988200
R8837 n1_M2_143700_69180 n1_M2_144780_69180 0.988200
R8838 n1_M2_144780_69180 n1_M2_145860_69180 0.988200
R8839 n1_M2_145860_69180 n1_M2_146940_69180 0.988200
R8840 n1_M2_60_70260 n1_M2_1140_70260 0.988200
R8841 n1_M2_1140_70260 n1_M2_2220_70260 0.988200
R8842 n1_M2_2220_70260 n1_M2_3300_70260 0.988200
R8843 n1_M2_3300_70260 n1_M2_4380_70260 0.988200
R8844 n1_M2_4380_70260 n1_M2_5460_70260 0.988200
R8845 n1_M2_5460_70260 n1_M2_6540_70260 0.988200
R8846 n1_M2_6540_70260 n1_M2_7620_70260 0.988200
R8847 n1_M2_7620_70260 n1_M2_8700_70260 0.988200
R8848 n1_M2_8700_70260 n1_M2_9780_70260 0.988200
R8849 n1_M2_9780_70260 n1_M2_10860_70260 0.988200
R8850 n1_M2_10860_70260 n1_M2_11940_70260 0.988200
R8851 n1_M2_11940_70260 n1_M2_13020_70260 0.988200
R8852 n1_M2_13020_70260 n1_M2_14100_70260 0.988200
R8853 n1_M2_14100_70260 n1_M2_15180_70260 0.988200
R8854 n1_M2_15180_70260 n1_M2_16260_70260 0.988200
R8855 n1_M2_16260_70260 n1_M2_17340_70260 0.988200
R8856 n1_M2_17340_70260 n1_M2_18420_70260 0.988200
R8857 n1_M2_18420_70260 n1_M2_19500_70260 0.988200
R8858 n1_M2_19500_70260 n1_M2_20580_70260 0.988200
R8859 n1_M2_20580_70260 n1_M2_21660_70260 0.988200
R8860 n1_M2_21660_70260 n1_M2_22740_70260 0.988200
R8861 n1_M2_22740_70260 n1_M2_23820_70260 0.988200
R8862 n1_M2_23820_70260 n1_M2_24900_70260 0.988200
R8863 n1_M2_24900_70260 n1_M2_25980_70260 0.988200
R8864 n1_M2_25980_70260 n1_M2_27060_70260 0.988200
R8865 n1_M2_27060_70260 n1_M2_28140_70260 0.988200
R8866 n1_M2_28140_70260 n1_M2_29220_70260 0.988200
R8867 n1_M2_29220_70260 n1_M2_30300_70260 0.988200
R8868 n1_M2_30300_70260 n1_M2_31380_70260 0.988200
R8869 n1_M2_31380_70260 n1_M2_32460_70260 0.988200
R8870 n1_M2_32460_70260 n1_M2_33540_70260 0.988200
R8871 n1_M2_33540_70260 n1_M2_34620_70260 0.988200
R8872 n1_M2_34620_70260 n1_M2_35700_70260 0.988200
R8873 n1_M2_35700_70260 n1_M2_36780_70260 0.988200
R8874 n1_M2_36780_70260 n1_M2_37860_70260 0.988200
R8875 n1_M2_37860_70260 n1_M2_38940_70260 0.988200
R8876 n1_M2_38940_70260 n1_M2_40020_70260 0.988200
R8877 n1_M2_40020_70260 n1_M2_41100_70260 0.988200
R8878 n1_M2_41100_70260 n1_M2_42180_70260 0.988200
R8879 n1_M2_42180_70260 n1_M2_43260_70260 0.988200
R8880 n1_M2_43260_70260 n1_M2_44340_70260 0.988200
R8881 n1_M2_44340_70260 n1_M2_45420_70260 0.988200
R8882 n1_M2_45420_70260 n1_M2_46500_70260 0.988200
R8883 n1_M2_46500_70260 n1_M2_47580_70260 0.988200
R8884 n1_M2_47580_70260 n1_M2_48660_70260 0.988200
R8885 n1_M2_48660_70260 n1_M2_49740_70260 0.988200
R8886 n1_M2_49740_70260 n1_M2_50820_70260 0.988200
R8887 n1_M2_50820_70260 n1_M2_51900_70260 0.988200
R8888 n1_M2_51900_70260 n1_M2_52980_70260 0.988200
R8889 n1_M2_52980_70260 n1_M2_54060_70260 0.988200
R8890 n1_M2_54060_70260 n1_M2_55140_70260 0.988200
R8891 n1_M2_55140_70260 n1_M2_56220_70260 0.988200
R8892 n1_M2_56220_70260 n1_M2_57300_70260 0.988200
R8893 n1_M2_57300_70260 n1_M2_58380_70260 0.988200
R8894 n1_M2_58380_70260 n1_M2_59460_70260 0.988200
R8895 n1_M2_59460_70260 n1_M2_60540_70260 0.988200
R8896 n1_M2_60540_70260 n1_M2_61620_70260 0.988200
R8897 n1_M2_61620_70260 n1_M2_62700_70260 0.988200
R8898 n1_M2_62700_70260 n1_M2_63780_70260 0.988200
R8899 n1_M2_63780_70260 n1_M2_64860_70260 0.988200
R8900 n1_M2_64860_70260 n1_M2_65940_70260 0.988200
R8901 n1_M2_65940_70260 n1_M2_67020_70260 0.988200
R8902 n1_M2_67020_70260 n1_M2_68100_70260 0.988200
R8903 n1_M2_68100_70260 n1_M2_69180_70260 0.988200
R8904 n1_M2_69180_70260 n1_M2_70260_70260 0.988200
R8905 n1_M2_70260_70260 n1_M2_71340_70260 0.988200
R8906 n1_M2_71340_70260 n1_M2_72420_70260 0.988200
R8907 n1_M2_72420_70260 n1_M2_73500_70260 0.988200
R8908 n1_M2_73500_70260 n1_M2_74580_70260 0.988200
R8909 n1_M2_74580_70260 n1_M2_75660_70260 0.988200
R8910 n1_M2_75660_70260 n1_M2_76740_70260 0.988200
R8911 n1_M2_76740_70260 n1_M2_77820_70260 0.988200
R8912 n1_M2_77820_70260 n1_M2_78900_70260 0.988200
R8913 n1_M2_78900_70260 n1_M2_79980_70260 0.988200
R8914 n1_M2_79980_70260 n1_M2_81060_70260 0.988200
R8915 n1_M2_81060_70260 n1_M2_82140_70260 0.988200
R8916 n1_M2_82140_70260 n1_M2_83220_70260 0.988200
R8917 n1_M2_83220_70260 n1_M2_84300_70260 0.988200
R8918 n1_M2_84300_70260 n1_M2_85380_70260 0.988200
R8919 n1_M2_85380_70260 n1_M2_86460_70260 0.988200
R8920 n1_M2_86460_70260 n1_M2_87540_70260 0.988200
R8921 n1_M2_87540_70260 n1_M2_88620_70260 0.988200
R8922 n1_M2_88620_70260 n1_M2_89700_70260 0.988200
R8923 n1_M2_89700_70260 n1_M2_90780_70260 0.988200
R8924 n1_M2_90780_70260 n1_M2_91860_70260 0.988200
R8925 n1_M2_91860_70260 n1_M2_92940_70260 0.988200
R8926 n1_M2_92940_70260 n1_M2_94020_70260 0.988200
R8927 n1_M2_94020_70260 n1_M2_95100_70260 0.988200
R8928 n1_M2_95100_70260 n1_M2_96180_70260 0.988200
R8929 n1_M2_96180_70260 n1_M2_97260_70260 0.988200
R8930 n1_M2_97260_70260 n1_M2_98340_70260 0.988200
R8931 n1_M2_98340_70260 n1_M2_99420_70260 0.988200
R8932 n1_M2_99420_70260 n1_M2_100500_70260 0.988200
R8933 n1_M2_100500_70260 n1_M2_101580_70260 0.988200
R8934 n1_M2_101580_70260 n1_M2_102660_70260 0.988200
R8935 n1_M2_102660_70260 n1_M2_103740_70260 0.988200
R8936 n1_M2_103740_70260 n1_M2_104820_70260 0.988200
R8937 n1_M2_104820_70260 n1_M2_105900_70260 0.988200
R8938 n1_M2_105900_70260 n1_M2_106980_70260 0.988200
R8939 n1_M2_106980_70260 n1_M2_108060_70260 0.988200
R8940 n1_M2_108060_70260 n1_M2_109140_70260 0.988200
R8941 n1_M2_109140_70260 n1_M2_110220_70260 0.988200
R8942 n1_M2_110220_70260 n1_M2_111300_70260 0.988200
R8943 n1_M2_111300_70260 n1_M2_112380_70260 0.988200
R8944 n1_M2_112380_70260 n1_M2_113460_70260 0.988200
R8945 n1_M2_113460_70260 n1_M2_114540_70260 0.988200
R8946 n1_M2_114540_70260 n1_M2_115620_70260 0.988200
R8947 n1_M2_115620_70260 n1_M2_116700_70260 0.988200
R8948 n1_M2_116700_70260 n1_M2_117780_70260 0.988200
R8949 n1_M2_117780_70260 n1_M2_118860_70260 0.988200
R8950 n1_M2_118860_70260 n1_M2_119940_70260 0.988200
R8951 n1_M2_119940_70260 n1_M2_121020_70260 0.988200
R8952 n1_M2_121020_70260 n1_M2_122100_70260 0.988200
R8953 n1_M2_122100_70260 n1_M2_123180_70260 0.988200
R8954 n1_M2_123180_70260 n1_M2_124260_70260 0.988200
R8955 n1_M2_124260_70260 n1_M2_125340_70260 0.988200
R8956 n1_M2_125340_70260 n1_M2_126420_70260 0.988200
R8957 n1_M2_126420_70260 n1_M2_127500_70260 0.988200
R8958 n1_M2_127500_70260 n1_M2_128580_70260 0.988200
R8959 n1_M2_128580_70260 n1_M2_129660_70260 0.988200
R8960 n1_M2_129660_70260 n1_M2_130740_70260 0.988200
R8961 n1_M2_130740_70260 n1_M2_131820_70260 0.988200
R8962 n1_M2_131820_70260 n1_M2_132900_70260 0.988200
R8963 n1_M2_132900_70260 n1_M2_133980_70260 0.988200
R8964 n1_M2_133980_70260 n1_M2_135060_70260 0.988200
R8965 n1_M2_135060_70260 n1_M2_136140_70260 0.988200
R8966 n1_M2_136140_70260 n1_M2_137220_70260 0.988200
R8967 n1_M2_137220_70260 n1_M2_138300_70260 0.988200
R8968 n1_M2_138300_70260 n1_M2_139380_70260 0.988200
R8969 n1_M2_139380_70260 n1_M2_140460_70260 0.988200
R8970 n1_M2_140460_70260 n1_M2_141540_70260 0.988200
R8971 n1_M2_141540_70260 n1_M2_142620_70260 0.988200
R8972 n1_M2_142620_70260 n1_M2_143700_70260 0.988200
R8973 n1_M2_143700_70260 n1_M2_144780_70260 0.988200
R8974 n1_M2_144780_70260 n1_M2_145860_70260 0.988200
R8975 n1_M2_145860_70260 n1_M2_146940_70260 0.988200
R8976 n1_M2_60_71340 n1_M2_1140_71340 0.988200
R8977 n1_M2_1140_71340 n1_M2_2220_71340 0.988200
R8978 n1_M2_2220_71340 n1_M2_3300_71340 0.988200
R8979 n1_M2_3300_71340 n1_M2_4380_71340 0.988200
R8980 n1_M2_4380_71340 n1_M2_5460_71340 0.988200
R8981 n1_M2_5460_71340 n1_M2_6540_71340 0.988200
R8982 n1_M2_6540_71340 n1_M2_7620_71340 0.988200
R8983 n1_M2_7620_71340 n1_M2_8700_71340 0.988200
R8984 n1_M2_8700_71340 n1_M2_9780_71340 0.988200
R8985 n1_M2_9780_71340 n1_M2_10860_71340 0.988200
R8986 n1_M2_10860_71340 n1_M2_11940_71340 0.988200
R8987 n1_M2_11940_71340 n1_M2_13020_71340 0.988200
R8988 n1_M2_13020_71340 n1_M2_14100_71340 0.988200
R8989 n1_M2_14100_71340 n1_M2_15180_71340 0.988200
R8990 n1_M2_15180_71340 n1_M2_16260_71340 0.988200
R8991 n1_M2_16260_71340 n1_M2_17340_71340 0.988200
R8992 n1_M2_17340_71340 n1_M2_18420_71340 0.988200
R8993 n1_M2_18420_71340 n1_M2_19500_71340 0.988200
R8994 n1_M2_19500_71340 n1_M2_20580_71340 0.988200
R8995 n1_M2_20580_71340 n1_M2_21660_71340 0.988200
R8996 n1_M2_21660_71340 n1_M2_22740_71340 0.988200
R8997 n1_M2_22740_71340 n1_M2_23820_71340 0.988200
R8998 n1_M2_23820_71340 n1_M2_24900_71340 0.988200
R8999 n1_M2_24900_71340 n1_M2_25980_71340 0.988200
R9000 n1_M2_25980_71340 n1_M2_27060_71340 0.988200
R9001 n1_M2_27060_71340 n1_M2_28140_71340 0.988200
R9002 n1_M2_28140_71340 n1_M2_29220_71340 0.988200
R9003 n1_M2_29220_71340 n1_M2_30300_71340 0.988200
R9004 n1_M2_30300_71340 n1_M2_31380_71340 0.988200
R9005 n1_M2_31380_71340 n1_M2_32460_71340 0.988200
R9006 n1_M2_32460_71340 n1_M2_33540_71340 0.988200
R9007 n1_M2_33540_71340 n1_M2_34620_71340 0.988200
R9008 n1_M2_34620_71340 n1_M2_35700_71340 0.988200
R9009 n1_M2_35700_71340 n1_M2_36780_71340 0.988200
R9010 n1_M2_36780_71340 n1_M2_37860_71340 0.988200
R9011 n1_M2_37860_71340 n1_M2_38940_71340 0.988200
R9012 n1_M2_38940_71340 n1_M2_40020_71340 0.988200
R9013 n1_M2_40020_71340 n1_M2_41100_71340 0.988200
R9014 n1_M2_41100_71340 n1_M2_42180_71340 0.988200
R9015 n1_M2_42180_71340 n1_M2_43260_71340 0.988200
R9016 n1_M2_43260_71340 n1_M2_44340_71340 0.988200
R9017 n1_M2_44340_71340 n1_M2_45420_71340 0.988200
R9018 n1_M2_45420_71340 n1_M2_46500_71340 0.988200
R9019 n1_M2_46500_71340 n1_M2_47580_71340 0.988200
R9020 n1_M2_47580_71340 n1_M2_48660_71340 0.988200
R9021 n1_M2_48660_71340 n1_M2_49740_71340 0.988200
R9022 n1_M2_49740_71340 n1_M2_50820_71340 0.988200
R9023 n1_M2_50820_71340 n1_M2_51900_71340 0.988200
R9024 n1_M2_51900_71340 n1_M2_52980_71340 0.988200
R9025 n1_M2_52980_71340 n1_M2_54060_71340 0.988200
R9026 n1_M2_54060_71340 n1_M2_55140_71340 0.988200
R9027 n1_M2_55140_71340 n1_M2_56220_71340 0.988200
R9028 n1_M2_56220_71340 n1_M2_57300_71340 0.988200
R9029 n1_M2_57300_71340 n1_M2_58380_71340 0.988200
R9030 n1_M2_58380_71340 n1_M2_59460_71340 0.988200
R9031 n1_M2_59460_71340 n1_M2_60540_71340 0.988200
R9032 n1_M2_60540_71340 n1_M2_61620_71340 0.988200
R9033 n1_M2_61620_71340 n1_M2_62700_71340 0.988200
R9034 n1_M2_62700_71340 n1_M2_63780_71340 0.988200
R9035 n1_M2_63780_71340 n1_M2_64860_71340 0.988200
R9036 n1_M2_64860_71340 n1_M2_65940_71340 0.988200
R9037 n1_M2_65940_71340 n1_M2_67020_71340 0.988200
R9038 n1_M2_67020_71340 n1_M2_68100_71340 0.988200
R9039 n1_M2_68100_71340 n1_M2_69180_71340 0.988200
R9040 n1_M2_69180_71340 n1_M2_70260_71340 0.988200
R9041 n1_M2_70260_71340 n1_M2_71340_71340 0.988200
R9042 n1_M2_71340_71340 n1_M2_72420_71340 0.988200
R9043 n1_M2_72420_71340 n1_M2_73500_71340 0.988200
R9044 n1_M2_73500_71340 n1_M2_74580_71340 0.988200
R9045 n1_M2_74580_71340 n1_M2_75660_71340 0.988200
R9046 n1_M2_75660_71340 n1_M2_76740_71340 0.988200
R9047 n1_M2_76740_71340 n1_M2_77820_71340 0.988200
R9048 n1_M2_77820_71340 n1_M2_78900_71340 0.988200
R9049 n1_M2_78900_71340 n1_M2_79980_71340 0.988200
R9050 n1_M2_79980_71340 n1_M2_81060_71340 0.988200
R9051 n1_M2_81060_71340 n1_M2_82140_71340 0.988200
R9052 n1_M2_82140_71340 n1_M2_83220_71340 0.988200
R9053 n1_M2_83220_71340 n1_M2_84300_71340 0.988200
R9054 n1_M2_84300_71340 n1_M2_85380_71340 0.988200
R9055 n1_M2_85380_71340 n1_M2_86460_71340 0.988200
R9056 n1_M2_86460_71340 n1_M2_87540_71340 0.988200
R9057 n1_M2_87540_71340 n1_M2_88620_71340 0.988200
R9058 n1_M2_88620_71340 n1_M2_89700_71340 0.988200
R9059 n1_M2_89700_71340 n1_M2_90780_71340 0.988200
R9060 n1_M2_90780_71340 n1_M2_91860_71340 0.988200
R9061 n1_M2_91860_71340 n1_M2_92940_71340 0.988200
R9062 n1_M2_92940_71340 n1_M2_94020_71340 0.988200
R9063 n1_M2_94020_71340 n1_M2_95100_71340 0.988200
R9064 n1_M2_95100_71340 n1_M2_96180_71340 0.988200
R9065 n1_M2_96180_71340 n1_M2_97260_71340 0.988200
R9066 n1_M2_97260_71340 n1_M2_98340_71340 0.988200
R9067 n1_M2_98340_71340 n1_M2_99420_71340 0.988200
R9068 n1_M2_99420_71340 n1_M2_100500_71340 0.988200
R9069 n1_M2_100500_71340 n1_M2_101580_71340 0.988200
R9070 n1_M2_101580_71340 n1_M2_102660_71340 0.988200
R9071 n1_M2_102660_71340 n1_M2_103740_71340 0.988200
R9072 n1_M2_103740_71340 n1_M2_104820_71340 0.988200
R9073 n1_M2_104820_71340 n1_M2_105900_71340 0.988200
R9074 n1_M2_105900_71340 n1_M2_106980_71340 0.988200
R9075 n1_M2_106980_71340 n1_M2_108060_71340 0.988200
R9076 n1_M2_108060_71340 n1_M2_109140_71340 0.988200
R9077 n1_M2_109140_71340 n1_M2_110220_71340 0.988200
R9078 n1_M2_110220_71340 n1_M2_111300_71340 0.988200
R9079 n1_M2_111300_71340 n1_M2_112380_71340 0.988200
R9080 n1_M2_112380_71340 n1_M2_113460_71340 0.988200
R9081 n1_M2_113460_71340 n1_M2_114540_71340 0.988200
R9082 n1_M2_114540_71340 n1_M2_115620_71340 0.988200
R9083 n1_M2_115620_71340 n1_M2_116700_71340 0.988200
R9084 n1_M2_116700_71340 n1_M2_117780_71340 0.988200
R9085 n1_M2_117780_71340 n1_M2_118860_71340 0.988200
R9086 n1_M2_118860_71340 n1_M2_119940_71340 0.988200
R9087 n1_M2_119940_71340 n1_M2_121020_71340 0.988200
R9088 n1_M2_121020_71340 n1_M2_122100_71340 0.988200
R9089 n1_M2_122100_71340 n1_M2_123180_71340 0.988200
R9090 n1_M2_123180_71340 n1_M2_124260_71340 0.988200
R9091 n1_M2_124260_71340 n1_M2_125340_71340 0.988200
R9092 n1_M2_125340_71340 n1_M2_126420_71340 0.988200
R9093 n1_M2_126420_71340 n1_M2_127500_71340 0.988200
R9094 n1_M2_127500_71340 n1_M2_128580_71340 0.988200
R9095 n1_M2_128580_71340 n1_M2_129660_71340 0.988200
R9096 n1_M2_129660_71340 n1_M2_130740_71340 0.988200
R9097 n1_M2_130740_71340 n1_M2_131820_71340 0.988200
R9098 n1_M2_131820_71340 n1_M2_132900_71340 0.988200
R9099 n1_M2_132900_71340 n1_M2_133980_71340 0.988200
R9100 n1_M2_133980_71340 n1_M2_135060_71340 0.988200
R9101 n1_M2_135060_71340 n1_M2_136140_71340 0.988200
R9102 n1_M2_136140_71340 n1_M2_137220_71340 0.988200
R9103 n1_M2_137220_71340 n1_M2_138300_71340 0.988200
R9104 n1_M2_138300_71340 n1_M2_139380_71340 0.988200
R9105 n1_M2_139380_71340 n1_M2_140460_71340 0.988200
R9106 n1_M2_140460_71340 n1_M2_141540_71340 0.988200
R9107 n1_M2_141540_71340 n1_M2_142620_71340 0.988200
R9108 n1_M2_142620_71340 n1_M2_143700_71340 0.988200
R9109 n1_M2_143700_71340 n1_M2_144780_71340 0.988200
R9110 n1_M2_144780_71340 n1_M2_145860_71340 0.988200
R9111 n1_M2_145860_71340 n1_M2_146940_71340 0.988200
R9112 n1_M2_60_72420 n1_M2_1140_72420 0.988200
R9113 n1_M2_1140_72420 n1_M2_2220_72420 0.988200
R9114 n1_M2_2220_72420 n1_M2_3300_72420 0.988200
R9115 n1_M2_3300_72420 n1_M2_4380_72420 0.988200
R9116 n1_M2_4380_72420 n1_M2_5460_72420 0.988200
R9117 n1_M2_5460_72420 n1_M2_6540_72420 0.988200
R9118 n1_M2_6540_72420 n1_M2_7620_72420 0.988200
R9119 n1_M2_7620_72420 n1_M2_8700_72420 0.988200
R9120 n1_M2_8700_72420 n1_M2_9780_72420 0.988200
R9121 n1_M2_9780_72420 n1_M2_10860_72420 0.988200
R9122 n1_M2_10860_72420 n1_M2_11940_72420 0.988200
R9123 n1_M2_11940_72420 n1_M2_13020_72420 0.988200
R9124 n1_M2_13020_72420 n1_M2_14100_72420 0.988200
R9125 n1_M2_14100_72420 n1_M2_15180_72420 0.988200
R9126 n1_M2_15180_72420 n1_M2_16260_72420 0.988200
R9127 n1_M2_16260_72420 n1_M2_17340_72420 0.988200
R9128 n1_M2_17340_72420 n1_M2_18420_72420 0.988200
R9129 n1_M2_18420_72420 n1_M2_19500_72420 0.988200
R9130 n1_M2_19500_72420 n1_M2_20580_72420 0.988200
R9131 n1_M2_20580_72420 n1_M2_21660_72420 0.988200
R9132 n1_M2_21660_72420 n1_M2_22740_72420 0.988200
R9133 n1_M2_22740_72420 n1_M2_23820_72420 0.988200
R9134 n1_M2_23820_72420 n1_M2_24900_72420 0.988200
R9135 n1_M2_24900_72420 n1_M2_25980_72420 0.988200
R9136 n1_M2_25980_72420 n1_M2_27060_72420 0.988200
R9137 n1_M2_27060_72420 n1_M2_28140_72420 0.988200
R9138 n1_M2_28140_72420 n1_M2_29220_72420 0.988200
R9139 n1_M2_29220_72420 n1_M2_30300_72420 0.988200
R9140 n1_M2_30300_72420 n1_M2_31380_72420 0.988200
R9141 n1_M2_31380_72420 n1_M2_32460_72420 0.988200
R9142 n1_M2_32460_72420 n1_M2_33540_72420 0.988200
R9143 n1_M2_33540_72420 n1_M2_34620_72420 0.988200
R9144 n1_M2_34620_72420 n1_M2_35700_72420 0.988200
R9145 n1_M2_35700_72420 n1_M2_36780_72420 0.988200
R9146 n1_M2_36780_72420 n1_M2_37860_72420 0.988200
R9147 n1_M2_37860_72420 n1_M2_38940_72420 0.988200
R9148 n1_M2_38940_72420 n1_M2_40020_72420 0.988200
R9149 n1_M2_40020_72420 n1_M2_41100_72420 0.988200
R9150 n1_M2_41100_72420 n1_M2_42180_72420 0.988200
R9151 n1_M2_42180_72420 n1_M2_43260_72420 0.988200
R9152 n1_M2_43260_72420 n1_M2_44340_72420 0.988200
R9153 n1_M2_44340_72420 n1_M2_45420_72420 0.988200
R9154 n1_M2_45420_72420 n1_M2_46500_72420 0.988200
R9155 n1_M2_46500_72420 n1_M2_47580_72420 0.988200
R9156 n1_M2_47580_72420 n1_M2_48660_72420 0.988200
R9157 n1_M2_48660_72420 n1_M2_49740_72420 0.988200
R9158 n1_M2_49740_72420 n1_M2_50820_72420 0.988200
R9159 n1_M2_50820_72420 n1_M2_51900_72420 0.988200
R9160 n1_M2_51900_72420 n1_M2_52980_72420 0.988200
R9161 n1_M2_52980_72420 n1_M2_54060_72420 0.988200
R9162 n1_M2_54060_72420 n1_M2_55140_72420 0.988200
R9163 n1_M2_55140_72420 n1_M2_56220_72420 0.988200
R9164 n1_M2_56220_72420 n1_M2_57300_72420 0.988200
R9165 n1_M2_57300_72420 n1_M2_58380_72420 0.988200
R9166 n1_M2_58380_72420 n1_M2_59460_72420 0.988200
R9167 n1_M2_59460_72420 n1_M2_60540_72420 0.988200
R9168 n1_M2_60540_72420 n1_M2_61620_72420 0.988200
R9169 n1_M2_61620_72420 n1_M2_62700_72420 0.988200
R9170 n1_M2_62700_72420 n1_M2_63780_72420 0.988200
R9171 n1_M2_63780_72420 n1_M2_64860_72420 0.988200
R9172 n1_M2_64860_72420 n1_M2_65940_72420 0.988200
R9173 n1_M2_65940_72420 n1_M2_67020_72420 0.988200
R9174 n1_M2_67020_72420 n1_M2_68100_72420 0.988200
R9175 n1_M2_68100_72420 n1_M2_69180_72420 0.988200
R9176 n1_M2_69180_72420 n1_M2_70260_72420 0.988200
R9177 n1_M2_70260_72420 n1_M2_71340_72420 0.988200
R9178 n1_M2_71340_72420 n1_M2_72420_72420 0.988200
R9179 n1_M2_72420_72420 n1_M2_73500_72420 0.988200
R9180 n1_M2_73500_72420 n1_M2_74580_72420 0.988200
R9181 n1_M2_74580_72420 n1_M2_75660_72420 0.988200
R9182 n1_M2_75660_72420 n1_M2_76740_72420 0.988200
R9183 n1_M2_76740_72420 n1_M2_77820_72420 0.988200
R9184 n1_M2_77820_72420 n1_M2_78900_72420 0.988200
R9185 n1_M2_78900_72420 n1_M2_79980_72420 0.988200
R9186 n1_M2_79980_72420 n1_M2_81060_72420 0.988200
R9187 n1_M2_81060_72420 n1_M2_82140_72420 0.988200
R9188 n1_M2_82140_72420 n1_M2_83220_72420 0.988200
R9189 n1_M2_83220_72420 n1_M2_84300_72420 0.988200
R9190 n1_M2_84300_72420 n1_M2_85380_72420 0.988200
R9191 n1_M2_85380_72420 n1_M2_86460_72420 0.988200
R9192 n1_M2_86460_72420 n1_M2_87540_72420 0.988200
R9193 n1_M2_87540_72420 n1_M2_88620_72420 0.988200
R9194 n1_M2_88620_72420 n1_M2_89700_72420 0.988200
R9195 n1_M2_89700_72420 n1_M2_90780_72420 0.988200
R9196 n1_M2_90780_72420 n1_M2_91860_72420 0.988200
R9197 n1_M2_91860_72420 n1_M2_92940_72420 0.988200
R9198 n1_M2_92940_72420 n1_M2_94020_72420 0.988200
R9199 n1_M2_94020_72420 n1_M2_95100_72420 0.988200
R9200 n1_M2_95100_72420 n1_M2_96180_72420 0.988200
R9201 n1_M2_96180_72420 n1_M2_97260_72420 0.988200
R9202 n1_M2_97260_72420 n1_M2_98340_72420 0.988200
R9203 n1_M2_98340_72420 n1_M2_99420_72420 0.988200
R9204 n1_M2_99420_72420 n1_M2_100500_72420 0.988200
R9205 n1_M2_100500_72420 n1_M2_101580_72420 0.988200
R9206 n1_M2_101580_72420 n1_M2_102660_72420 0.988200
R9207 n1_M2_102660_72420 n1_M2_103740_72420 0.988200
R9208 n1_M2_103740_72420 n1_M2_104820_72420 0.988200
R9209 n1_M2_104820_72420 n1_M2_105900_72420 0.988200
R9210 n1_M2_105900_72420 n1_M2_106980_72420 0.988200
R9211 n1_M2_106980_72420 n1_M2_108060_72420 0.988200
R9212 n1_M2_108060_72420 n1_M2_109140_72420 0.988200
R9213 n1_M2_109140_72420 n1_M2_110220_72420 0.988200
R9214 n1_M2_110220_72420 n1_M2_111300_72420 0.988200
R9215 n1_M2_111300_72420 n1_M2_112380_72420 0.988200
R9216 n1_M2_112380_72420 n1_M2_113460_72420 0.988200
R9217 n1_M2_113460_72420 n1_M2_114540_72420 0.988200
R9218 n1_M2_114540_72420 n1_M2_115620_72420 0.988200
R9219 n1_M2_115620_72420 n1_M2_116700_72420 0.988200
R9220 n1_M2_116700_72420 n1_M2_117780_72420 0.988200
R9221 n1_M2_117780_72420 n1_M2_118860_72420 0.988200
R9222 n1_M2_118860_72420 n1_M2_119940_72420 0.988200
R9223 n1_M2_119940_72420 n1_M2_121020_72420 0.988200
R9224 n1_M2_121020_72420 n1_M2_122100_72420 0.988200
R9225 n1_M2_122100_72420 n1_M2_123180_72420 0.988200
R9226 n1_M2_123180_72420 n1_M2_124260_72420 0.988200
R9227 n1_M2_124260_72420 n1_M2_125340_72420 0.988200
R9228 n1_M2_125340_72420 n1_M2_126420_72420 0.988200
R9229 n1_M2_126420_72420 n1_M2_127500_72420 0.988200
R9230 n1_M2_127500_72420 n1_M2_128580_72420 0.988200
R9231 n1_M2_128580_72420 n1_M2_129660_72420 0.988200
R9232 n1_M2_129660_72420 n1_M2_130740_72420 0.988200
R9233 n1_M2_130740_72420 n1_M2_131820_72420 0.988200
R9234 n1_M2_131820_72420 n1_M2_132900_72420 0.988200
R9235 n1_M2_132900_72420 n1_M2_133980_72420 0.988200
R9236 n1_M2_133980_72420 n1_M2_135060_72420 0.988200
R9237 n1_M2_135060_72420 n1_M2_136140_72420 0.988200
R9238 n1_M2_136140_72420 n1_M2_137220_72420 0.988200
R9239 n1_M2_137220_72420 n1_M2_138300_72420 0.988200
R9240 n1_M2_138300_72420 n1_M2_139380_72420 0.988200
R9241 n1_M2_139380_72420 n1_M2_140460_72420 0.988200
R9242 n1_M2_140460_72420 n1_M2_141540_72420 0.988200
R9243 n1_M2_141540_72420 n1_M2_142620_72420 0.988200
R9244 n1_M2_142620_72420 n1_M2_143700_72420 0.988200
R9245 n1_M2_143700_72420 n1_M2_144780_72420 0.988200
R9246 n1_M2_144780_72420 n1_M2_145860_72420 0.988200
R9247 n1_M2_145860_72420 n1_M2_146940_72420 0.988200
R9248 n1_M2_60_73500 n1_M2_1140_73500 0.988200
R9249 n1_M2_1140_73500 n1_M2_2220_73500 0.988200
R9250 n1_M2_2220_73500 n1_M2_3300_73500 0.988200
R9251 n1_M2_3300_73500 n1_M2_4380_73500 0.988200
R9252 n1_M2_4380_73500 n1_M2_5460_73500 0.988200
R9253 n1_M2_5460_73500 n1_M2_6540_73500 0.988200
R9254 n1_M2_6540_73500 n1_M2_7620_73500 0.988200
R9255 n1_M2_7620_73500 n1_M2_8700_73500 0.988200
R9256 n1_M2_8700_73500 n1_M2_9780_73500 0.988200
R9257 n1_M2_9780_73500 n1_M2_10860_73500 0.988200
R9258 n1_M2_10860_73500 n1_M2_11940_73500 0.988200
R9259 n1_M2_11940_73500 n1_M2_13020_73500 0.988200
R9260 n1_M2_13020_73500 n1_M2_14100_73500 0.988200
R9261 n1_M2_14100_73500 n1_M2_15180_73500 0.988200
R9262 n1_M2_15180_73500 n1_M2_16260_73500 0.988200
R9263 n1_M2_16260_73500 n1_M2_17340_73500 0.988200
R9264 n1_M2_17340_73500 n1_M2_18420_73500 0.988200
R9265 n1_M2_18420_73500 n1_M2_19500_73500 0.988200
R9266 n1_M2_19500_73500 n1_M2_20580_73500 0.988200
R9267 n1_M2_20580_73500 n1_M2_21660_73500 0.988200
R9268 n1_M2_21660_73500 n1_M2_22740_73500 0.988200
R9269 n1_M2_22740_73500 n1_M2_23820_73500 0.988200
R9270 n1_M2_23820_73500 n1_M2_24900_73500 0.988200
R9271 n1_M2_24900_73500 n1_M2_25980_73500 0.988200
R9272 n1_M2_25980_73500 n1_M2_27060_73500 0.988200
R9273 n1_M2_27060_73500 n1_M2_28140_73500 0.988200
R9274 n1_M2_28140_73500 n1_M2_29220_73500 0.988200
R9275 n1_M2_29220_73500 n1_M2_30300_73500 0.988200
R9276 n1_M2_30300_73500 n1_M2_31380_73500 0.988200
R9277 n1_M2_31380_73500 n1_M2_32460_73500 0.988200
R9278 n1_M2_32460_73500 n1_M2_33540_73500 0.988200
R9279 n1_M2_33540_73500 n1_M2_34620_73500 0.988200
R9280 n1_M2_34620_73500 n1_M2_35700_73500 0.988200
R9281 n1_M2_35700_73500 n1_M2_36780_73500 0.988200
R9282 n1_M2_36780_73500 n1_M2_37860_73500 0.988200
R9283 n1_M2_37860_73500 n1_M2_38940_73500 0.988200
R9284 n1_M2_38940_73500 n1_M2_40020_73500 0.988200
R9285 n1_M2_40020_73500 n1_M2_41100_73500 0.988200
R9286 n1_M2_41100_73500 n1_M2_42180_73500 0.988200
R9287 n1_M2_42180_73500 n1_M2_43260_73500 0.988200
R9288 n1_M2_43260_73500 n1_M2_44340_73500 0.988200
R9289 n1_M2_44340_73500 n1_M2_45420_73500 0.988200
R9290 n1_M2_45420_73500 n1_M2_46500_73500 0.988200
R9291 n1_M2_46500_73500 n1_M2_47580_73500 0.988200
R9292 n1_M2_47580_73500 n1_M2_48660_73500 0.988200
R9293 n1_M2_48660_73500 n1_M2_49740_73500 0.988200
R9294 n1_M2_49740_73500 n1_M2_50820_73500 0.988200
R9295 n1_M2_50820_73500 n1_M2_51900_73500 0.988200
R9296 n1_M2_51900_73500 n1_M2_52980_73500 0.988200
R9297 n1_M2_52980_73500 n1_M2_54060_73500 0.988200
R9298 n1_M2_54060_73500 n1_M2_55140_73500 0.988200
R9299 n1_M2_55140_73500 n1_M2_56220_73500 0.988200
R9300 n1_M2_56220_73500 n1_M2_57300_73500 0.988200
R9301 n1_M2_57300_73500 n1_M2_58380_73500 0.988200
R9302 n1_M2_58380_73500 n1_M2_59460_73500 0.988200
R9303 n1_M2_59460_73500 n1_M2_60540_73500 0.988200
R9304 n1_M2_60540_73500 n1_M2_61620_73500 0.988200
R9305 n1_M2_61620_73500 n1_M2_62700_73500 0.988200
R9306 n1_M2_62700_73500 n1_M2_63780_73500 0.988200
R9307 n1_M2_63780_73500 n1_M2_64860_73500 0.988200
R9308 n1_M2_64860_73500 n1_M2_65940_73500 0.988200
R9309 n1_M2_65940_73500 n1_M2_67020_73500 0.988200
R9310 n1_M2_67020_73500 n1_M2_68100_73500 0.988200
R9311 n1_M2_68100_73500 n1_M2_69180_73500 0.988200
R9312 n1_M2_69180_73500 n1_M2_70260_73500 0.988200
R9313 n1_M2_70260_73500 n1_M2_71340_73500 0.988200
R9314 n1_M2_71340_73500 n1_M2_72420_73500 0.988200
R9315 n1_M2_72420_73500 n1_M2_73500_73500 0.988200
R9316 n1_M2_73500_73500 n1_M2_74580_73500 0.988200
R9317 n1_M2_74580_73500 n1_M2_75660_73500 0.988200
R9318 n1_M2_75660_73500 n1_M2_76740_73500 0.988200
R9319 n1_M2_76740_73500 n1_M2_77820_73500 0.988200
R9320 n1_M2_77820_73500 n1_M2_78900_73500 0.988200
R9321 n1_M2_78900_73500 n1_M2_79980_73500 0.988200
R9322 n1_M2_79980_73500 n1_M2_81060_73500 0.988200
R9323 n1_M2_81060_73500 n1_M2_82140_73500 0.988200
R9324 n1_M2_82140_73500 n1_M2_83220_73500 0.988200
R9325 n1_M2_83220_73500 n1_M2_84300_73500 0.988200
R9326 n1_M2_84300_73500 n1_M2_85380_73500 0.988200
R9327 n1_M2_85380_73500 n1_M2_86460_73500 0.988200
R9328 n1_M2_86460_73500 n1_M2_87540_73500 0.988200
R9329 n1_M2_87540_73500 n1_M2_88620_73500 0.988200
R9330 n1_M2_88620_73500 n1_M2_89700_73500 0.988200
R9331 n1_M2_89700_73500 n1_M2_90780_73500 0.988200
R9332 n1_M2_90780_73500 n1_M2_91860_73500 0.988200
R9333 n1_M2_91860_73500 n1_M2_92940_73500 0.988200
R9334 n1_M2_92940_73500 n1_M2_94020_73500 0.988200
R9335 n1_M2_94020_73500 n1_M2_95100_73500 0.988200
R9336 n1_M2_95100_73500 n1_M2_96180_73500 0.988200
R9337 n1_M2_96180_73500 n1_M2_97260_73500 0.988200
R9338 n1_M2_97260_73500 n1_M2_98340_73500 0.988200
R9339 n1_M2_98340_73500 n1_M2_99420_73500 0.988200
R9340 n1_M2_99420_73500 n1_M2_100500_73500 0.988200
R9341 n1_M2_100500_73500 n1_M2_101580_73500 0.988200
R9342 n1_M2_101580_73500 n1_M2_102660_73500 0.988200
R9343 n1_M2_102660_73500 n1_M2_103740_73500 0.988200
R9344 n1_M2_103740_73500 n1_M2_104820_73500 0.988200
R9345 n1_M2_104820_73500 n1_M2_105900_73500 0.988200
R9346 n1_M2_105900_73500 n1_M2_106980_73500 0.988200
R9347 n1_M2_106980_73500 n1_M2_108060_73500 0.988200
R9348 n1_M2_108060_73500 n1_M2_109140_73500 0.988200
R9349 n1_M2_109140_73500 n1_M2_110220_73500 0.988200
R9350 n1_M2_110220_73500 n1_M2_111300_73500 0.988200
R9351 n1_M2_111300_73500 n1_M2_112380_73500 0.988200
R9352 n1_M2_112380_73500 n1_M2_113460_73500 0.988200
R9353 n1_M2_113460_73500 n1_M2_114540_73500 0.988200
R9354 n1_M2_114540_73500 n1_M2_115620_73500 0.988200
R9355 n1_M2_115620_73500 n1_M2_116700_73500 0.988200
R9356 n1_M2_116700_73500 n1_M2_117780_73500 0.988200
R9357 n1_M2_117780_73500 n1_M2_118860_73500 0.988200
R9358 n1_M2_118860_73500 n1_M2_119940_73500 0.988200
R9359 n1_M2_119940_73500 n1_M2_121020_73500 0.988200
R9360 n1_M2_121020_73500 n1_M2_122100_73500 0.988200
R9361 n1_M2_122100_73500 n1_M2_123180_73500 0.988200
R9362 n1_M2_123180_73500 n1_M2_124260_73500 0.988200
R9363 n1_M2_124260_73500 n1_M2_125340_73500 0.988200
R9364 n1_M2_125340_73500 n1_M2_126420_73500 0.988200
R9365 n1_M2_126420_73500 n1_M2_127500_73500 0.988200
R9366 n1_M2_127500_73500 n1_M2_128580_73500 0.988200
R9367 n1_M2_128580_73500 n1_M2_129660_73500 0.988200
R9368 n1_M2_129660_73500 n1_M2_130740_73500 0.988200
R9369 n1_M2_130740_73500 n1_M2_131820_73500 0.988200
R9370 n1_M2_131820_73500 n1_M2_132900_73500 0.988200
R9371 n1_M2_132900_73500 n1_M2_133980_73500 0.988200
R9372 n1_M2_133980_73500 n1_M2_135060_73500 0.988200
R9373 n1_M2_135060_73500 n1_M2_136140_73500 0.988200
R9374 n1_M2_136140_73500 n1_M2_137220_73500 0.988200
R9375 n1_M2_137220_73500 n1_M2_138300_73500 0.988200
R9376 n1_M2_138300_73500 n1_M2_139380_73500 0.988200
R9377 n1_M2_139380_73500 n1_M2_140460_73500 0.988200
R9378 n1_M2_140460_73500 n1_M2_141540_73500 0.988200
R9379 n1_M2_141540_73500 n1_M2_142620_73500 0.988200
R9380 n1_M2_142620_73500 n1_M2_143700_73500 0.988200
R9381 n1_M2_143700_73500 n1_M2_144780_73500 0.988200
R9382 n1_M2_144780_73500 n1_M2_145860_73500 0.988200
R9383 n1_M2_145860_73500 n1_M2_146940_73500 0.988200
R9384 n1_M2_60_74580 n1_M2_1140_74580 0.988200
R9385 n1_M2_1140_74580 n1_M2_2220_74580 0.988200
R9386 n1_M2_2220_74580 n1_M2_3300_74580 0.988200
R9387 n1_M2_3300_74580 n1_M2_4380_74580 0.988200
R9388 n1_M2_4380_74580 n1_M2_5460_74580 0.988200
R9389 n1_M2_5460_74580 n1_M2_6540_74580 0.988200
R9390 n1_M2_6540_74580 n1_M2_7620_74580 0.988200
R9391 n1_M2_7620_74580 n1_M2_8700_74580 0.988200
R9392 n1_M2_8700_74580 n1_M2_9780_74580 0.988200
R9393 n1_M2_9780_74580 n1_M2_10860_74580 0.988200
R9394 n1_M2_10860_74580 n1_M2_11940_74580 0.988200
R9395 n1_M2_11940_74580 n1_M2_13020_74580 0.988200
R9396 n1_M2_13020_74580 n1_M2_14100_74580 0.988200
R9397 n1_M2_14100_74580 n1_M2_15180_74580 0.988200
R9398 n1_M2_15180_74580 n1_M2_16260_74580 0.988200
R9399 n1_M2_16260_74580 n1_M2_17340_74580 0.988200
R9400 n1_M2_17340_74580 n1_M2_18420_74580 0.988200
R9401 n1_M2_18420_74580 n1_M2_19500_74580 0.988200
R9402 n1_M2_19500_74580 n1_M2_20580_74580 0.988200
R9403 n1_M2_20580_74580 n1_M2_21660_74580 0.988200
R9404 n1_M2_21660_74580 n1_M2_22740_74580 0.988200
R9405 n1_M2_22740_74580 n1_M2_23820_74580 0.988200
R9406 n1_M2_23820_74580 n1_M2_24900_74580 0.988200
R9407 n1_M2_24900_74580 n1_M2_25980_74580 0.988200
R9408 n1_M2_25980_74580 n1_M2_27060_74580 0.988200
R9409 n1_M2_27060_74580 n1_M2_28140_74580 0.988200
R9410 n1_M2_28140_74580 n1_M2_29220_74580 0.988200
R9411 n1_M2_29220_74580 n1_M2_30300_74580 0.988200
R9412 n1_M2_30300_74580 n1_M2_31380_74580 0.988200
R9413 n1_M2_31380_74580 n1_M2_32460_74580 0.988200
R9414 n1_M2_32460_74580 n1_M2_33540_74580 0.988200
R9415 n1_M2_33540_74580 n1_M2_34620_74580 0.988200
R9416 n1_M2_34620_74580 n1_M2_35700_74580 0.988200
R9417 n1_M2_35700_74580 n1_M2_36780_74580 0.988200
R9418 n1_M2_36780_74580 n1_M2_37860_74580 0.988200
R9419 n1_M2_37860_74580 n1_M2_38940_74580 0.988200
R9420 n1_M2_38940_74580 n1_M2_40020_74580 0.988200
R9421 n1_M2_40020_74580 n1_M2_41100_74580 0.988200
R9422 n1_M2_41100_74580 n1_M2_42180_74580 0.988200
R9423 n1_M2_42180_74580 n1_M2_43260_74580 0.988200
R9424 n1_M2_43260_74580 n1_M2_44340_74580 0.988200
R9425 n1_M2_44340_74580 n1_M2_45420_74580 0.988200
R9426 n1_M2_45420_74580 n1_M2_46500_74580 0.988200
R9427 n1_M2_46500_74580 n1_M2_47580_74580 0.988200
R9428 n1_M2_47580_74580 n1_M2_48660_74580 0.988200
R9429 n1_M2_48660_74580 n1_M2_49740_74580 0.988200
R9430 n1_M2_49740_74580 n1_M2_50820_74580 0.988200
R9431 n1_M2_50820_74580 n1_M2_51900_74580 0.988200
R9432 n1_M2_51900_74580 n1_M2_52980_74580 0.988200
R9433 n1_M2_52980_74580 n1_M2_54060_74580 0.988200
R9434 n1_M2_54060_74580 n1_M2_55140_74580 0.988200
R9435 n1_M2_55140_74580 n1_M2_56220_74580 0.988200
R9436 n1_M2_56220_74580 n1_M2_57300_74580 0.988200
R9437 n1_M2_57300_74580 n1_M2_58380_74580 0.988200
R9438 n1_M2_58380_74580 n1_M2_59460_74580 0.988200
R9439 n1_M2_59460_74580 n1_M2_60540_74580 0.988200
R9440 n1_M2_60540_74580 n1_M2_61620_74580 0.988200
R9441 n1_M2_61620_74580 n1_M2_62700_74580 0.988200
R9442 n1_M2_62700_74580 n1_M2_63780_74580 0.988200
R9443 n1_M2_63780_74580 n1_M2_64860_74580 0.988200
R9444 n1_M2_64860_74580 n1_M2_65940_74580 0.988200
R9445 n1_M2_65940_74580 n1_M2_67020_74580 0.988200
R9446 n1_M2_67020_74580 n1_M2_68100_74580 0.988200
R9447 n1_M2_68100_74580 n1_M2_69180_74580 0.988200
R9448 n1_M2_69180_74580 n1_M2_70260_74580 0.988200
R9449 n1_M2_70260_74580 n1_M2_71340_74580 0.988200
R9450 n1_M2_71340_74580 n1_M2_72420_74580 0.988200
R9451 n1_M2_72420_74580 n1_M2_73500_74580 0.988200
R9452 n1_M2_73500_74580 n1_M2_74580_74580 0.988200
R9453 n1_M2_74580_74580 n1_M2_75660_74580 0.988200
R9454 n1_M2_75660_74580 n1_M2_76740_74580 0.988200
R9455 n1_M2_76740_74580 n1_M2_77820_74580 0.988200
R9456 n1_M2_77820_74580 n1_M2_78900_74580 0.988200
R9457 n1_M2_78900_74580 n1_M2_79980_74580 0.988200
R9458 n1_M2_79980_74580 n1_M2_81060_74580 0.988200
R9459 n1_M2_81060_74580 n1_M2_82140_74580 0.988200
R9460 n1_M2_82140_74580 n1_M2_83220_74580 0.988200
R9461 n1_M2_83220_74580 n1_M2_84300_74580 0.988200
R9462 n1_M2_84300_74580 n1_M2_85380_74580 0.988200
R9463 n1_M2_85380_74580 n1_M2_86460_74580 0.988200
R9464 n1_M2_86460_74580 n1_M2_87540_74580 0.988200
R9465 n1_M2_87540_74580 n1_M2_88620_74580 0.988200
R9466 n1_M2_88620_74580 n1_M2_89700_74580 0.988200
R9467 n1_M2_89700_74580 n1_M2_90780_74580 0.988200
R9468 n1_M2_90780_74580 n1_M2_91860_74580 0.988200
R9469 n1_M2_91860_74580 n1_M2_92940_74580 0.988200
R9470 n1_M2_92940_74580 n1_M2_94020_74580 0.988200
R9471 n1_M2_94020_74580 n1_M2_95100_74580 0.988200
R9472 n1_M2_95100_74580 n1_M2_96180_74580 0.988200
R9473 n1_M2_96180_74580 n1_M2_97260_74580 0.988200
R9474 n1_M2_97260_74580 n1_M2_98340_74580 0.988200
R9475 n1_M2_98340_74580 n1_M2_99420_74580 0.988200
R9476 n1_M2_99420_74580 n1_M2_100500_74580 0.988200
R9477 n1_M2_100500_74580 n1_M2_101580_74580 0.988200
R9478 n1_M2_101580_74580 n1_M2_102660_74580 0.988200
R9479 n1_M2_102660_74580 n1_M2_103740_74580 0.988200
R9480 n1_M2_103740_74580 n1_M2_104820_74580 0.988200
R9481 n1_M2_104820_74580 n1_M2_105900_74580 0.988200
R9482 n1_M2_105900_74580 n1_M2_106980_74580 0.988200
R9483 n1_M2_106980_74580 n1_M2_108060_74580 0.988200
R9484 n1_M2_108060_74580 n1_M2_109140_74580 0.988200
R9485 n1_M2_109140_74580 n1_M2_110220_74580 0.988200
R9486 n1_M2_110220_74580 n1_M2_111300_74580 0.988200
R9487 n1_M2_111300_74580 n1_M2_112380_74580 0.988200
R9488 n1_M2_112380_74580 n1_M2_113460_74580 0.988200
R9489 n1_M2_113460_74580 n1_M2_114540_74580 0.988200
R9490 n1_M2_114540_74580 n1_M2_115620_74580 0.988200
R9491 n1_M2_115620_74580 n1_M2_116700_74580 0.988200
R9492 n1_M2_116700_74580 n1_M2_117780_74580 0.988200
R9493 n1_M2_117780_74580 n1_M2_118860_74580 0.988200
R9494 n1_M2_118860_74580 n1_M2_119940_74580 0.988200
R9495 n1_M2_119940_74580 n1_M2_121020_74580 0.988200
R9496 n1_M2_121020_74580 n1_M2_122100_74580 0.988200
R9497 n1_M2_122100_74580 n1_M2_123180_74580 0.988200
R9498 n1_M2_123180_74580 n1_M2_124260_74580 0.988200
R9499 n1_M2_124260_74580 n1_M2_125340_74580 0.988200
R9500 n1_M2_125340_74580 n1_M2_126420_74580 0.988200
R9501 n1_M2_126420_74580 n1_M2_127500_74580 0.988200
R9502 n1_M2_127500_74580 n1_M2_128580_74580 0.988200
R9503 n1_M2_128580_74580 n1_M2_129660_74580 0.988200
R9504 n1_M2_129660_74580 n1_M2_130740_74580 0.988200
R9505 n1_M2_130740_74580 n1_M2_131820_74580 0.988200
R9506 n1_M2_131820_74580 n1_M2_132900_74580 0.988200
R9507 n1_M2_132900_74580 n1_M2_133980_74580 0.988200
R9508 n1_M2_133980_74580 n1_M2_135060_74580 0.988200
R9509 n1_M2_135060_74580 n1_M2_136140_74580 0.988200
R9510 n1_M2_136140_74580 n1_M2_137220_74580 0.988200
R9511 n1_M2_137220_74580 n1_M2_138300_74580 0.988200
R9512 n1_M2_138300_74580 n1_M2_139380_74580 0.988200
R9513 n1_M2_139380_74580 n1_M2_140460_74580 0.988200
R9514 n1_M2_140460_74580 n1_M2_141540_74580 0.988200
R9515 n1_M2_141540_74580 n1_M2_142620_74580 0.988200
R9516 n1_M2_142620_74580 n1_M2_143700_74580 0.988200
R9517 n1_M2_143700_74580 n1_M2_144780_74580 0.988200
R9518 n1_M2_144780_74580 n1_M2_145860_74580 0.988200
R9519 n1_M2_145860_74580 n1_M2_146940_74580 0.988200
R9520 n1_M2_60_75660 n1_M2_1140_75660 0.988200
R9521 n1_M2_1140_75660 n1_M2_2220_75660 0.988200
R9522 n1_M2_2220_75660 n1_M2_3300_75660 0.988200
R9523 n1_M2_3300_75660 n1_M2_4380_75660 0.988200
R9524 n1_M2_4380_75660 n1_M2_5460_75660 0.988200
R9525 n1_M2_5460_75660 n1_M2_6540_75660 0.988200
R9526 n1_M2_6540_75660 n1_M2_7620_75660 0.988200
R9527 n1_M2_7620_75660 n1_M2_8700_75660 0.988200
R9528 n1_M2_8700_75660 n1_M2_9780_75660 0.988200
R9529 n1_M2_9780_75660 n1_M2_10860_75660 0.988200
R9530 n1_M2_10860_75660 n1_M2_11940_75660 0.988200
R9531 n1_M2_11940_75660 n1_M2_13020_75660 0.988200
R9532 n1_M2_13020_75660 n1_M2_14100_75660 0.988200
R9533 n1_M2_14100_75660 n1_M2_15180_75660 0.988200
R9534 n1_M2_15180_75660 n1_M2_16260_75660 0.988200
R9535 n1_M2_16260_75660 n1_M2_17340_75660 0.988200
R9536 n1_M2_17340_75660 n1_M2_18420_75660 0.988200
R9537 n1_M2_18420_75660 n1_M2_19500_75660 0.988200
R9538 n1_M2_19500_75660 n1_M2_20580_75660 0.988200
R9539 n1_M2_20580_75660 n1_M2_21660_75660 0.988200
R9540 n1_M2_21660_75660 n1_M2_22740_75660 0.988200
R9541 n1_M2_22740_75660 n1_M2_23820_75660 0.988200
R9542 n1_M2_23820_75660 n1_M2_24900_75660 0.988200
R9543 n1_M2_24900_75660 n1_M2_25980_75660 0.988200
R9544 n1_M2_25980_75660 n1_M2_27060_75660 0.988200
R9545 n1_M2_27060_75660 n1_M2_28140_75660 0.988200
R9546 n1_M2_28140_75660 n1_M2_29220_75660 0.988200
R9547 n1_M2_29220_75660 n1_M2_30300_75660 0.988200
R9548 n1_M2_30300_75660 n1_M2_31380_75660 0.988200
R9549 n1_M2_31380_75660 n1_M2_32460_75660 0.988200
R9550 n1_M2_32460_75660 n1_M2_33540_75660 0.988200
R9551 n1_M2_33540_75660 n1_M2_34620_75660 0.988200
R9552 n1_M2_34620_75660 n1_M2_35700_75660 0.988200
R9553 n1_M2_35700_75660 n1_M2_36780_75660 0.988200
R9554 n1_M2_36780_75660 n1_M2_37860_75660 0.988200
R9555 n1_M2_37860_75660 n1_M2_38940_75660 0.988200
R9556 n1_M2_38940_75660 n1_M2_40020_75660 0.988200
R9557 n1_M2_40020_75660 n1_M2_41100_75660 0.988200
R9558 n1_M2_41100_75660 n1_M2_42180_75660 0.988200
R9559 n1_M2_42180_75660 n1_M2_43260_75660 0.988200
R9560 n1_M2_43260_75660 n1_M2_44340_75660 0.988200
R9561 n1_M2_44340_75660 n1_M2_45420_75660 0.988200
R9562 n1_M2_45420_75660 n1_M2_46500_75660 0.988200
R9563 n1_M2_46500_75660 n1_M2_47580_75660 0.988200
R9564 n1_M2_47580_75660 n1_M2_48660_75660 0.988200
R9565 n1_M2_48660_75660 n1_M2_49740_75660 0.988200
R9566 n1_M2_49740_75660 n1_M2_50820_75660 0.988200
R9567 n1_M2_50820_75660 n1_M2_51900_75660 0.988200
R9568 n1_M2_51900_75660 n1_M2_52980_75660 0.988200
R9569 n1_M2_52980_75660 n1_M2_54060_75660 0.988200
R9570 n1_M2_54060_75660 n1_M2_55140_75660 0.988200
R9571 n1_M2_55140_75660 n1_M2_56220_75660 0.988200
R9572 n1_M2_56220_75660 n1_M2_57300_75660 0.988200
R9573 n1_M2_57300_75660 n1_M2_58380_75660 0.988200
R9574 n1_M2_58380_75660 n1_M2_59460_75660 0.988200
R9575 n1_M2_59460_75660 n1_M2_60540_75660 0.988200
R9576 n1_M2_60540_75660 n1_M2_61620_75660 0.988200
R9577 n1_M2_61620_75660 n1_M2_62700_75660 0.988200
R9578 n1_M2_62700_75660 n1_M2_63780_75660 0.988200
R9579 n1_M2_63780_75660 n1_M2_64860_75660 0.988200
R9580 n1_M2_64860_75660 n1_M2_65940_75660 0.988200
R9581 n1_M2_65940_75660 n1_M2_67020_75660 0.988200
R9582 n1_M2_67020_75660 n1_M2_68100_75660 0.988200
R9583 n1_M2_68100_75660 n1_M2_69180_75660 0.988200
R9584 n1_M2_69180_75660 n1_M2_70260_75660 0.988200
R9585 n1_M2_70260_75660 n1_M2_71340_75660 0.988200
R9586 n1_M2_71340_75660 n1_M2_72420_75660 0.988200
R9587 n1_M2_72420_75660 n1_M2_73500_75660 0.988200
R9588 n1_M2_73500_75660 n1_M2_74580_75660 0.988200
R9589 n1_M2_74580_75660 n1_M2_75660_75660 0.988200
R9590 n1_M2_75660_75660 n1_M2_76740_75660 0.988200
R9591 n1_M2_76740_75660 n1_M2_77820_75660 0.988200
R9592 n1_M2_77820_75660 n1_M2_78900_75660 0.988200
R9593 n1_M2_78900_75660 n1_M2_79980_75660 0.988200
R9594 n1_M2_79980_75660 n1_M2_81060_75660 0.988200
R9595 n1_M2_81060_75660 n1_M2_82140_75660 0.988200
R9596 n1_M2_82140_75660 n1_M2_83220_75660 0.988200
R9597 n1_M2_83220_75660 n1_M2_84300_75660 0.988200
R9598 n1_M2_84300_75660 n1_M2_85380_75660 0.988200
R9599 n1_M2_85380_75660 n1_M2_86460_75660 0.988200
R9600 n1_M2_86460_75660 n1_M2_87540_75660 0.988200
R9601 n1_M2_87540_75660 n1_M2_88620_75660 0.988200
R9602 n1_M2_88620_75660 n1_M2_89700_75660 0.988200
R9603 n1_M2_89700_75660 n1_M2_90780_75660 0.988200
R9604 n1_M2_90780_75660 n1_M2_91860_75660 0.988200
R9605 n1_M2_91860_75660 n1_M2_92940_75660 0.988200
R9606 n1_M2_92940_75660 n1_M2_94020_75660 0.988200
R9607 n1_M2_94020_75660 n1_M2_95100_75660 0.988200
R9608 n1_M2_95100_75660 n1_M2_96180_75660 0.988200
R9609 n1_M2_96180_75660 n1_M2_97260_75660 0.988200
R9610 n1_M2_97260_75660 n1_M2_98340_75660 0.988200
R9611 n1_M2_98340_75660 n1_M2_99420_75660 0.988200
R9612 n1_M2_99420_75660 n1_M2_100500_75660 0.988200
R9613 n1_M2_100500_75660 n1_M2_101580_75660 0.988200
R9614 n1_M2_101580_75660 n1_M2_102660_75660 0.988200
R9615 n1_M2_102660_75660 n1_M2_103740_75660 0.988200
R9616 n1_M2_103740_75660 n1_M2_104820_75660 0.988200
R9617 n1_M2_104820_75660 n1_M2_105900_75660 0.988200
R9618 n1_M2_105900_75660 n1_M2_106980_75660 0.988200
R9619 n1_M2_106980_75660 n1_M2_108060_75660 0.988200
R9620 n1_M2_108060_75660 n1_M2_109140_75660 0.988200
R9621 n1_M2_109140_75660 n1_M2_110220_75660 0.988200
R9622 n1_M2_110220_75660 n1_M2_111300_75660 0.988200
R9623 n1_M2_111300_75660 n1_M2_112380_75660 0.988200
R9624 n1_M2_112380_75660 n1_M2_113460_75660 0.988200
R9625 n1_M2_113460_75660 n1_M2_114540_75660 0.988200
R9626 n1_M2_114540_75660 n1_M2_115620_75660 0.988200
R9627 n1_M2_115620_75660 n1_M2_116700_75660 0.988200
R9628 n1_M2_116700_75660 n1_M2_117780_75660 0.988200
R9629 n1_M2_117780_75660 n1_M2_118860_75660 0.988200
R9630 n1_M2_118860_75660 n1_M2_119940_75660 0.988200
R9631 n1_M2_119940_75660 n1_M2_121020_75660 0.988200
R9632 n1_M2_121020_75660 n1_M2_122100_75660 0.988200
R9633 n1_M2_122100_75660 n1_M2_123180_75660 0.988200
R9634 n1_M2_123180_75660 n1_M2_124260_75660 0.988200
R9635 n1_M2_124260_75660 n1_M2_125340_75660 0.988200
R9636 n1_M2_125340_75660 n1_M2_126420_75660 0.988200
R9637 n1_M2_126420_75660 n1_M2_127500_75660 0.988200
R9638 n1_M2_127500_75660 n1_M2_128580_75660 0.988200
R9639 n1_M2_128580_75660 n1_M2_129660_75660 0.988200
R9640 n1_M2_129660_75660 n1_M2_130740_75660 0.988200
R9641 n1_M2_130740_75660 n1_M2_131820_75660 0.988200
R9642 n1_M2_131820_75660 n1_M2_132900_75660 0.988200
R9643 n1_M2_132900_75660 n1_M2_133980_75660 0.988200
R9644 n1_M2_133980_75660 n1_M2_135060_75660 0.988200
R9645 n1_M2_135060_75660 n1_M2_136140_75660 0.988200
R9646 n1_M2_136140_75660 n1_M2_137220_75660 0.988200
R9647 n1_M2_137220_75660 n1_M2_138300_75660 0.988200
R9648 n1_M2_138300_75660 n1_M2_139380_75660 0.988200
R9649 n1_M2_139380_75660 n1_M2_140460_75660 0.988200
R9650 n1_M2_140460_75660 n1_M2_141540_75660 0.988200
R9651 n1_M2_141540_75660 n1_M2_142620_75660 0.988200
R9652 n1_M2_142620_75660 n1_M2_143700_75660 0.988200
R9653 n1_M2_143700_75660 n1_M2_144780_75660 0.988200
R9654 n1_M2_144780_75660 n1_M2_145860_75660 0.988200
R9655 n1_M2_145860_75660 n1_M2_146940_75660 0.988200
R9656 n1_M2_60_76740 n1_M2_1140_76740 0.988200
R9657 n1_M2_1140_76740 n1_M2_2220_76740 0.988200
R9658 n1_M2_2220_76740 n1_M2_3300_76740 0.988200
R9659 n1_M2_3300_76740 n1_M2_4380_76740 0.988200
R9660 n1_M2_4380_76740 n1_M2_5460_76740 0.988200
R9661 n1_M2_5460_76740 n1_M2_6540_76740 0.988200
R9662 n1_M2_6540_76740 n1_M2_7620_76740 0.988200
R9663 n1_M2_7620_76740 n1_M2_8700_76740 0.988200
R9664 n1_M2_8700_76740 n1_M2_9780_76740 0.988200
R9665 n1_M2_9780_76740 n1_M2_10860_76740 0.988200
R9666 n1_M2_10860_76740 n1_M2_11940_76740 0.988200
R9667 n1_M2_11940_76740 n1_M2_13020_76740 0.988200
R9668 n1_M2_13020_76740 n1_M2_14100_76740 0.988200
R9669 n1_M2_14100_76740 n1_M2_15180_76740 0.988200
R9670 n1_M2_15180_76740 n1_M2_16260_76740 0.988200
R9671 n1_M2_16260_76740 n1_M2_17340_76740 0.988200
R9672 n1_M2_17340_76740 n1_M2_18420_76740 0.988200
R9673 n1_M2_18420_76740 n1_M2_19500_76740 0.988200
R9674 n1_M2_19500_76740 n1_M2_20580_76740 0.988200
R9675 n1_M2_20580_76740 n1_M2_21660_76740 0.988200
R9676 n1_M2_21660_76740 n1_M2_22740_76740 0.988200
R9677 n1_M2_22740_76740 n1_M2_23820_76740 0.988200
R9678 n1_M2_23820_76740 n1_M2_24900_76740 0.988200
R9679 n1_M2_24900_76740 n1_M2_25980_76740 0.988200
R9680 n1_M2_25980_76740 n1_M2_27060_76740 0.988200
R9681 n1_M2_27060_76740 n1_M2_28140_76740 0.988200
R9682 n1_M2_28140_76740 n1_M2_29220_76740 0.988200
R9683 n1_M2_29220_76740 n1_M2_30300_76740 0.988200
R9684 n1_M2_30300_76740 n1_M2_31380_76740 0.988200
R9685 n1_M2_31380_76740 n1_M2_32460_76740 0.988200
R9686 n1_M2_32460_76740 n1_M2_33540_76740 0.988200
R9687 n1_M2_33540_76740 n1_M2_34620_76740 0.988200
R9688 n1_M2_34620_76740 n1_M2_35700_76740 0.988200
R9689 n1_M2_35700_76740 n1_M2_36780_76740 0.988200
R9690 n1_M2_36780_76740 n1_M2_37860_76740 0.988200
R9691 n1_M2_37860_76740 n1_M2_38940_76740 0.988200
R9692 n1_M2_38940_76740 n1_M2_40020_76740 0.988200
R9693 n1_M2_40020_76740 n1_M2_41100_76740 0.988200
R9694 n1_M2_41100_76740 n1_M2_42180_76740 0.988200
R9695 n1_M2_42180_76740 n1_M2_43260_76740 0.988200
R9696 n1_M2_43260_76740 n1_M2_44340_76740 0.988200
R9697 n1_M2_44340_76740 n1_M2_45420_76740 0.988200
R9698 n1_M2_45420_76740 n1_M2_46500_76740 0.988200
R9699 n1_M2_46500_76740 n1_M2_47580_76740 0.988200
R9700 n1_M2_47580_76740 n1_M2_48660_76740 0.988200
R9701 n1_M2_48660_76740 n1_M2_49740_76740 0.988200
R9702 n1_M2_49740_76740 n1_M2_50820_76740 0.988200
R9703 n1_M2_50820_76740 n1_M2_51900_76740 0.988200
R9704 n1_M2_51900_76740 n1_M2_52980_76740 0.988200
R9705 n1_M2_52980_76740 n1_M2_54060_76740 0.988200
R9706 n1_M2_54060_76740 n1_M2_55140_76740 0.988200
R9707 n1_M2_55140_76740 n1_M2_56220_76740 0.988200
R9708 n1_M2_56220_76740 n1_M2_57300_76740 0.988200
R9709 n1_M2_57300_76740 n1_M2_58380_76740 0.988200
R9710 n1_M2_58380_76740 n1_M2_59460_76740 0.988200
R9711 n1_M2_59460_76740 n1_M2_60540_76740 0.988200
R9712 n1_M2_60540_76740 n1_M2_61620_76740 0.988200
R9713 n1_M2_61620_76740 n1_M2_62700_76740 0.988200
R9714 n1_M2_62700_76740 n1_M2_63780_76740 0.988200
R9715 n1_M2_63780_76740 n1_M2_64860_76740 0.988200
R9716 n1_M2_64860_76740 n1_M2_65940_76740 0.988200
R9717 n1_M2_65940_76740 n1_M2_67020_76740 0.988200
R9718 n1_M2_67020_76740 n1_M2_68100_76740 0.988200
R9719 n1_M2_68100_76740 n1_M2_69180_76740 0.988200
R9720 n1_M2_69180_76740 n1_M2_70260_76740 0.988200
R9721 n1_M2_70260_76740 n1_M2_71340_76740 0.988200
R9722 n1_M2_71340_76740 n1_M2_72420_76740 0.988200
R9723 n1_M2_72420_76740 n1_M2_73500_76740 0.988200
R9724 n1_M2_73500_76740 n1_M2_74580_76740 0.988200
R9725 n1_M2_74580_76740 n1_M2_75660_76740 0.988200
R9726 n1_M2_75660_76740 n1_M2_76740_76740 0.988200
R9727 n1_M2_76740_76740 n1_M2_77820_76740 0.988200
R9728 n1_M2_77820_76740 n1_M2_78900_76740 0.988200
R9729 n1_M2_78900_76740 n1_M2_79980_76740 0.988200
R9730 n1_M2_79980_76740 n1_M2_81060_76740 0.988200
R9731 n1_M2_81060_76740 n1_M2_82140_76740 0.988200
R9732 n1_M2_82140_76740 n1_M2_83220_76740 0.988200
R9733 n1_M2_83220_76740 n1_M2_84300_76740 0.988200
R9734 n1_M2_84300_76740 n1_M2_85380_76740 0.988200
R9735 n1_M2_85380_76740 n1_M2_86460_76740 0.988200
R9736 n1_M2_86460_76740 n1_M2_87540_76740 0.988200
R9737 n1_M2_87540_76740 n1_M2_88620_76740 0.988200
R9738 n1_M2_88620_76740 n1_M2_89700_76740 0.988200
R9739 n1_M2_89700_76740 n1_M2_90780_76740 0.988200
R9740 n1_M2_90780_76740 n1_M2_91860_76740 0.988200
R9741 n1_M2_91860_76740 n1_M2_92940_76740 0.988200
R9742 n1_M2_92940_76740 n1_M2_94020_76740 0.988200
R9743 n1_M2_94020_76740 n1_M2_95100_76740 0.988200
R9744 n1_M2_95100_76740 n1_M2_96180_76740 0.988200
R9745 n1_M2_96180_76740 n1_M2_97260_76740 0.988200
R9746 n1_M2_97260_76740 n1_M2_98340_76740 0.988200
R9747 n1_M2_98340_76740 n1_M2_99420_76740 0.988200
R9748 n1_M2_99420_76740 n1_M2_100500_76740 0.988200
R9749 n1_M2_100500_76740 n1_M2_101580_76740 0.988200
R9750 n1_M2_101580_76740 n1_M2_102660_76740 0.988200
R9751 n1_M2_102660_76740 n1_M2_103740_76740 0.988200
R9752 n1_M2_103740_76740 n1_M2_104820_76740 0.988200
R9753 n1_M2_104820_76740 n1_M2_105900_76740 0.988200
R9754 n1_M2_105900_76740 n1_M2_106980_76740 0.988200
R9755 n1_M2_106980_76740 n1_M2_108060_76740 0.988200
R9756 n1_M2_108060_76740 n1_M2_109140_76740 0.988200
R9757 n1_M2_109140_76740 n1_M2_110220_76740 0.988200
R9758 n1_M2_110220_76740 n1_M2_111300_76740 0.988200
R9759 n1_M2_111300_76740 n1_M2_112380_76740 0.988200
R9760 n1_M2_112380_76740 n1_M2_113460_76740 0.988200
R9761 n1_M2_113460_76740 n1_M2_114540_76740 0.988200
R9762 n1_M2_114540_76740 n1_M2_115620_76740 0.988200
R9763 n1_M2_115620_76740 n1_M2_116700_76740 0.988200
R9764 n1_M2_116700_76740 n1_M2_117780_76740 0.988200
R9765 n1_M2_117780_76740 n1_M2_118860_76740 0.988200
R9766 n1_M2_118860_76740 n1_M2_119940_76740 0.988200
R9767 n1_M2_119940_76740 n1_M2_121020_76740 0.988200
R9768 n1_M2_121020_76740 n1_M2_122100_76740 0.988200
R9769 n1_M2_122100_76740 n1_M2_123180_76740 0.988200
R9770 n1_M2_123180_76740 n1_M2_124260_76740 0.988200
R9771 n1_M2_124260_76740 n1_M2_125340_76740 0.988200
R9772 n1_M2_125340_76740 n1_M2_126420_76740 0.988200
R9773 n1_M2_126420_76740 n1_M2_127500_76740 0.988200
R9774 n1_M2_127500_76740 n1_M2_128580_76740 0.988200
R9775 n1_M2_128580_76740 n1_M2_129660_76740 0.988200
R9776 n1_M2_129660_76740 n1_M2_130740_76740 0.988200
R9777 n1_M2_130740_76740 n1_M2_131820_76740 0.988200
R9778 n1_M2_131820_76740 n1_M2_132900_76740 0.988200
R9779 n1_M2_132900_76740 n1_M2_133980_76740 0.988200
R9780 n1_M2_133980_76740 n1_M2_135060_76740 0.988200
R9781 n1_M2_135060_76740 n1_M2_136140_76740 0.988200
R9782 n1_M2_136140_76740 n1_M2_137220_76740 0.988200
R9783 n1_M2_137220_76740 n1_M2_138300_76740 0.988200
R9784 n1_M2_138300_76740 n1_M2_139380_76740 0.988200
R9785 n1_M2_139380_76740 n1_M2_140460_76740 0.988200
R9786 n1_M2_140460_76740 n1_M2_141540_76740 0.988200
R9787 n1_M2_141540_76740 n1_M2_142620_76740 0.988200
R9788 n1_M2_142620_76740 n1_M2_143700_76740 0.988200
R9789 n1_M2_143700_76740 n1_M2_144780_76740 0.988200
R9790 n1_M2_144780_76740 n1_M2_145860_76740 0.988200
R9791 n1_M2_145860_76740 n1_M2_146940_76740 0.988200
R9792 n1_M2_60_77820 n1_M2_1140_77820 0.988200
R9793 n1_M2_1140_77820 n1_M2_2220_77820 0.988200
R9794 n1_M2_2220_77820 n1_M2_3300_77820 0.988200
R9795 n1_M2_3300_77820 n1_M2_4380_77820 0.988200
R9796 n1_M2_4380_77820 n1_M2_5460_77820 0.988200
R9797 n1_M2_5460_77820 n1_M2_6540_77820 0.988200
R9798 n1_M2_6540_77820 n1_M2_7620_77820 0.988200
R9799 n1_M2_7620_77820 n1_M2_8700_77820 0.988200
R9800 n1_M2_8700_77820 n1_M2_9780_77820 0.988200
R9801 n1_M2_9780_77820 n1_M2_10860_77820 0.988200
R9802 n1_M2_10860_77820 n1_M2_11940_77820 0.988200
R9803 n1_M2_11940_77820 n1_M2_13020_77820 0.988200
R9804 n1_M2_13020_77820 n1_M2_14100_77820 0.988200
R9805 n1_M2_14100_77820 n1_M2_15180_77820 0.988200
R9806 n1_M2_15180_77820 n1_M2_16260_77820 0.988200
R9807 n1_M2_16260_77820 n1_M2_17340_77820 0.988200
R9808 n1_M2_17340_77820 n1_M2_18420_77820 0.988200
R9809 n1_M2_18420_77820 n1_M2_19500_77820 0.988200
R9810 n1_M2_19500_77820 n1_M2_20580_77820 0.988200
R9811 n1_M2_20580_77820 n1_M2_21660_77820 0.988200
R9812 n1_M2_21660_77820 n1_M2_22740_77820 0.988200
R9813 n1_M2_22740_77820 n1_M2_23820_77820 0.988200
R9814 n1_M2_23820_77820 n1_M2_24900_77820 0.988200
R9815 n1_M2_24900_77820 n1_M2_25980_77820 0.988200
R9816 n1_M2_25980_77820 n1_M2_27060_77820 0.988200
R9817 n1_M2_27060_77820 n1_M2_28140_77820 0.988200
R9818 n1_M2_28140_77820 n1_M2_29220_77820 0.988200
R9819 n1_M2_29220_77820 n1_M2_30300_77820 0.988200
R9820 n1_M2_30300_77820 n1_M2_31380_77820 0.988200
R9821 n1_M2_31380_77820 n1_M2_32460_77820 0.988200
R9822 n1_M2_32460_77820 n1_M2_33540_77820 0.988200
R9823 n1_M2_33540_77820 n1_M2_34620_77820 0.988200
R9824 n1_M2_34620_77820 n1_M2_35700_77820 0.988200
R9825 n1_M2_35700_77820 n1_M2_36780_77820 0.988200
R9826 n1_M2_36780_77820 n1_M2_37860_77820 0.988200
R9827 n1_M2_37860_77820 n1_M2_38940_77820 0.988200
R9828 n1_M2_38940_77820 n1_M2_40020_77820 0.988200
R9829 n1_M2_40020_77820 n1_M2_41100_77820 0.988200
R9830 n1_M2_41100_77820 n1_M2_42180_77820 0.988200
R9831 n1_M2_42180_77820 n1_M2_43260_77820 0.988200
R9832 n1_M2_43260_77820 n1_M2_44340_77820 0.988200
R9833 n1_M2_44340_77820 n1_M2_45420_77820 0.988200
R9834 n1_M2_45420_77820 n1_M2_46500_77820 0.988200
R9835 n1_M2_46500_77820 n1_M2_47580_77820 0.988200
R9836 n1_M2_47580_77820 n1_M2_48660_77820 0.988200
R9837 n1_M2_48660_77820 n1_M2_49740_77820 0.988200
R9838 n1_M2_49740_77820 n1_M2_50820_77820 0.988200
R9839 n1_M2_50820_77820 n1_M2_51900_77820 0.988200
R9840 n1_M2_51900_77820 n1_M2_52980_77820 0.988200
R9841 n1_M2_52980_77820 n1_M2_54060_77820 0.988200
R9842 n1_M2_54060_77820 n1_M2_55140_77820 0.988200
R9843 n1_M2_55140_77820 n1_M2_56220_77820 0.988200
R9844 n1_M2_56220_77820 n1_M2_57300_77820 0.988200
R9845 n1_M2_57300_77820 n1_M2_58380_77820 0.988200
R9846 n1_M2_58380_77820 n1_M2_59460_77820 0.988200
R9847 n1_M2_59460_77820 n1_M2_60540_77820 0.988200
R9848 n1_M2_60540_77820 n1_M2_61620_77820 0.988200
R9849 n1_M2_61620_77820 n1_M2_62700_77820 0.988200
R9850 n1_M2_62700_77820 n1_M2_63780_77820 0.988200
R9851 n1_M2_63780_77820 n1_M2_64860_77820 0.988200
R9852 n1_M2_64860_77820 n1_M2_65940_77820 0.988200
R9853 n1_M2_65940_77820 n1_M2_67020_77820 0.988200
R9854 n1_M2_67020_77820 n1_M2_68100_77820 0.988200
R9855 n1_M2_68100_77820 n1_M2_69180_77820 0.988200
R9856 n1_M2_69180_77820 n1_M2_70260_77820 0.988200
R9857 n1_M2_70260_77820 n1_M2_71340_77820 0.988200
R9858 n1_M2_71340_77820 n1_M2_72420_77820 0.988200
R9859 n1_M2_72420_77820 n1_M2_73500_77820 0.988200
R9860 n1_M2_73500_77820 n1_M2_74580_77820 0.988200
R9861 n1_M2_74580_77820 n1_M2_75660_77820 0.988200
R9862 n1_M2_75660_77820 n1_M2_76740_77820 0.988200
R9863 n1_M2_76740_77820 n1_M2_77820_77820 0.988200
R9864 n1_M2_77820_77820 n1_M2_78900_77820 0.988200
R9865 n1_M2_78900_77820 n1_M2_79980_77820 0.988200
R9866 n1_M2_79980_77820 n1_M2_81060_77820 0.988200
R9867 n1_M2_81060_77820 n1_M2_82140_77820 0.988200
R9868 n1_M2_82140_77820 n1_M2_83220_77820 0.988200
R9869 n1_M2_83220_77820 n1_M2_84300_77820 0.988200
R9870 n1_M2_84300_77820 n1_M2_85380_77820 0.988200
R9871 n1_M2_85380_77820 n1_M2_86460_77820 0.988200
R9872 n1_M2_86460_77820 n1_M2_87540_77820 0.988200
R9873 n1_M2_87540_77820 n1_M2_88620_77820 0.988200
R9874 n1_M2_88620_77820 n1_M2_89700_77820 0.988200
R9875 n1_M2_89700_77820 n1_M2_90780_77820 0.988200
R9876 n1_M2_90780_77820 n1_M2_91860_77820 0.988200
R9877 n1_M2_91860_77820 n1_M2_92940_77820 0.988200
R9878 n1_M2_92940_77820 n1_M2_94020_77820 0.988200
R9879 n1_M2_94020_77820 n1_M2_95100_77820 0.988200
R9880 n1_M2_95100_77820 n1_M2_96180_77820 0.988200
R9881 n1_M2_96180_77820 n1_M2_97260_77820 0.988200
R9882 n1_M2_97260_77820 n1_M2_98340_77820 0.988200
R9883 n1_M2_98340_77820 n1_M2_99420_77820 0.988200
R9884 n1_M2_99420_77820 n1_M2_100500_77820 0.988200
R9885 n1_M2_100500_77820 n1_M2_101580_77820 0.988200
R9886 n1_M2_101580_77820 n1_M2_102660_77820 0.988200
R9887 n1_M2_102660_77820 n1_M2_103740_77820 0.988200
R9888 n1_M2_103740_77820 n1_M2_104820_77820 0.988200
R9889 n1_M2_104820_77820 n1_M2_105900_77820 0.988200
R9890 n1_M2_105900_77820 n1_M2_106980_77820 0.988200
R9891 n1_M2_106980_77820 n1_M2_108060_77820 0.988200
R9892 n1_M2_108060_77820 n1_M2_109140_77820 0.988200
R9893 n1_M2_109140_77820 n1_M2_110220_77820 0.988200
R9894 n1_M2_110220_77820 n1_M2_111300_77820 0.988200
R9895 n1_M2_111300_77820 n1_M2_112380_77820 0.988200
R9896 n1_M2_112380_77820 n1_M2_113460_77820 0.988200
R9897 n1_M2_113460_77820 n1_M2_114540_77820 0.988200
R9898 n1_M2_114540_77820 n1_M2_115620_77820 0.988200
R9899 n1_M2_115620_77820 n1_M2_116700_77820 0.988200
R9900 n1_M2_116700_77820 n1_M2_117780_77820 0.988200
R9901 n1_M2_117780_77820 n1_M2_118860_77820 0.988200
R9902 n1_M2_118860_77820 n1_M2_119940_77820 0.988200
R9903 n1_M2_119940_77820 n1_M2_121020_77820 0.988200
R9904 n1_M2_121020_77820 n1_M2_122100_77820 0.988200
R9905 n1_M2_122100_77820 n1_M2_123180_77820 0.988200
R9906 n1_M2_123180_77820 n1_M2_124260_77820 0.988200
R9907 n1_M2_124260_77820 n1_M2_125340_77820 0.988200
R9908 n1_M2_125340_77820 n1_M2_126420_77820 0.988200
R9909 n1_M2_126420_77820 n1_M2_127500_77820 0.988200
R9910 n1_M2_127500_77820 n1_M2_128580_77820 0.988200
R9911 n1_M2_128580_77820 n1_M2_129660_77820 0.988200
R9912 n1_M2_129660_77820 n1_M2_130740_77820 0.988200
R9913 n1_M2_130740_77820 n1_M2_131820_77820 0.988200
R9914 n1_M2_131820_77820 n1_M2_132900_77820 0.988200
R9915 n1_M2_132900_77820 n1_M2_133980_77820 0.988200
R9916 n1_M2_133980_77820 n1_M2_135060_77820 0.988200
R9917 n1_M2_135060_77820 n1_M2_136140_77820 0.988200
R9918 n1_M2_136140_77820 n1_M2_137220_77820 0.988200
R9919 n1_M2_137220_77820 n1_M2_138300_77820 0.988200
R9920 n1_M2_138300_77820 n1_M2_139380_77820 0.988200
R9921 n1_M2_139380_77820 n1_M2_140460_77820 0.988200
R9922 n1_M2_140460_77820 n1_M2_141540_77820 0.988200
R9923 n1_M2_141540_77820 n1_M2_142620_77820 0.988200
R9924 n1_M2_142620_77820 n1_M2_143700_77820 0.988200
R9925 n1_M2_143700_77820 n1_M2_144780_77820 0.988200
R9926 n1_M2_144780_77820 n1_M2_145860_77820 0.988200
R9927 n1_M2_145860_77820 n1_M2_146940_77820 0.988200
R9928 n1_M2_60_78900 n1_M2_1140_78900 0.988200
R9929 n1_M2_1140_78900 n1_M2_2220_78900 0.988200
R9930 n1_M2_2220_78900 n1_M2_3300_78900 0.988200
R9931 n1_M2_3300_78900 n1_M2_4380_78900 0.988200
R9932 n1_M2_4380_78900 n1_M2_5460_78900 0.988200
R9933 n1_M2_5460_78900 n1_M2_6540_78900 0.988200
R9934 n1_M2_6540_78900 n1_M2_7620_78900 0.988200
R9935 n1_M2_7620_78900 n1_M2_8700_78900 0.988200
R9936 n1_M2_8700_78900 n1_M2_9780_78900 0.988200
R9937 n1_M2_9780_78900 n1_M2_10860_78900 0.988200
R9938 n1_M2_10860_78900 n1_M2_11940_78900 0.988200
R9939 n1_M2_11940_78900 n1_M2_13020_78900 0.988200
R9940 n1_M2_13020_78900 n1_M2_14100_78900 0.988200
R9941 n1_M2_14100_78900 n1_M2_15180_78900 0.988200
R9942 n1_M2_15180_78900 n1_M2_16260_78900 0.988200
R9943 n1_M2_16260_78900 n1_M2_17340_78900 0.988200
R9944 n1_M2_17340_78900 n1_M2_18420_78900 0.988200
R9945 n1_M2_18420_78900 n1_M2_19500_78900 0.988200
R9946 n1_M2_19500_78900 n1_M2_20580_78900 0.988200
R9947 n1_M2_20580_78900 n1_M2_21660_78900 0.988200
R9948 n1_M2_21660_78900 n1_M2_22740_78900 0.988200
R9949 n1_M2_22740_78900 n1_M2_23820_78900 0.988200
R9950 n1_M2_23820_78900 n1_M2_24900_78900 0.988200
R9951 n1_M2_24900_78900 n1_M2_25980_78900 0.988200
R9952 n1_M2_25980_78900 n1_M2_27060_78900 0.988200
R9953 n1_M2_27060_78900 n1_M2_28140_78900 0.988200
R9954 n1_M2_28140_78900 n1_M2_29220_78900 0.988200
R9955 n1_M2_29220_78900 n1_M2_30300_78900 0.988200
R9956 n1_M2_30300_78900 n1_M2_31380_78900 0.988200
R9957 n1_M2_31380_78900 n1_M2_32460_78900 0.988200
R9958 n1_M2_32460_78900 n1_M2_33540_78900 0.988200
R9959 n1_M2_33540_78900 n1_M2_34620_78900 0.988200
R9960 n1_M2_34620_78900 n1_M2_35700_78900 0.988200
R9961 n1_M2_35700_78900 n1_M2_36780_78900 0.988200
R9962 n1_M2_36780_78900 n1_M2_37860_78900 0.988200
R9963 n1_M2_37860_78900 n1_M2_38940_78900 0.988200
R9964 n1_M2_38940_78900 n1_M2_40020_78900 0.988200
R9965 n1_M2_40020_78900 n1_M2_41100_78900 0.988200
R9966 n1_M2_41100_78900 n1_M2_42180_78900 0.988200
R9967 n1_M2_42180_78900 n1_M2_43260_78900 0.988200
R9968 n1_M2_43260_78900 n1_M2_44340_78900 0.988200
R9969 n1_M2_44340_78900 n1_M2_45420_78900 0.988200
R9970 n1_M2_45420_78900 n1_M2_46500_78900 0.988200
R9971 n1_M2_46500_78900 n1_M2_47580_78900 0.988200
R9972 n1_M2_47580_78900 n1_M2_48660_78900 0.988200
R9973 n1_M2_48660_78900 n1_M2_49740_78900 0.988200
R9974 n1_M2_49740_78900 n1_M2_50820_78900 0.988200
R9975 n1_M2_50820_78900 n1_M2_51900_78900 0.988200
R9976 n1_M2_51900_78900 n1_M2_52980_78900 0.988200
R9977 n1_M2_52980_78900 n1_M2_54060_78900 0.988200
R9978 n1_M2_54060_78900 n1_M2_55140_78900 0.988200
R9979 n1_M2_55140_78900 n1_M2_56220_78900 0.988200
R9980 n1_M2_56220_78900 n1_M2_57300_78900 0.988200
R9981 n1_M2_57300_78900 n1_M2_58380_78900 0.988200
R9982 n1_M2_58380_78900 n1_M2_59460_78900 0.988200
R9983 n1_M2_59460_78900 n1_M2_60540_78900 0.988200
R9984 n1_M2_60540_78900 n1_M2_61620_78900 0.988200
R9985 n1_M2_61620_78900 n1_M2_62700_78900 0.988200
R9986 n1_M2_62700_78900 n1_M2_63780_78900 0.988200
R9987 n1_M2_63780_78900 n1_M2_64860_78900 0.988200
R9988 n1_M2_64860_78900 n1_M2_65940_78900 0.988200
R9989 n1_M2_65940_78900 n1_M2_67020_78900 0.988200
R9990 n1_M2_67020_78900 n1_M2_68100_78900 0.988200
R9991 n1_M2_68100_78900 n1_M2_69180_78900 0.988200
R9992 n1_M2_69180_78900 n1_M2_70260_78900 0.988200
R9993 n1_M2_70260_78900 n1_M2_71340_78900 0.988200
R9994 n1_M2_71340_78900 n1_M2_72420_78900 0.988200
R9995 n1_M2_72420_78900 n1_M2_73500_78900 0.988200
R9996 n1_M2_73500_78900 n1_M2_74580_78900 0.988200
R9997 n1_M2_74580_78900 n1_M2_75660_78900 0.988200
R9998 n1_M2_75660_78900 n1_M2_76740_78900 0.988200
R9999 n1_M2_76740_78900 n1_M2_77820_78900 0.988200
R10000 n1_M2_77820_78900 n1_M2_78900_78900 0.988200
R10001 n1_M2_78900_78900 n1_M2_79980_78900 0.988200
R10002 n1_M2_79980_78900 n1_M2_81060_78900 0.988200
R10003 n1_M2_81060_78900 n1_M2_82140_78900 0.988200
R10004 n1_M2_82140_78900 n1_M2_83220_78900 0.988200
R10005 n1_M2_83220_78900 n1_M2_84300_78900 0.988200
R10006 n1_M2_84300_78900 n1_M2_85380_78900 0.988200
R10007 n1_M2_85380_78900 n1_M2_86460_78900 0.988200
R10008 n1_M2_86460_78900 n1_M2_87540_78900 0.988200
R10009 n1_M2_87540_78900 n1_M2_88620_78900 0.988200
R10010 n1_M2_88620_78900 n1_M2_89700_78900 0.988200
R10011 n1_M2_89700_78900 n1_M2_90780_78900 0.988200
R10012 n1_M2_90780_78900 n1_M2_91860_78900 0.988200
R10013 n1_M2_91860_78900 n1_M2_92940_78900 0.988200
R10014 n1_M2_92940_78900 n1_M2_94020_78900 0.988200
R10015 n1_M2_94020_78900 n1_M2_95100_78900 0.988200
R10016 n1_M2_95100_78900 n1_M2_96180_78900 0.988200
R10017 n1_M2_96180_78900 n1_M2_97260_78900 0.988200
R10018 n1_M2_97260_78900 n1_M2_98340_78900 0.988200
R10019 n1_M2_98340_78900 n1_M2_99420_78900 0.988200
R10020 n1_M2_99420_78900 n1_M2_100500_78900 0.988200
R10021 n1_M2_100500_78900 n1_M2_101580_78900 0.988200
R10022 n1_M2_101580_78900 n1_M2_102660_78900 0.988200
R10023 n1_M2_102660_78900 n1_M2_103740_78900 0.988200
R10024 n1_M2_103740_78900 n1_M2_104820_78900 0.988200
R10025 n1_M2_104820_78900 n1_M2_105900_78900 0.988200
R10026 n1_M2_105900_78900 n1_M2_106980_78900 0.988200
R10027 n1_M2_106980_78900 n1_M2_108060_78900 0.988200
R10028 n1_M2_108060_78900 n1_M2_109140_78900 0.988200
R10029 n1_M2_109140_78900 n1_M2_110220_78900 0.988200
R10030 n1_M2_110220_78900 n1_M2_111300_78900 0.988200
R10031 n1_M2_111300_78900 n1_M2_112380_78900 0.988200
R10032 n1_M2_112380_78900 n1_M2_113460_78900 0.988200
R10033 n1_M2_113460_78900 n1_M2_114540_78900 0.988200
R10034 n1_M2_114540_78900 n1_M2_115620_78900 0.988200
R10035 n1_M2_115620_78900 n1_M2_116700_78900 0.988200
R10036 n1_M2_116700_78900 n1_M2_117780_78900 0.988200
R10037 n1_M2_117780_78900 n1_M2_118860_78900 0.988200
R10038 n1_M2_118860_78900 n1_M2_119940_78900 0.988200
R10039 n1_M2_119940_78900 n1_M2_121020_78900 0.988200
R10040 n1_M2_121020_78900 n1_M2_122100_78900 0.988200
R10041 n1_M2_122100_78900 n1_M2_123180_78900 0.988200
R10042 n1_M2_123180_78900 n1_M2_124260_78900 0.988200
R10043 n1_M2_124260_78900 n1_M2_125340_78900 0.988200
R10044 n1_M2_125340_78900 n1_M2_126420_78900 0.988200
R10045 n1_M2_126420_78900 n1_M2_127500_78900 0.988200
R10046 n1_M2_127500_78900 n1_M2_128580_78900 0.988200
R10047 n1_M2_128580_78900 n1_M2_129660_78900 0.988200
R10048 n1_M2_129660_78900 n1_M2_130740_78900 0.988200
R10049 n1_M2_130740_78900 n1_M2_131820_78900 0.988200
R10050 n1_M2_131820_78900 n1_M2_132900_78900 0.988200
R10051 n1_M2_132900_78900 n1_M2_133980_78900 0.988200
R10052 n1_M2_133980_78900 n1_M2_135060_78900 0.988200
R10053 n1_M2_135060_78900 n1_M2_136140_78900 0.988200
R10054 n1_M2_136140_78900 n1_M2_137220_78900 0.988200
R10055 n1_M2_137220_78900 n1_M2_138300_78900 0.988200
R10056 n1_M2_138300_78900 n1_M2_139380_78900 0.988200
R10057 n1_M2_139380_78900 n1_M2_140460_78900 0.988200
R10058 n1_M2_140460_78900 n1_M2_141540_78900 0.988200
R10059 n1_M2_141540_78900 n1_M2_142620_78900 0.988200
R10060 n1_M2_142620_78900 n1_M2_143700_78900 0.988200
R10061 n1_M2_143700_78900 n1_M2_144780_78900 0.988200
R10062 n1_M2_144780_78900 n1_M2_145860_78900 0.988200
R10063 n1_M2_145860_78900 n1_M2_146940_78900 0.988200
R10064 n1_M2_60_79980 n1_M2_1140_79980 0.988200
R10065 n1_M2_1140_79980 n1_M2_2220_79980 0.988200
R10066 n1_M2_2220_79980 n1_M2_3300_79980 0.988200
R10067 n1_M2_3300_79980 n1_M2_4380_79980 0.988200
R10068 n1_M2_4380_79980 n1_M2_5460_79980 0.988200
R10069 n1_M2_5460_79980 n1_M2_6540_79980 0.988200
R10070 n1_M2_6540_79980 n1_M2_7620_79980 0.988200
R10071 n1_M2_7620_79980 n1_M2_8700_79980 0.988200
R10072 n1_M2_8700_79980 n1_M2_9780_79980 0.988200
R10073 n1_M2_9780_79980 n1_M2_10860_79980 0.988200
R10074 n1_M2_10860_79980 n1_M2_11940_79980 0.988200
R10075 n1_M2_11940_79980 n1_M2_13020_79980 0.988200
R10076 n1_M2_13020_79980 n1_M2_14100_79980 0.988200
R10077 n1_M2_14100_79980 n1_M2_15180_79980 0.988200
R10078 n1_M2_15180_79980 n1_M2_16260_79980 0.988200
R10079 n1_M2_16260_79980 n1_M2_17340_79980 0.988200
R10080 n1_M2_17340_79980 n1_M2_18420_79980 0.988200
R10081 n1_M2_18420_79980 n1_M2_19500_79980 0.988200
R10082 n1_M2_19500_79980 n1_M2_20580_79980 0.988200
R10083 n1_M2_20580_79980 n1_M2_21660_79980 0.988200
R10084 n1_M2_21660_79980 n1_M2_22740_79980 0.988200
R10085 n1_M2_22740_79980 n1_M2_23820_79980 0.988200
R10086 n1_M2_23820_79980 n1_M2_24900_79980 0.988200
R10087 n1_M2_24900_79980 n1_M2_25980_79980 0.988200
R10088 n1_M2_25980_79980 n1_M2_27060_79980 0.988200
R10089 n1_M2_27060_79980 n1_M2_28140_79980 0.988200
R10090 n1_M2_28140_79980 n1_M2_29220_79980 0.988200
R10091 n1_M2_29220_79980 n1_M2_30300_79980 0.988200
R10092 n1_M2_30300_79980 n1_M2_31380_79980 0.988200
R10093 n1_M2_31380_79980 n1_M2_32460_79980 0.988200
R10094 n1_M2_32460_79980 n1_M2_33540_79980 0.988200
R10095 n1_M2_33540_79980 n1_M2_34620_79980 0.988200
R10096 n1_M2_34620_79980 n1_M2_35700_79980 0.988200
R10097 n1_M2_35700_79980 n1_M2_36780_79980 0.988200
R10098 n1_M2_36780_79980 n1_M2_37860_79980 0.988200
R10099 n1_M2_37860_79980 n1_M2_38940_79980 0.988200
R10100 n1_M2_38940_79980 n1_M2_40020_79980 0.988200
R10101 n1_M2_40020_79980 n1_M2_41100_79980 0.988200
R10102 n1_M2_41100_79980 n1_M2_42180_79980 0.988200
R10103 n1_M2_42180_79980 n1_M2_43260_79980 0.988200
R10104 n1_M2_43260_79980 n1_M2_44340_79980 0.988200
R10105 n1_M2_44340_79980 n1_M2_45420_79980 0.988200
R10106 n1_M2_45420_79980 n1_M2_46500_79980 0.988200
R10107 n1_M2_46500_79980 n1_M2_47580_79980 0.988200
R10108 n1_M2_47580_79980 n1_M2_48660_79980 0.988200
R10109 n1_M2_48660_79980 n1_M2_49740_79980 0.988200
R10110 n1_M2_49740_79980 n1_M2_50820_79980 0.988200
R10111 n1_M2_50820_79980 n1_M2_51900_79980 0.988200
R10112 n1_M2_51900_79980 n1_M2_52980_79980 0.988200
R10113 n1_M2_52980_79980 n1_M2_54060_79980 0.988200
R10114 n1_M2_54060_79980 n1_M2_55140_79980 0.988200
R10115 n1_M2_55140_79980 n1_M2_56220_79980 0.988200
R10116 n1_M2_56220_79980 n1_M2_57300_79980 0.988200
R10117 n1_M2_57300_79980 n1_M2_58380_79980 0.988200
R10118 n1_M2_58380_79980 n1_M2_59460_79980 0.988200
R10119 n1_M2_59460_79980 n1_M2_60540_79980 0.988200
R10120 n1_M2_60540_79980 n1_M2_61620_79980 0.988200
R10121 n1_M2_61620_79980 n1_M2_62700_79980 0.988200
R10122 n1_M2_62700_79980 n1_M2_63780_79980 0.988200
R10123 n1_M2_63780_79980 n1_M2_64860_79980 0.988200
R10124 n1_M2_64860_79980 n1_M2_65940_79980 0.988200
R10125 n1_M2_65940_79980 n1_M2_67020_79980 0.988200
R10126 n1_M2_67020_79980 n1_M2_68100_79980 0.988200
R10127 n1_M2_68100_79980 n1_M2_69180_79980 0.988200
R10128 n1_M2_69180_79980 n1_M2_70260_79980 0.988200
R10129 n1_M2_70260_79980 n1_M2_71340_79980 0.988200
R10130 n1_M2_71340_79980 n1_M2_72420_79980 0.988200
R10131 n1_M2_72420_79980 n1_M2_73500_79980 0.988200
R10132 n1_M2_73500_79980 n1_M2_74580_79980 0.988200
R10133 n1_M2_74580_79980 n1_M2_75660_79980 0.988200
R10134 n1_M2_75660_79980 n1_M2_76740_79980 0.988200
R10135 n1_M2_76740_79980 n1_M2_77820_79980 0.988200
R10136 n1_M2_77820_79980 n1_M2_78900_79980 0.988200
R10137 n1_M2_78900_79980 n1_M2_79980_79980 0.988200
R10138 n1_M2_79980_79980 n1_M2_81060_79980 0.988200
R10139 n1_M2_81060_79980 n1_M2_82140_79980 0.988200
R10140 n1_M2_82140_79980 n1_M2_83220_79980 0.988200
R10141 n1_M2_83220_79980 n1_M2_84300_79980 0.988200
R10142 n1_M2_84300_79980 n1_M2_85380_79980 0.988200
R10143 n1_M2_85380_79980 n1_M2_86460_79980 0.988200
R10144 n1_M2_86460_79980 n1_M2_87540_79980 0.988200
R10145 n1_M2_87540_79980 n1_M2_88620_79980 0.988200
R10146 n1_M2_88620_79980 n1_M2_89700_79980 0.988200
R10147 n1_M2_89700_79980 n1_M2_90780_79980 0.988200
R10148 n1_M2_90780_79980 n1_M2_91860_79980 0.988200
R10149 n1_M2_91860_79980 n1_M2_92940_79980 0.988200
R10150 n1_M2_92940_79980 n1_M2_94020_79980 0.988200
R10151 n1_M2_94020_79980 n1_M2_95100_79980 0.988200
R10152 n1_M2_95100_79980 n1_M2_96180_79980 0.988200
R10153 n1_M2_96180_79980 n1_M2_97260_79980 0.988200
R10154 n1_M2_97260_79980 n1_M2_98340_79980 0.988200
R10155 n1_M2_98340_79980 n1_M2_99420_79980 0.988200
R10156 n1_M2_99420_79980 n1_M2_100500_79980 0.988200
R10157 n1_M2_100500_79980 n1_M2_101580_79980 0.988200
R10158 n1_M2_101580_79980 n1_M2_102660_79980 0.988200
R10159 n1_M2_102660_79980 n1_M2_103740_79980 0.988200
R10160 n1_M2_103740_79980 n1_M2_104820_79980 0.988200
R10161 n1_M2_104820_79980 n1_M2_105900_79980 0.988200
R10162 n1_M2_105900_79980 n1_M2_106980_79980 0.988200
R10163 n1_M2_106980_79980 n1_M2_108060_79980 0.988200
R10164 n1_M2_108060_79980 n1_M2_109140_79980 0.988200
R10165 n1_M2_109140_79980 n1_M2_110220_79980 0.988200
R10166 n1_M2_110220_79980 n1_M2_111300_79980 0.988200
R10167 n1_M2_111300_79980 n1_M2_112380_79980 0.988200
R10168 n1_M2_112380_79980 n1_M2_113460_79980 0.988200
R10169 n1_M2_113460_79980 n1_M2_114540_79980 0.988200
R10170 n1_M2_114540_79980 n1_M2_115620_79980 0.988200
R10171 n1_M2_115620_79980 n1_M2_116700_79980 0.988200
R10172 n1_M2_116700_79980 n1_M2_117780_79980 0.988200
R10173 n1_M2_117780_79980 n1_M2_118860_79980 0.988200
R10174 n1_M2_118860_79980 n1_M2_119940_79980 0.988200
R10175 n1_M2_119940_79980 n1_M2_121020_79980 0.988200
R10176 n1_M2_121020_79980 n1_M2_122100_79980 0.988200
R10177 n1_M2_122100_79980 n1_M2_123180_79980 0.988200
R10178 n1_M2_123180_79980 n1_M2_124260_79980 0.988200
R10179 n1_M2_124260_79980 n1_M2_125340_79980 0.988200
R10180 n1_M2_125340_79980 n1_M2_126420_79980 0.988200
R10181 n1_M2_126420_79980 n1_M2_127500_79980 0.988200
R10182 n1_M2_127500_79980 n1_M2_128580_79980 0.988200
R10183 n1_M2_128580_79980 n1_M2_129660_79980 0.988200
R10184 n1_M2_129660_79980 n1_M2_130740_79980 0.988200
R10185 n1_M2_130740_79980 n1_M2_131820_79980 0.988200
R10186 n1_M2_131820_79980 n1_M2_132900_79980 0.988200
R10187 n1_M2_132900_79980 n1_M2_133980_79980 0.988200
R10188 n1_M2_133980_79980 n1_M2_135060_79980 0.988200
R10189 n1_M2_135060_79980 n1_M2_136140_79980 0.988200
R10190 n1_M2_136140_79980 n1_M2_137220_79980 0.988200
R10191 n1_M2_137220_79980 n1_M2_138300_79980 0.988200
R10192 n1_M2_138300_79980 n1_M2_139380_79980 0.988200
R10193 n1_M2_139380_79980 n1_M2_140460_79980 0.988200
R10194 n1_M2_140460_79980 n1_M2_141540_79980 0.988200
R10195 n1_M2_141540_79980 n1_M2_142620_79980 0.988200
R10196 n1_M2_142620_79980 n1_M2_143700_79980 0.988200
R10197 n1_M2_143700_79980 n1_M2_144780_79980 0.988200
R10198 n1_M2_144780_79980 n1_M2_145860_79980 0.988200
R10199 n1_M2_145860_79980 n1_M2_146940_79980 0.988200
R10200 n1_M2_60_81060 n1_M2_1140_81060 0.988200
R10201 n1_M2_1140_81060 n1_M2_2220_81060 0.988200
R10202 n1_M2_2220_81060 n1_M2_3300_81060 0.988200
R10203 n1_M2_3300_81060 n1_M2_4380_81060 0.988200
R10204 n1_M2_4380_81060 n1_M2_5460_81060 0.988200
R10205 n1_M2_5460_81060 n1_M2_6540_81060 0.988200
R10206 n1_M2_6540_81060 n1_M2_7620_81060 0.988200
R10207 n1_M2_7620_81060 n1_M2_8700_81060 0.988200
R10208 n1_M2_8700_81060 n1_M2_9780_81060 0.988200
R10209 n1_M2_9780_81060 n1_M2_10860_81060 0.988200
R10210 n1_M2_10860_81060 n1_M2_11940_81060 0.988200
R10211 n1_M2_11940_81060 n1_M2_13020_81060 0.988200
R10212 n1_M2_13020_81060 n1_M2_14100_81060 0.988200
R10213 n1_M2_14100_81060 n1_M2_15180_81060 0.988200
R10214 n1_M2_15180_81060 n1_M2_16260_81060 0.988200
R10215 n1_M2_16260_81060 n1_M2_17340_81060 0.988200
R10216 n1_M2_17340_81060 n1_M2_18420_81060 0.988200
R10217 n1_M2_18420_81060 n1_M2_19500_81060 0.988200
R10218 n1_M2_19500_81060 n1_M2_20580_81060 0.988200
R10219 n1_M2_20580_81060 n1_M2_21660_81060 0.988200
R10220 n1_M2_21660_81060 n1_M2_22740_81060 0.988200
R10221 n1_M2_22740_81060 n1_M2_23820_81060 0.988200
R10222 n1_M2_23820_81060 n1_M2_24900_81060 0.988200
R10223 n1_M2_24900_81060 n1_M2_25980_81060 0.988200
R10224 n1_M2_25980_81060 n1_M2_27060_81060 0.988200
R10225 n1_M2_27060_81060 n1_M2_28140_81060 0.988200
R10226 n1_M2_28140_81060 n1_M2_29220_81060 0.988200
R10227 n1_M2_29220_81060 n1_M2_30300_81060 0.988200
R10228 n1_M2_30300_81060 n1_M2_31380_81060 0.988200
R10229 n1_M2_31380_81060 n1_M2_32460_81060 0.988200
R10230 n1_M2_32460_81060 n1_M2_33540_81060 0.988200
R10231 n1_M2_33540_81060 n1_M2_34620_81060 0.988200
R10232 n1_M2_34620_81060 n1_M2_35700_81060 0.988200
R10233 n1_M2_35700_81060 n1_M2_36780_81060 0.988200
R10234 n1_M2_36780_81060 n1_M2_37860_81060 0.988200
R10235 n1_M2_37860_81060 n1_M2_38940_81060 0.988200
R10236 n1_M2_38940_81060 n1_M2_40020_81060 0.988200
R10237 n1_M2_40020_81060 n1_M2_41100_81060 0.988200
R10238 n1_M2_41100_81060 n1_M2_42180_81060 0.988200
R10239 n1_M2_42180_81060 n1_M2_43260_81060 0.988200
R10240 n1_M2_43260_81060 n1_M2_44340_81060 0.988200
R10241 n1_M2_44340_81060 n1_M2_45420_81060 0.988200
R10242 n1_M2_45420_81060 n1_M2_46500_81060 0.988200
R10243 n1_M2_46500_81060 n1_M2_47580_81060 0.988200
R10244 n1_M2_47580_81060 n1_M2_48660_81060 0.988200
R10245 n1_M2_48660_81060 n1_M2_49740_81060 0.988200
R10246 n1_M2_49740_81060 n1_M2_50820_81060 0.988200
R10247 n1_M2_50820_81060 n1_M2_51900_81060 0.988200
R10248 n1_M2_51900_81060 n1_M2_52980_81060 0.988200
R10249 n1_M2_52980_81060 n1_M2_54060_81060 0.988200
R10250 n1_M2_54060_81060 n1_M2_55140_81060 0.988200
R10251 n1_M2_55140_81060 n1_M2_56220_81060 0.988200
R10252 n1_M2_56220_81060 n1_M2_57300_81060 0.988200
R10253 n1_M2_57300_81060 n1_M2_58380_81060 0.988200
R10254 n1_M2_58380_81060 n1_M2_59460_81060 0.988200
R10255 n1_M2_59460_81060 n1_M2_60540_81060 0.988200
R10256 n1_M2_60540_81060 n1_M2_61620_81060 0.988200
R10257 n1_M2_61620_81060 n1_M2_62700_81060 0.988200
R10258 n1_M2_62700_81060 n1_M2_63780_81060 0.988200
R10259 n1_M2_63780_81060 n1_M2_64860_81060 0.988200
R10260 n1_M2_64860_81060 n1_M2_65940_81060 0.988200
R10261 n1_M2_65940_81060 n1_M2_67020_81060 0.988200
R10262 n1_M2_67020_81060 n1_M2_68100_81060 0.988200
R10263 n1_M2_68100_81060 n1_M2_69180_81060 0.988200
R10264 n1_M2_69180_81060 n1_M2_70260_81060 0.988200
R10265 n1_M2_70260_81060 n1_M2_71340_81060 0.988200
R10266 n1_M2_71340_81060 n1_M2_72420_81060 0.988200
R10267 n1_M2_72420_81060 n1_M2_73500_81060 0.988200
R10268 n1_M2_73500_81060 n1_M2_74580_81060 0.988200
R10269 n1_M2_74580_81060 n1_M2_75660_81060 0.988200
R10270 n1_M2_75660_81060 n1_M2_76740_81060 0.988200
R10271 n1_M2_76740_81060 n1_M2_77820_81060 0.988200
R10272 n1_M2_77820_81060 n1_M2_78900_81060 0.988200
R10273 n1_M2_78900_81060 n1_M2_79980_81060 0.988200
R10274 n1_M2_79980_81060 n1_M2_81060_81060 0.988200
R10275 n1_M2_81060_81060 n1_M2_82140_81060 0.988200
R10276 n1_M2_82140_81060 n1_M2_83220_81060 0.988200
R10277 n1_M2_83220_81060 n1_M2_84300_81060 0.988200
R10278 n1_M2_84300_81060 n1_M2_85380_81060 0.988200
R10279 n1_M2_85380_81060 n1_M2_86460_81060 0.988200
R10280 n1_M2_86460_81060 n1_M2_87540_81060 0.988200
R10281 n1_M2_87540_81060 n1_M2_88620_81060 0.988200
R10282 n1_M2_88620_81060 n1_M2_89700_81060 0.988200
R10283 n1_M2_89700_81060 n1_M2_90780_81060 0.988200
R10284 n1_M2_90780_81060 n1_M2_91860_81060 0.988200
R10285 n1_M2_91860_81060 n1_M2_92940_81060 0.988200
R10286 n1_M2_92940_81060 n1_M2_94020_81060 0.988200
R10287 n1_M2_94020_81060 n1_M2_95100_81060 0.988200
R10288 n1_M2_95100_81060 n1_M2_96180_81060 0.988200
R10289 n1_M2_96180_81060 n1_M2_97260_81060 0.988200
R10290 n1_M2_97260_81060 n1_M2_98340_81060 0.988200
R10291 n1_M2_98340_81060 n1_M2_99420_81060 0.988200
R10292 n1_M2_99420_81060 n1_M2_100500_81060 0.988200
R10293 n1_M2_100500_81060 n1_M2_101580_81060 0.988200
R10294 n1_M2_101580_81060 n1_M2_102660_81060 0.988200
R10295 n1_M2_102660_81060 n1_M2_103740_81060 0.988200
R10296 n1_M2_103740_81060 n1_M2_104820_81060 0.988200
R10297 n1_M2_104820_81060 n1_M2_105900_81060 0.988200
R10298 n1_M2_105900_81060 n1_M2_106980_81060 0.988200
R10299 n1_M2_106980_81060 n1_M2_108060_81060 0.988200
R10300 n1_M2_108060_81060 n1_M2_109140_81060 0.988200
R10301 n1_M2_109140_81060 n1_M2_110220_81060 0.988200
R10302 n1_M2_110220_81060 n1_M2_111300_81060 0.988200
R10303 n1_M2_111300_81060 n1_M2_112380_81060 0.988200
R10304 n1_M2_112380_81060 n1_M2_113460_81060 0.988200
R10305 n1_M2_113460_81060 n1_M2_114540_81060 0.988200
R10306 n1_M2_114540_81060 n1_M2_115620_81060 0.988200
R10307 n1_M2_115620_81060 n1_M2_116700_81060 0.988200
R10308 n1_M2_116700_81060 n1_M2_117780_81060 0.988200
R10309 n1_M2_117780_81060 n1_M2_118860_81060 0.988200
R10310 n1_M2_118860_81060 n1_M2_119940_81060 0.988200
R10311 n1_M2_119940_81060 n1_M2_121020_81060 0.988200
R10312 n1_M2_121020_81060 n1_M2_122100_81060 0.988200
R10313 n1_M2_122100_81060 n1_M2_123180_81060 0.988200
R10314 n1_M2_123180_81060 n1_M2_124260_81060 0.988200
R10315 n1_M2_124260_81060 n1_M2_125340_81060 0.988200
R10316 n1_M2_125340_81060 n1_M2_126420_81060 0.988200
R10317 n1_M2_126420_81060 n1_M2_127500_81060 0.988200
R10318 n1_M2_127500_81060 n1_M2_128580_81060 0.988200
R10319 n1_M2_128580_81060 n1_M2_129660_81060 0.988200
R10320 n1_M2_129660_81060 n1_M2_130740_81060 0.988200
R10321 n1_M2_130740_81060 n1_M2_131820_81060 0.988200
R10322 n1_M2_131820_81060 n1_M2_132900_81060 0.988200
R10323 n1_M2_132900_81060 n1_M2_133980_81060 0.988200
R10324 n1_M2_133980_81060 n1_M2_135060_81060 0.988200
R10325 n1_M2_135060_81060 n1_M2_136140_81060 0.988200
R10326 n1_M2_136140_81060 n1_M2_137220_81060 0.988200
R10327 n1_M2_137220_81060 n1_M2_138300_81060 0.988200
R10328 n1_M2_138300_81060 n1_M2_139380_81060 0.988200
R10329 n1_M2_139380_81060 n1_M2_140460_81060 0.988200
R10330 n1_M2_140460_81060 n1_M2_141540_81060 0.988200
R10331 n1_M2_141540_81060 n1_M2_142620_81060 0.988200
R10332 n1_M2_142620_81060 n1_M2_143700_81060 0.988200
R10333 n1_M2_143700_81060 n1_M2_144780_81060 0.988200
R10334 n1_M2_144780_81060 n1_M2_145860_81060 0.988200
R10335 n1_M2_145860_81060 n1_M2_146940_81060 0.988200
R10336 n1_M2_60_82140 n1_M2_1140_82140 0.988200
R10337 n1_M2_1140_82140 n1_M2_2220_82140 0.988200
R10338 n1_M2_2220_82140 n1_M2_3300_82140 0.988200
R10339 n1_M2_3300_82140 n1_M2_4380_82140 0.988200
R10340 n1_M2_4380_82140 n1_M2_5460_82140 0.988200
R10341 n1_M2_5460_82140 n1_M2_6540_82140 0.988200
R10342 n1_M2_6540_82140 n1_M2_7620_82140 0.988200
R10343 n1_M2_7620_82140 n1_M2_8700_82140 0.988200
R10344 n1_M2_8700_82140 n1_M2_9780_82140 0.988200
R10345 n1_M2_9780_82140 n1_M2_10860_82140 0.988200
R10346 n1_M2_10860_82140 n1_M2_11940_82140 0.988200
R10347 n1_M2_11940_82140 n1_M2_13020_82140 0.988200
R10348 n1_M2_13020_82140 n1_M2_14100_82140 0.988200
R10349 n1_M2_14100_82140 n1_M2_15180_82140 0.988200
R10350 n1_M2_15180_82140 n1_M2_16260_82140 0.988200
R10351 n1_M2_16260_82140 n1_M2_17340_82140 0.988200
R10352 n1_M2_17340_82140 n1_M2_18420_82140 0.988200
R10353 n1_M2_18420_82140 n1_M2_19500_82140 0.988200
R10354 n1_M2_19500_82140 n1_M2_20580_82140 0.988200
R10355 n1_M2_20580_82140 n1_M2_21660_82140 0.988200
R10356 n1_M2_21660_82140 n1_M2_22740_82140 0.988200
R10357 n1_M2_22740_82140 n1_M2_23820_82140 0.988200
R10358 n1_M2_23820_82140 n1_M2_24900_82140 0.988200
R10359 n1_M2_24900_82140 n1_M2_25980_82140 0.988200
R10360 n1_M2_25980_82140 n1_M2_27060_82140 0.988200
R10361 n1_M2_27060_82140 n1_M2_28140_82140 0.988200
R10362 n1_M2_28140_82140 n1_M2_29220_82140 0.988200
R10363 n1_M2_29220_82140 n1_M2_30300_82140 0.988200
R10364 n1_M2_30300_82140 n1_M2_31380_82140 0.988200
R10365 n1_M2_31380_82140 n1_M2_32460_82140 0.988200
R10366 n1_M2_32460_82140 n1_M2_33540_82140 0.988200
R10367 n1_M2_33540_82140 n1_M2_34620_82140 0.988200
R10368 n1_M2_34620_82140 n1_M2_35700_82140 0.988200
R10369 n1_M2_35700_82140 n1_M2_36780_82140 0.988200
R10370 n1_M2_36780_82140 n1_M2_37860_82140 0.988200
R10371 n1_M2_37860_82140 n1_M2_38940_82140 0.988200
R10372 n1_M2_38940_82140 n1_M2_40020_82140 0.988200
R10373 n1_M2_40020_82140 n1_M2_41100_82140 0.988200
R10374 n1_M2_41100_82140 n1_M2_42180_82140 0.988200
R10375 n1_M2_42180_82140 n1_M2_43260_82140 0.988200
R10376 n1_M2_43260_82140 n1_M2_44340_82140 0.988200
R10377 n1_M2_44340_82140 n1_M2_45420_82140 0.988200
R10378 n1_M2_45420_82140 n1_M2_46500_82140 0.988200
R10379 n1_M2_46500_82140 n1_M2_47580_82140 0.988200
R10380 n1_M2_47580_82140 n1_M2_48660_82140 0.988200
R10381 n1_M2_48660_82140 n1_M2_49740_82140 0.988200
R10382 n1_M2_49740_82140 n1_M2_50820_82140 0.988200
R10383 n1_M2_50820_82140 n1_M2_51900_82140 0.988200
R10384 n1_M2_51900_82140 n1_M2_52980_82140 0.988200
R10385 n1_M2_52980_82140 n1_M2_54060_82140 0.988200
R10386 n1_M2_54060_82140 n1_M2_55140_82140 0.988200
R10387 n1_M2_55140_82140 n1_M2_56220_82140 0.988200
R10388 n1_M2_56220_82140 n1_M2_57300_82140 0.988200
R10389 n1_M2_57300_82140 n1_M2_58380_82140 0.988200
R10390 n1_M2_58380_82140 n1_M2_59460_82140 0.988200
R10391 n1_M2_59460_82140 n1_M2_60540_82140 0.988200
R10392 n1_M2_60540_82140 n1_M2_61620_82140 0.988200
R10393 n1_M2_61620_82140 n1_M2_62700_82140 0.988200
R10394 n1_M2_62700_82140 n1_M2_63780_82140 0.988200
R10395 n1_M2_63780_82140 n1_M2_64860_82140 0.988200
R10396 n1_M2_64860_82140 n1_M2_65940_82140 0.988200
R10397 n1_M2_65940_82140 n1_M2_67020_82140 0.988200
R10398 n1_M2_67020_82140 n1_M2_68100_82140 0.988200
R10399 n1_M2_68100_82140 n1_M2_69180_82140 0.988200
R10400 n1_M2_69180_82140 n1_M2_70260_82140 0.988200
R10401 n1_M2_70260_82140 n1_M2_71340_82140 0.988200
R10402 n1_M2_71340_82140 n1_M2_72420_82140 0.988200
R10403 n1_M2_72420_82140 n1_M2_73500_82140 0.988200
R10404 n1_M2_73500_82140 n1_M2_74580_82140 0.988200
R10405 n1_M2_74580_82140 n1_M2_75660_82140 0.988200
R10406 n1_M2_75660_82140 n1_M2_76740_82140 0.988200
R10407 n1_M2_76740_82140 n1_M2_77820_82140 0.988200
R10408 n1_M2_77820_82140 n1_M2_78900_82140 0.988200
R10409 n1_M2_78900_82140 n1_M2_79980_82140 0.988200
R10410 n1_M2_79980_82140 n1_M2_81060_82140 0.988200
R10411 n1_M2_81060_82140 n1_M2_82140_82140 0.988200
R10412 n1_M2_82140_82140 n1_M2_83220_82140 0.988200
R10413 n1_M2_83220_82140 n1_M2_84300_82140 0.988200
R10414 n1_M2_84300_82140 n1_M2_85380_82140 0.988200
R10415 n1_M2_85380_82140 n1_M2_86460_82140 0.988200
R10416 n1_M2_86460_82140 n1_M2_87540_82140 0.988200
R10417 n1_M2_87540_82140 n1_M2_88620_82140 0.988200
R10418 n1_M2_88620_82140 n1_M2_89700_82140 0.988200
R10419 n1_M2_89700_82140 n1_M2_90780_82140 0.988200
R10420 n1_M2_90780_82140 n1_M2_91860_82140 0.988200
R10421 n1_M2_91860_82140 n1_M2_92940_82140 0.988200
R10422 n1_M2_92940_82140 n1_M2_94020_82140 0.988200
R10423 n1_M2_94020_82140 n1_M2_95100_82140 0.988200
R10424 n1_M2_95100_82140 n1_M2_96180_82140 0.988200
R10425 n1_M2_96180_82140 n1_M2_97260_82140 0.988200
R10426 n1_M2_97260_82140 n1_M2_98340_82140 0.988200
R10427 n1_M2_98340_82140 n1_M2_99420_82140 0.988200
R10428 n1_M2_99420_82140 n1_M2_100500_82140 0.988200
R10429 n1_M2_100500_82140 n1_M2_101580_82140 0.988200
R10430 n1_M2_101580_82140 n1_M2_102660_82140 0.988200
R10431 n1_M2_102660_82140 n1_M2_103740_82140 0.988200
R10432 n1_M2_103740_82140 n1_M2_104820_82140 0.988200
R10433 n1_M2_104820_82140 n1_M2_105900_82140 0.988200
R10434 n1_M2_105900_82140 n1_M2_106980_82140 0.988200
R10435 n1_M2_106980_82140 n1_M2_108060_82140 0.988200
R10436 n1_M2_108060_82140 n1_M2_109140_82140 0.988200
R10437 n1_M2_109140_82140 n1_M2_110220_82140 0.988200
R10438 n1_M2_110220_82140 n1_M2_111300_82140 0.988200
R10439 n1_M2_111300_82140 n1_M2_112380_82140 0.988200
R10440 n1_M2_112380_82140 n1_M2_113460_82140 0.988200
R10441 n1_M2_113460_82140 n1_M2_114540_82140 0.988200
R10442 n1_M2_114540_82140 n1_M2_115620_82140 0.988200
R10443 n1_M2_115620_82140 n1_M2_116700_82140 0.988200
R10444 n1_M2_116700_82140 n1_M2_117780_82140 0.988200
R10445 n1_M2_117780_82140 n1_M2_118860_82140 0.988200
R10446 n1_M2_118860_82140 n1_M2_119940_82140 0.988200
R10447 n1_M2_119940_82140 n1_M2_121020_82140 0.988200
R10448 n1_M2_121020_82140 n1_M2_122100_82140 0.988200
R10449 n1_M2_122100_82140 n1_M2_123180_82140 0.988200
R10450 n1_M2_123180_82140 n1_M2_124260_82140 0.988200
R10451 n1_M2_124260_82140 n1_M2_125340_82140 0.988200
R10452 n1_M2_125340_82140 n1_M2_126420_82140 0.988200
R10453 n1_M2_126420_82140 n1_M2_127500_82140 0.988200
R10454 n1_M2_127500_82140 n1_M2_128580_82140 0.988200
R10455 n1_M2_128580_82140 n1_M2_129660_82140 0.988200
R10456 n1_M2_129660_82140 n1_M2_130740_82140 0.988200
R10457 n1_M2_130740_82140 n1_M2_131820_82140 0.988200
R10458 n1_M2_131820_82140 n1_M2_132900_82140 0.988200
R10459 n1_M2_132900_82140 n1_M2_133980_82140 0.988200
R10460 n1_M2_133980_82140 n1_M2_135060_82140 0.988200
R10461 n1_M2_135060_82140 n1_M2_136140_82140 0.988200
R10462 n1_M2_136140_82140 n1_M2_137220_82140 0.988200
R10463 n1_M2_137220_82140 n1_M2_138300_82140 0.988200
R10464 n1_M2_138300_82140 n1_M2_139380_82140 0.988200
R10465 n1_M2_139380_82140 n1_M2_140460_82140 0.988200
R10466 n1_M2_140460_82140 n1_M2_141540_82140 0.988200
R10467 n1_M2_141540_82140 n1_M2_142620_82140 0.988200
R10468 n1_M2_142620_82140 n1_M2_143700_82140 0.988200
R10469 n1_M2_143700_82140 n1_M2_144780_82140 0.988200
R10470 n1_M2_144780_82140 n1_M2_145860_82140 0.988200
R10471 n1_M2_145860_82140 n1_M2_146940_82140 0.988200
R10472 n1_M2_60_83220 n1_M2_1140_83220 0.988200
R10473 n1_M2_1140_83220 n1_M2_2220_83220 0.988200
R10474 n1_M2_2220_83220 n1_M2_3300_83220 0.988200
R10475 n1_M2_3300_83220 n1_M2_4380_83220 0.988200
R10476 n1_M2_4380_83220 n1_M2_5460_83220 0.988200
R10477 n1_M2_5460_83220 n1_M2_6540_83220 0.988200
R10478 n1_M2_6540_83220 n1_M2_7620_83220 0.988200
R10479 n1_M2_7620_83220 n1_M2_8700_83220 0.988200
R10480 n1_M2_8700_83220 n1_M2_9780_83220 0.988200
R10481 n1_M2_9780_83220 n1_M2_10860_83220 0.988200
R10482 n1_M2_10860_83220 n1_M2_11940_83220 0.988200
R10483 n1_M2_11940_83220 n1_M2_13020_83220 0.988200
R10484 n1_M2_13020_83220 n1_M2_14100_83220 0.988200
R10485 n1_M2_14100_83220 n1_M2_15180_83220 0.988200
R10486 n1_M2_15180_83220 n1_M2_16260_83220 0.988200
R10487 n1_M2_16260_83220 n1_M2_17340_83220 0.988200
R10488 n1_M2_17340_83220 n1_M2_18420_83220 0.988200
R10489 n1_M2_18420_83220 n1_M2_19500_83220 0.988200
R10490 n1_M2_19500_83220 n1_M2_20580_83220 0.988200
R10491 n1_M2_20580_83220 n1_M2_21660_83220 0.988200
R10492 n1_M2_21660_83220 n1_M2_22740_83220 0.988200
R10493 n1_M2_22740_83220 n1_M2_23820_83220 0.988200
R10494 n1_M2_23820_83220 n1_M2_24900_83220 0.988200
R10495 n1_M2_24900_83220 n1_M2_25980_83220 0.988200
R10496 n1_M2_25980_83220 n1_M2_27060_83220 0.988200
R10497 n1_M2_27060_83220 n1_M2_28140_83220 0.988200
R10498 n1_M2_28140_83220 n1_M2_29220_83220 0.988200
R10499 n1_M2_29220_83220 n1_M2_30300_83220 0.988200
R10500 n1_M2_30300_83220 n1_M2_31380_83220 0.988200
R10501 n1_M2_31380_83220 n1_M2_32460_83220 0.988200
R10502 n1_M2_32460_83220 n1_M2_33540_83220 0.988200
R10503 n1_M2_33540_83220 n1_M2_34620_83220 0.988200
R10504 n1_M2_34620_83220 n1_M2_35700_83220 0.988200
R10505 n1_M2_35700_83220 n1_M2_36780_83220 0.988200
R10506 n1_M2_36780_83220 n1_M2_37860_83220 0.988200
R10507 n1_M2_37860_83220 n1_M2_38940_83220 0.988200
R10508 n1_M2_38940_83220 n1_M2_40020_83220 0.988200
R10509 n1_M2_40020_83220 n1_M2_41100_83220 0.988200
R10510 n1_M2_41100_83220 n1_M2_42180_83220 0.988200
R10511 n1_M2_42180_83220 n1_M2_43260_83220 0.988200
R10512 n1_M2_43260_83220 n1_M2_44340_83220 0.988200
R10513 n1_M2_44340_83220 n1_M2_45420_83220 0.988200
R10514 n1_M2_45420_83220 n1_M2_46500_83220 0.988200
R10515 n1_M2_46500_83220 n1_M2_47580_83220 0.988200
R10516 n1_M2_47580_83220 n1_M2_48660_83220 0.988200
R10517 n1_M2_48660_83220 n1_M2_49740_83220 0.988200
R10518 n1_M2_49740_83220 n1_M2_50820_83220 0.988200
R10519 n1_M2_50820_83220 n1_M2_51900_83220 0.988200
R10520 n1_M2_51900_83220 n1_M2_52980_83220 0.988200
R10521 n1_M2_52980_83220 n1_M2_54060_83220 0.988200
R10522 n1_M2_54060_83220 n1_M2_55140_83220 0.988200
R10523 n1_M2_55140_83220 n1_M2_56220_83220 0.988200
R10524 n1_M2_56220_83220 n1_M2_57300_83220 0.988200
R10525 n1_M2_57300_83220 n1_M2_58380_83220 0.988200
R10526 n1_M2_58380_83220 n1_M2_59460_83220 0.988200
R10527 n1_M2_59460_83220 n1_M2_60540_83220 0.988200
R10528 n1_M2_60540_83220 n1_M2_61620_83220 0.988200
R10529 n1_M2_61620_83220 n1_M2_62700_83220 0.988200
R10530 n1_M2_62700_83220 n1_M2_63780_83220 0.988200
R10531 n1_M2_63780_83220 n1_M2_64860_83220 0.988200
R10532 n1_M2_64860_83220 n1_M2_65940_83220 0.988200
R10533 n1_M2_65940_83220 n1_M2_67020_83220 0.988200
R10534 n1_M2_67020_83220 n1_M2_68100_83220 0.988200
R10535 n1_M2_68100_83220 n1_M2_69180_83220 0.988200
R10536 n1_M2_69180_83220 n1_M2_70260_83220 0.988200
R10537 n1_M2_70260_83220 n1_M2_71340_83220 0.988200
R10538 n1_M2_71340_83220 n1_M2_72420_83220 0.988200
R10539 n1_M2_72420_83220 n1_M2_73500_83220 0.988200
R10540 n1_M2_73500_83220 n1_M2_74580_83220 0.988200
R10541 n1_M2_74580_83220 n1_M2_75660_83220 0.988200
R10542 n1_M2_75660_83220 n1_M2_76740_83220 0.988200
R10543 n1_M2_76740_83220 n1_M2_77820_83220 0.988200
R10544 n1_M2_77820_83220 n1_M2_78900_83220 0.988200
R10545 n1_M2_78900_83220 n1_M2_79980_83220 0.988200
R10546 n1_M2_79980_83220 n1_M2_81060_83220 0.988200
R10547 n1_M2_81060_83220 n1_M2_82140_83220 0.988200
R10548 n1_M2_82140_83220 n1_M2_83220_83220 0.988200
R10549 n1_M2_83220_83220 n1_M2_84300_83220 0.988200
R10550 n1_M2_84300_83220 n1_M2_85380_83220 0.988200
R10551 n1_M2_85380_83220 n1_M2_86460_83220 0.988200
R10552 n1_M2_86460_83220 n1_M2_87540_83220 0.988200
R10553 n1_M2_87540_83220 n1_M2_88620_83220 0.988200
R10554 n1_M2_88620_83220 n1_M2_89700_83220 0.988200
R10555 n1_M2_89700_83220 n1_M2_90780_83220 0.988200
R10556 n1_M2_90780_83220 n1_M2_91860_83220 0.988200
R10557 n1_M2_91860_83220 n1_M2_92940_83220 0.988200
R10558 n1_M2_92940_83220 n1_M2_94020_83220 0.988200
R10559 n1_M2_94020_83220 n1_M2_95100_83220 0.988200
R10560 n1_M2_95100_83220 n1_M2_96180_83220 0.988200
R10561 n1_M2_96180_83220 n1_M2_97260_83220 0.988200
R10562 n1_M2_97260_83220 n1_M2_98340_83220 0.988200
R10563 n1_M2_98340_83220 n1_M2_99420_83220 0.988200
R10564 n1_M2_99420_83220 n1_M2_100500_83220 0.988200
R10565 n1_M2_100500_83220 n1_M2_101580_83220 0.988200
R10566 n1_M2_101580_83220 n1_M2_102660_83220 0.988200
R10567 n1_M2_102660_83220 n1_M2_103740_83220 0.988200
R10568 n1_M2_103740_83220 n1_M2_104820_83220 0.988200
R10569 n1_M2_104820_83220 n1_M2_105900_83220 0.988200
R10570 n1_M2_105900_83220 n1_M2_106980_83220 0.988200
R10571 n1_M2_106980_83220 n1_M2_108060_83220 0.988200
R10572 n1_M2_108060_83220 n1_M2_109140_83220 0.988200
R10573 n1_M2_109140_83220 n1_M2_110220_83220 0.988200
R10574 n1_M2_110220_83220 n1_M2_111300_83220 0.988200
R10575 n1_M2_111300_83220 n1_M2_112380_83220 0.988200
R10576 n1_M2_112380_83220 n1_M2_113460_83220 0.988200
R10577 n1_M2_113460_83220 n1_M2_114540_83220 0.988200
R10578 n1_M2_114540_83220 n1_M2_115620_83220 0.988200
R10579 n1_M2_115620_83220 n1_M2_116700_83220 0.988200
R10580 n1_M2_116700_83220 n1_M2_117780_83220 0.988200
R10581 n1_M2_117780_83220 n1_M2_118860_83220 0.988200
R10582 n1_M2_118860_83220 n1_M2_119940_83220 0.988200
R10583 n1_M2_119940_83220 n1_M2_121020_83220 0.988200
R10584 n1_M2_121020_83220 n1_M2_122100_83220 0.988200
R10585 n1_M2_122100_83220 n1_M2_123180_83220 0.988200
R10586 n1_M2_123180_83220 n1_M2_124260_83220 0.988200
R10587 n1_M2_124260_83220 n1_M2_125340_83220 0.988200
R10588 n1_M2_125340_83220 n1_M2_126420_83220 0.988200
R10589 n1_M2_126420_83220 n1_M2_127500_83220 0.988200
R10590 n1_M2_127500_83220 n1_M2_128580_83220 0.988200
R10591 n1_M2_128580_83220 n1_M2_129660_83220 0.988200
R10592 n1_M2_129660_83220 n1_M2_130740_83220 0.988200
R10593 n1_M2_130740_83220 n1_M2_131820_83220 0.988200
R10594 n1_M2_131820_83220 n1_M2_132900_83220 0.988200
R10595 n1_M2_132900_83220 n1_M2_133980_83220 0.988200
R10596 n1_M2_133980_83220 n1_M2_135060_83220 0.988200
R10597 n1_M2_135060_83220 n1_M2_136140_83220 0.988200
R10598 n1_M2_136140_83220 n1_M2_137220_83220 0.988200
R10599 n1_M2_137220_83220 n1_M2_138300_83220 0.988200
R10600 n1_M2_138300_83220 n1_M2_139380_83220 0.988200
R10601 n1_M2_139380_83220 n1_M2_140460_83220 0.988200
R10602 n1_M2_140460_83220 n1_M2_141540_83220 0.988200
R10603 n1_M2_141540_83220 n1_M2_142620_83220 0.988200
R10604 n1_M2_142620_83220 n1_M2_143700_83220 0.988200
R10605 n1_M2_143700_83220 n1_M2_144780_83220 0.988200
R10606 n1_M2_144780_83220 n1_M2_145860_83220 0.988200
R10607 n1_M2_145860_83220 n1_M2_146940_83220 0.988200
R10608 n1_M2_60_84300 n1_M2_1140_84300 0.988200
R10609 n1_M2_1140_84300 n1_M2_2220_84300 0.988200
R10610 n1_M2_2220_84300 n1_M2_3300_84300 0.988200
R10611 n1_M2_3300_84300 n1_M2_4380_84300 0.988200
R10612 n1_M2_4380_84300 n1_M2_5460_84300 0.988200
R10613 n1_M2_5460_84300 n1_M2_6540_84300 0.988200
R10614 n1_M2_6540_84300 n1_M2_7620_84300 0.988200
R10615 n1_M2_7620_84300 n1_M2_8700_84300 0.988200
R10616 n1_M2_8700_84300 n1_M2_9780_84300 0.988200
R10617 n1_M2_9780_84300 n1_M2_10860_84300 0.988200
R10618 n1_M2_10860_84300 n1_M2_11940_84300 0.988200
R10619 n1_M2_11940_84300 n1_M2_13020_84300 0.988200
R10620 n1_M2_13020_84300 n1_M2_14100_84300 0.988200
R10621 n1_M2_14100_84300 n1_M2_15180_84300 0.988200
R10622 n1_M2_15180_84300 n1_M2_16260_84300 0.988200
R10623 n1_M2_16260_84300 n1_M2_17340_84300 0.988200
R10624 n1_M2_17340_84300 n1_M2_18420_84300 0.988200
R10625 n1_M2_18420_84300 n1_M2_19500_84300 0.988200
R10626 n1_M2_19500_84300 n1_M2_20580_84300 0.988200
R10627 n1_M2_20580_84300 n1_M2_21660_84300 0.988200
R10628 n1_M2_21660_84300 n1_M2_22740_84300 0.988200
R10629 n1_M2_22740_84300 n1_M2_23820_84300 0.988200
R10630 n1_M2_23820_84300 n1_M2_24900_84300 0.988200
R10631 n1_M2_24900_84300 n1_M2_25980_84300 0.988200
R10632 n1_M2_25980_84300 n1_M2_27060_84300 0.988200
R10633 n1_M2_27060_84300 n1_M2_28140_84300 0.988200
R10634 n1_M2_28140_84300 n1_M2_29220_84300 0.988200
R10635 n1_M2_29220_84300 n1_M2_30300_84300 0.988200
R10636 n1_M2_30300_84300 n1_M2_31380_84300 0.988200
R10637 n1_M2_31380_84300 n1_M2_32460_84300 0.988200
R10638 n1_M2_32460_84300 n1_M2_33540_84300 0.988200
R10639 n1_M2_33540_84300 n1_M2_34620_84300 0.988200
R10640 n1_M2_34620_84300 n1_M2_35700_84300 0.988200
R10641 n1_M2_35700_84300 n1_M2_36780_84300 0.988200
R10642 n1_M2_36780_84300 n1_M2_37860_84300 0.988200
R10643 n1_M2_37860_84300 n1_M2_38940_84300 0.988200
R10644 n1_M2_38940_84300 n1_M2_40020_84300 0.988200
R10645 n1_M2_40020_84300 n1_M2_41100_84300 0.988200
R10646 n1_M2_41100_84300 n1_M2_42180_84300 0.988200
R10647 n1_M2_42180_84300 n1_M2_43260_84300 0.988200
R10648 n1_M2_43260_84300 n1_M2_44340_84300 0.988200
R10649 n1_M2_44340_84300 n1_M2_45420_84300 0.988200
R10650 n1_M2_45420_84300 n1_M2_46500_84300 0.988200
R10651 n1_M2_46500_84300 n1_M2_47580_84300 0.988200
R10652 n1_M2_47580_84300 n1_M2_48660_84300 0.988200
R10653 n1_M2_48660_84300 n1_M2_49740_84300 0.988200
R10654 n1_M2_49740_84300 n1_M2_50820_84300 0.988200
R10655 n1_M2_50820_84300 n1_M2_51900_84300 0.988200
R10656 n1_M2_51900_84300 n1_M2_52980_84300 0.988200
R10657 n1_M2_52980_84300 n1_M2_54060_84300 0.988200
R10658 n1_M2_54060_84300 n1_M2_55140_84300 0.988200
R10659 n1_M2_55140_84300 n1_M2_56220_84300 0.988200
R10660 n1_M2_56220_84300 n1_M2_57300_84300 0.988200
R10661 n1_M2_57300_84300 n1_M2_58380_84300 0.988200
R10662 n1_M2_58380_84300 n1_M2_59460_84300 0.988200
R10663 n1_M2_59460_84300 n1_M2_60540_84300 0.988200
R10664 n1_M2_60540_84300 n1_M2_61620_84300 0.988200
R10665 n1_M2_61620_84300 n1_M2_62700_84300 0.988200
R10666 n1_M2_62700_84300 n1_M2_63780_84300 0.988200
R10667 n1_M2_63780_84300 n1_M2_64860_84300 0.988200
R10668 n1_M2_64860_84300 n1_M2_65940_84300 0.988200
R10669 n1_M2_65940_84300 n1_M2_67020_84300 0.988200
R10670 n1_M2_67020_84300 n1_M2_68100_84300 0.988200
R10671 n1_M2_68100_84300 n1_M2_69180_84300 0.988200
R10672 n1_M2_69180_84300 n1_M2_70260_84300 0.988200
R10673 n1_M2_70260_84300 n1_M2_71340_84300 0.988200
R10674 n1_M2_71340_84300 n1_M2_72420_84300 0.988200
R10675 n1_M2_72420_84300 n1_M2_73500_84300 0.988200
R10676 n1_M2_73500_84300 n1_M2_74580_84300 0.988200
R10677 n1_M2_74580_84300 n1_M2_75660_84300 0.988200
R10678 n1_M2_75660_84300 n1_M2_76740_84300 0.988200
R10679 n1_M2_76740_84300 n1_M2_77820_84300 0.988200
R10680 n1_M2_77820_84300 n1_M2_78900_84300 0.988200
R10681 n1_M2_78900_84300 n1_M2_79980_84300 0.988200
R10682 n1_M2_79980_84300 n1_M2_81060_84300 0.988200
R10683 n1_M2_81060_84300 n1_M2_82140_84300 0.988200
R10684 n1_M2_82140_84300 n1_M2_83220_84300 0.988200
R10685 n1_M2_83220_84300 n1_M2_84300_84300 0.988200
R10686 n1_M2_84300_84300 n1_M2_85380_84300 0.988200
R10687 n1_M2_85380_84300 n1_M2_86460_84300 0.988200
R10688 n1_M2_86460_84300 n1_M2_87540_84300 0.988200
R10689 n1_M2_87540_84300 n1_M2_88620_84300 0.988200
R10690 n1_M2_88620_84300 n1_M2_89700_84300 0.988200
R10691 n1_M2_89700_84300 n1_M2_90780_84300 0.988200
R10692 n1_M2_90780_84300 n1_M2_91860_84300 0.988200
R10693 n1_M2_91860_84300 n1_M2_92940_84300 0.988200
R10694 n1_M2_92940_84300 n1_M2_94020_84300 0.988200
R10695 n1_M2_94020_84300 n1_M2_95100_84300 0.988200
R10696 n1_M2_95100_84300 n1_M2_96180_84300 0.988200
R10697 n1_M2_96180_84300 n1_M2_97260_84300 0.988200
R10698 n1_M2_97260_84300 n1_M2_98340_84300 0.988200
R10699 n1_M2_98340_84300 n1_M2_99420_84300 0.988200
R10700 n1_M2_99420_84300 n1_M2_100500_84300 0.988200
R10701 n1_M2_100500_84300 n1_M2_101580_84300 0.988200
R10702 n1_M2_101580_84300 n1_M2_102660_84300 0.988200
R10703 n1_M2_102660_84300 n1_M2_103740_84300 0.988200
R10704 n1_M2_103740_84300 n1_M2_104820_84300 0.988200
R10705 n1_M2_104820_84300 n1_M2_105900_84300 0.988200
R10706 n1_M2_105900_84300 n1_M2_106980_84300 0.988200
R10707 n1_M2_106980_84300 n1_M2_108060_84300 0.988200
R10708 n1_M2_108060_84300 n1_M2_109140_84300 0.988200
R10709 n1_M2_109140_84300 n1_M2_110220_84300 0.988200
R10710 n1_M2_110220_84300 n1_M2_111300_84300 0.988200
R10711 n1_M2_111300_84300 n1_M2_112380_84300 0.988200
R10712 n1_M2_112380_84300 n1_M2_113460_84300 0.988200
R10713 n1_M2_113460_84300 n1_M2_114540_84300 0.988200
R10714 n1_M2_114540_84300 n1_M2_115620_84300 0.988200
R10715 n1_M2_115620_84300 n1_M2_116700_84300 0.988200
R10716 n1_M2_116700_84300 n1_M2_117780_84300 0.988200
R10717 n1_M2_117780_84300 n1_M2_118860_84300 0.988200
R10718 n1_M2_118860_84300 n1_M2_119940_84300 0.988200
R10719 n1_M2_119940_84300 n1_M2_121020_84300 0.988200
R10720 n1_M2_121020_84300 n1_M2_122100_84300 0.988200
R10721 n1_M2_122100_84300 n1_M2_123180_84300 0.988200
R10722 n1_M2_123180_84300 n1_M2_124260_84300 0.988200
R10723 n1_M2_124260_84300 n1_M2_125340_84300 0.988200
R10724 n1_M2_125340_84300 n1_M2_126420_84300 0.988200
R10725 n1_M2_126420_84300 n1_M2_127500_84300 0.988200
R10726 n1_M2_127500_84300 n1_M2_128580_84300 0.988200
R10727 n1_M2_128580_84300 n1_M2_129660_84300 0.988200
R10728 n1_M2_129660_84300 n1_M2_130740_84300 0.988200
R10729 n1_M2_130740_84300 n1_M2_131820_84300 0.988200
R10730 n1_M2_131820_84300 n1_M2_132900_84300 0.988200
R10731 n1_M2_132900_84300 n1_M2_133980_84300 0.988200
R10732 n1_M2_133980_84300 n1_M2_135060_84300 0.988200
R10733 n1_M2_135060_84300 n1_M2_136140_84300 0.988200
R10734 n1_M2_136140_84300 n1_M2_137220_84300 0.988200
R10735 n1_M2_137220_84300 n1_M2_138300_84300 0.988200
R10736 n1_M2_138300_84300 n1_M2_139380_84300 0.988200
R10737 n1_M2_139380_84300 n1_M2_140460_84300 0.988200
R10738 n1_M2_140460_84300 n1_M2_141540_84300 0.988200
R10739 n1_M2_141540_84300 n1_M2_142620_84300 0.988200
R10740 n1_M2_142620_84300 n1_M2_143700_84300 0.988200
R10741 n1_M2_143700_84300 n1_M2_144780_84300 0.988200
R10742 n1_M2_144780_84300 n1_M2_145860_84300 0.988200
R10743 n1_M2_145860_84300 n1_M2_146940_84300 0.988200
R10744 n1_M2_60_85380 n1_M2_1140_85380 0.988200
R10745 n1_M2_1140_85380 n1_M2_2220_85380 0.988200
R10746 n1_M2_2220_85380 n1_M2_3300_85380 0.988200
R10747 n1_M2_3300_85380 n1_M2_4380_85380 0.988200
R10748 n1_M2_4380_85380 n1_M2_5460_85380 0.988200
R10749 n1_M2_5460_85380 n1_M2_6540_85380 0.988200
R10750 n1_M2_6540_85380 n1_M2_7620_85380 0.988200
R10751 n1_M2_7620_85380 n1_M2_8700_85380 0.988200
R10752 n1_M2_8700_85380 n1_M2_9780_85380 0.988200
R10753 n1_M2_9780_85380 n1_M2_10860_85380 0.988200
R10754 n1_M2_10860_85380 n1_M2_11940_85380 0.988200
R10755 n1_M2_11940_85380 n1_M2_13020_85380 0.988200
R10756 n1_M2_13020_85380 n1_M2_14100_85380 0.988200
R10757 n1_M2_14100_85380 n1_M2_15180_85380 0.988200
R10758 n1_M2_15180_85380 n1_M2_16260_85380 0.988200
R10759 n1_M2_16260_85380 n1_M2_17340_85380 0.988200
R10760 n1_M2_17340_85380 n1_M2_18420_85380 0.988200
R10761 n1_M2_18420_85380 n1_M2_19500_85380 0.988200
R10762 n1_M2_19500_85380 n1_M2_20580_85380 0.988200
R10763 n1_M2_20580_85380 n1_M2_21660_85380 0.988200
R10764 n1_M2_21660_85380 n1_M2_22740_85380 0.988200
R10765 n1_M2_22740_85380 n1_M2_23820_85380 0.988200
R10766 n1_M2_23820_85380 n1_M2_24900_85380 0.988200
R10767 n1_M2_24900_85380 n1_M2_25980_85380 0.988200
R10768 n1_M2_25980_85380 n1_M2_27060_85380 0.988200
R10769 n1_M2_27060_85380 n1_M2_28140_85380 0.988200
R10770 n1_M2_28140_85380 n1_M2_29220_85380 0.988200
R10771 n1_M2_29220_85380 n1_M2_30300_85380 0.988200
R10772 n1_M2_30300_85380 n1_M2_31380_85380 0.988200
R10773 n1_M2_31380_85380 n1_M2_32460_85380 0.988200
R10774 n1_M2_32460_85380 n1_M2_33540_85380 0.988200
R10775 n1_M2_33540_85380 n1_M2_34620_85380 0.988200
R10776 n1_M2_34620_85380 n1_M2_35700_85380 0.988200
R10777 n1_M2_35700_85380 n1_M2_36780_85380 0.988200
R10778 n1_M2_36780_85380 n1_M2_37860_85380 0.988200
R10779 n1_M2_37860_85380 n1_M2_38940_85380 0.988200
R10780 n1_M2_38940_85380 n1_M2_40020_85380 0.988200
R10781 n1_M2_40020_85380 n1_M2_41100_85380 0.988200
R10782 n1_M2_41100_85380 n1_M2_42180_85380 0.988200
R10783 n1_M2_42180_85380 n1_M2_43260_85380 0.988200
R10784 n1_M2_43260_85380 n1_M2_44340_85380 0.988200
R10785 n1_M2_44340_85380 n1_M2_45420_85380 0.988200
R10786 n1_M2_45420_85380 n1_M2_46500_85380 0.988200
R10787 n1_M2_46500_85380 n1_M2_47580_85380 0.988200
R10788 n1_M2_47580_85380 n1_M2_48660_85380 0.988200
R10789 n1_M2_48660_85380 n1_M2_49740_85380 0.988200
R10790 n1_M2_49740_85380 n1_M2_50820_85380 0.988200
R10791 n1_M2_50820_85380 n1_M2_51900_85380 0.988200
R10792 n1_M2_51900_85380 n1_M2_52980_85380 0.988200
R10793 n1_M2_52980_85380 n1_M2_54060_85380 0.988200
R10794 n1_M2_54060_85380 n1_M2_55140_85380 0.988200
R10795 n1_M2_55140_85380 n1_M2_56220_85380 0.988200
R10796 n1_M2_56220_85380 n1_M2_57300_85380 0.988200
R10797 n1_M2_57300_85380 n1_M2_58380_85380 0.988200
R10798 n1_M2_58380_85380 n1_M2_59460_85380 0.988200
R10799 n1_M2_59460_85380 n1_M2_60540_85380 0.988200
R10800 n1_M2_60540_85380 n1_M2_61620_85380 0.988200
R10801 n1_M2_61620_85380 n1_M2_62700_85380 0.988200
R10802 n1_M2_62700_85380 n1_M2_63780_85380 0.988200
R10803 n1_M2_63780_85380 n1_M2_64860_85380 0.988200
R10804 n1_M2_64860_85380 n1_M2_65940_85380 0.988200
R10805 n1_M2_65940_85380 n1_M2_67020_85380 0.988200
R10806 n1_M2_67020_85380 n1_M2_68100_85380 0.988200
R10807 n1_M2_68100_85380 n1_M2_69180_85380 0.988200
R10808 n1_M2_69180_85380 n1_M2_70260_85380 0.988200
R10809 n1_M2_70260_85380 n1_M2_71340_85380 0.988200
R10810 n1_M2_71340_85380 n1_M2_72420_85380 0.988200
R10811 n1_M2_72420_85380 n1_M2_73500_85380 0.988200
R10812 n1_M2_73500_85380 n1_M2_74580_85380 0.988200
R10813 n1_M2_74580_85380 n1_M2_75660_85380 0.988200
R10814 n1_M2_75660_85380 n1_M2_76740_85380 0.988200
R10815 n1_M2_76740_85380 n1_M2_77820_85380 0.988200
R10816 n1_M2_77820_85380 n1_M2_78900_85380 0.988200
R10817 n1_M2_78900_85380 n1_M2_79980_85380 0.988200
R10818 n1_M2_79980_85380 n1_M2_81060_85380 0.988200
R10819 n1_M2_81060_85380 n1_M2_82140_85380 0.988200
R10820 n1_M2_82140_85380 n1_M2_83220_85380 0.988200
R10821 n1_M2_83220_85380 n1_M2_84300_85380 0.988200
R10822 n1_M2_84300_85380 n1_M2_85380_85380 0.988200
R10823 n1_M2_85380_85380 n1_M2_86460_85380 0.988200
R10824 n1_M2_86460_85380 n1_M2_87540_85380 0.988200
R10825 n1_M2_87540_85380 n1_M2_88620_85380 0.988200
R10826 n1_M2_88620_85380 n1_M2_89700_85380 0.988200
R10827 n1_M2_89700_85380 n1_M2_90780_85380 0.988200
R10828 n1_M2_90780_85380 n1_M2_91860_85380 0.988200
R10829 n1_M2_91860_85380 n1_M2_92940_85380 0.988200
R10830 n1_M2_92940_85380 n1_M2_94020_85380 0.988200
R10831 n1_M2_94020_85380 n1_M2_95100_85380 0.988200
R10832 n1_M2_95100_85380 n1_M2_96180_85380 0.988200
R10833 n1_M2_96180_85380 n1_M2_97260_85380 0.988200
R10834 n1_M2_97260_85380 n1_M2_98340_85380 0.988200
R10835 n1_M2_98340_85380 n1_M2_99420_85380 0.988200
R10836 n1_M2_99420_85380 n1_M2_100500_85380 0.988200
R10837 n1_M2_100500_85380 n1_M2_101580_85380 0.988200
R10838 n1_M2_101580_85380 n1_M2_102660_85380 0.988200
R10839 n1_M2_102660_85380 n1_M2_103740_85380 0.988200
R10840 n1_M2_103740_85380 n1_M2_104820_85380 0.988200
R10841 n1_M2_104820_85380 n1_M2_105900_85380 0.988200
R10842 n1_M2_105900_85380 n1_M2_106980_85380 0.988200
R10843 n1_M2_106980_85380 n1_M2_108060_85380 0.988200
R10844 n1_M2_108060_85380 n1_M2_109140_85380 0.988200
R10845 n1_M2_109140_85380 n1_M2_110220_85380 0.988200
R10846 n1_M2_110220_85380 n1_M2_111300_85380 0.988200
R10847 n1_M2_111300_85380 n1_M2_112380_85380 0.988200
R10848 n1_M2_112380_85380 n1_M2_113460_85380 0.988200
R10849 n1_M2_113460_85380 n1_M2_114540_85380 0.988200
R10850 n1_M2_114540_85380 n1_M2_115620_85380 0.988200
R10851 n1_M2_115620_85380 n1_M2_116700_85380 0.988200
R10852 n1_M2_116700_85380 n1_M2_117780_85380 0.988200
R10853 n1_M2_117780_85380 n1_M2_118860_85380 0.988200
R10854 n1_M2_118860_85380 n1_M2_119940_85380 0.988200
R10855 n1_M2_119940_85380 n1_M2_121020_85380 0.988200
R10856 n1_M2_121020_85380 n1_M2_122100_85380 0.988200
R10857 n1_M2_122100_85380 n1_M2_123180_85380 0.988200
R10858 n1_M2_123180_85380 n1_M2_124260_85380 0.988200
R10859 n1_M2_124260_85380 n1_M2_125340_85380 0.988200
R10860 n1_M2_125340_85380 n1_M2_126420_85380 0.988200
R10861 n1_M2_126420_85380 n1_M2_127500_85380 0.988200
R10862 n1_M2_127500_85380 n1_M2_128580_85380 0.988200
R10863 n1_M2_128580_85380 n1_M2_129660_85380 0.988200
R10864 n1_M2_129660_85380 n1_M2_130740_85380 0.988200
R10865 n1_M2_130740_85380 n1_M2_131820_85380 0.988200
R10866 n1_M2_131820_85380 n1_M2_132900_85380 0.988200
R10867 n1_M2_132900_85380 n1_M2_133980_85380 0.988200
R10868 n1_M2_133980_85380 n1_M2_135060_85380 0.988200
R10869 n1_M2_135060_85380 n1_M2_136140_85380 0.988200
R10870 n1_M2_136140_85380 n1_M2_137220_85380 0.988200
R10871 n1_M2_137220_85380 n1_M2_138300_85380 0.988200
R10872 n1_M2_138300_85380 n1_M2_139380_85380 0.988200
R10873 n1_M2_139380_85380 n1_M2_140460_85380 0.988200
R10874 n1_M2_140460_85380 n1_M2_141540_85380 0.988200
R10875 n1_M2_141540_85380 n1_M2_142620_85380 0.988200
R10876 n1_M2_142620_85380 n1_M2_143700_85380 0.988200
R10877 n1_M2_143700_85380 n1_M2_144780_85380 0.988200
R10878 n1_M2_144780_85380 n1_M2_145860_85380 0.988200
R10879 n1_M2_145860_85380 n1_M2_146940_85380 0.988200
R10880 n1_M2_60_86460 n1_M2_1140_86460 0.988200
R10881 n1_M2_1140_86460 n1_M2_2220_86460 0.988200
R10882 n1_M2_2220_86460 n1_M2_3300_86460 0.988200
R10883 n1_M2_3300_86460 n1_M2_4380_86460 0.988200
R10884 n1_M2_4380_86460 n1_M2_5460_86460 0.988200
R10885 n1_M2_5460_86460 n1_M2_6540_86460 0.988200
R10886 n1_M2_6540_86460 n1_M2_7620_86460 0.988200
R10887 n1_M2_7620_86460 n1_M2_8700_86460 0.988200
R10888 n1_M2_8700_86460 n1_M2_9780_86460 0.988200
R10889 n1_M2_9780_86460 n1_M2_10860_86460 0.988200
R10890 n1_M2_10860_86460 n1_M2_11940_86460 0.988200
R10891 n1_M2_11940_86460 n1_M2_13020_86460 0.988200
R10892 n1_M2_13020_86460 n1_M2_14100_86460 0.988200
R10893 n1_M2_14100_86460 n1_M2_15180_86460 0.988200
R10894 n1_M2_15180_86460 n1_M2_16260_86460 0.988200
R10895 n1_M2_16260_86460 n1_M2_17340_86460 0.988200
R10896 n1_M2_17340_86460 n1_M2_18420_86460 0.988200
R10897 n1_M2_18420_86460 n1_M2_19500_86460 0.988200
R10898 n1_M2_19500_86460 n1_M2_20580_86460 0.988200
R10899 n1_M2_20580_86460 n1_M2_21660_86460 0.988200
R10900 n1_M2_21660_86460 n1_M2_22740_86460 0.988200
R10901 n1_M2_22740_86460 n1_M2_23820_86460 0.988200
R10902 n1_M2_23820_86460 n1_M2_24900_86460 0.988200
R10903 n1_M2_24900_86460 n1_M2_25980_86460 0.988200
R10904 n1_M2_25980_86460 n1_M2_27060_86460 0.988200
R10905 n1_M2_27060_86460 n1_M2_28140_86460 0.988200
R10906 n1_M2_28140_86460 n1_M2_29220_86460 0.988200
R10907 n1_M2_29220_86460 n1_M2_30300_86460 0.988200
R10908 n1_M2_30300_86460 n1_M2_31380_86460 0.988200
R10909 n1_M2_31380_86460 n1_M2_32460_86460 0.988200
R10910 n1_M2_32460_86460 n1_M2_33540_86460 0.988200
R10911 n1_M2_33540_86460 n1_M2_34620_86460 0.988200
R10912 n1_M2_34620_86460 n1_M2_35700_86460 0.988200
R10913 n1_M2_35700_86460 n1_M2_36780_86460 0.988200
R10914 n1_M2_36780_86460 n1_M2_37860_86460 0.988200
R10915 n1_M2_37860_86460 n1_M2_38940_86460 0.988200
R10916 n1_M2_38940_86460 n1_M2_40020_86460 0.988200
R10917 n1_M2_40020_86460 n1_M2_41100_86460 0.988200
R10918 n1_M2_41100_86460 n1_M2_42180_86460 0.988200
R10919 n1_M2_42180_86460 n1_M2_43260_86460 0.988200
R10920 n1_M2_43260_86460 n1_M2_44340_86460 0.988200
R10921 n1_M2_44340_86460 n1_M2_45420_86460 0.988200
R10922 n1_M2_45420_86460 n1_M2_46500_86460 0.988200
R10923 n1_M2_46500_86460 n1_M2_47580_86460 0.988200
R10924 n1_M2_47580_86460 n1_M2_48660_86460 0.988200
R10925 n1_M2_48660_86460 n1_M2_49740_86460 0.988200
R10926 n1_M2_49740_86460 n1_M2_50820_86460 0.988200
R10927 n1_M2_50820_86460 n1_M2_51900_86460 0.988200
R10928 n1_M2_51900_86460 n1_M2_52980_86460 0.988200
R10929 n1_M2_52980_86460 n1_M2_54060_86460 0.988200
R10930 n1_M2_54060_86460 n1_M2_55140_86460 0.988200
R10931 n1_M2_55140_86460 n1_M2_56220_86460 0.988200
R10932 n1_M2_56220_86460 n1_M2_57300_86460 0.988200
R10933 n1_M2_57300_86460 n1_M2_58380_86460 0.988200
R10934 n1_M2_58380_86460 n1_M2_59460_86460 0.988200
R10935 n1_M2_59460_86460 n1_M2_60540_86460 0.988200
R10936 n1_M2_60540_86460 n1_M2_61620_86460 0.988200
R10937 n1_M2_61620_86460 n1_M2_62700_86460 0.988200
R10938 n1_M2_62700_86460 n1_M2_63780_86460 0.988200
R10939 n1_M2_63780_86460 n1_M2_64860_86460 0.988200
R10940 n1_M2_64860_86460 n1_M2_65940_86460 0.988200
R10941 n1_M2_65940_86460 n1_M2_67020_86460 0.988200
R10942 n1_M2_67020_86460 n1_M2_68100_86460 0.988200
R10943 n1_M2_68100_86460 n1_M2_69180_86460 0.988200
R10944 n1_M2_69180_86460 n1_M2_70260_86460 0.988200
R10945 n1_M2_70260_86460 n1_M2_71340_86460 0.988200
R10946 n1_M2_71340_86460 n1_M2_72420_86460 0.988200
R10947 n1_M2_72420_86460 n1_M2_73500_86460 0.988200
R10948 n1_M2_73500_86460 n1_M2_74580_86460 0.988200
R10949 n1_M2_74580_86460 n1_M2_75660_86460 0.988200
R10950 n1_M2_75660_86460 n1_M2_76740_86460 0.988200
R10951 n1_M2_76740_86460 n1_M2_77820_86460 0.988200
R10952 n1_M2_77820_86460 n1_M2_78900_86460 0.988200
R10953 n1_M2_78900_86460 n1_M2_79980_86460 0.988200
R10954 n1_M2_79980_86460 n1_M2_81060_86460 0.988200
R10955 n1_M2_81060_86460 n1_M2_82140_86460 0.988200
R10956 n1_M2_82140_86460 n1_M2_83220_86460 0.988200
R10957 n1_M2_83220_86460 n1_M2_84300_86460 0.988200
R10958 n1_M2_84300_86460 n1_M2_85380_86460 0.988200
R10959 n1_M2_85380_86460 n1_M2_86460_86460 0.988200
R10960 n1_M2_86460_86460 n1_M2_87540_86460 0.988200
R10961 n1_M2_87540_86460 n1_M2_88620_86460 0.988200
R10962 n1_M2_88620_86460 n1_M2_89700_86460 0.988200
R10963 n1_M2_89700_86460 n1_M2_90780_86460 0.988200
R10964 n1_M2_90780_86460 n1_M2_91860_86460 0.988200
R10965 n1_M2_91860_86460 n1_M2_92940_86460 0.988200
R10966 n1_M2_92940_86460 n1_M2_94020_86460 0.988200
R10967 n1_M2_94020_86460 n1_M2_95100_86460 0.988200
R10968 n1_M2_95100_86460 n1_M2_96180_86460 0.988200
R10969 n1_M2_96180_86460 n1_M2_97260_86460 0.988200
R10970 n1_M2_97260_86460 n1_M2_98340_86460 0.988200
R10971 n1_M2_98340_86460 n1_M2_99420_86460 0.988200
R10972 n1_M2_99420_86460 n1_M2_100500_86460 0.988200
R10973 n1_M2_100500_86460 n1_M2_101580_86460 0.988200
R10974 n1_M2_101580_86460 n1_M2_102660_86460 0.988200
R10975 n1_M2_102660_86460 n1_M2_103740_86460 0.988200
R10976 n1_M2_103740_86460 n1_M2_104820_86460 0.988200
R10977 n1_M2_104820_86460 n1_M2_105900_86460 0.988200
R10978 n1_M2_105900_86460 n1_M2_106980_86460 0.988200
R10979 n1_M2_106980_86460 n1_M2_108060_86460 0.988200
R10980 n1_M2_108060_86460 n1_M2_109140_86460 0.988200
R10981 n1_M2_109140_86460 n1_M2_110220_86460 0.988200
R10982 n1_M2_110220_86460 n1_M2_111300_86460 0.988200
R10983 n1_M2_111300_86460 n1_M2_112380_86460 0.988200
R10984 n1_M2_112380_86460 n1_M2_113460_86460 0.988200
R10985 n1_M2_113460_86460 n1_M2_114540_86460 0.988200
R10986 n1_M2_114540_86460 n1_M2_115620_86460 0.988200
R10987 n1_M2_115620_86460 n1_M2_116700_86460 0.988200
R10988 n1_M2_116700_86460 n1_M2_117780_86460 0.988200
R10989 n1_M2_117780_86460 n1_M2_118860_86460 0.988200
R10990 n1_M2_118860_86460 n1_M2_119940_86460 0.988200
R10991 n1_M2_119940_86460 n1_M2_121020_86460 0.988200
R10992 n1_M2_121020_86460 n1_M2_122100_86460 0.988200
R10993 n1_M2_122100_86460 n1_M2_123180_86460 0.988200
R10994 n1_M2_123180_86460 n1_M2_124260_86460 0.988200
R10995 n1_M2_124260_86460 n1_M2_125340_86460 0.988200
R10996 n1_M2_125340_86460 n1_M2_126420_86460 0.988200
R10997 n1_M2_126420_86460 n1_M2_127500_86460 0.988200
R10998 n1_M2_127500_86460 n1_M2_128580_86460 0.988200
R10999 n1_M2_128580_86460 n1_M2_129660_86460 0.988200
R11000 n1_M2_129660_86460 n1_M2_130740_86460 0.988200
R11001 n1_M2_130740_86460 n1_M2_131820_86460 0.988200
R11002 n1_M2_131820_86460 n1_M2_132900_86460 0.988200
R11003 n1_M2_132900_86460 n1_M2_133980_86460 0.988200
R11004 n1_M2_133980_86460 n1_M2_135060_86460 0.988200
R11005 n1_M2_135060_86460 n1_M2_136140_86460 0.988200
R11006 n1_M2_136140_86460 n1_M2_137220_86460 0.988200
R11007 n1_M2_137220_86460 n1_M2_138300_86460 0.988200
R11008 n1_M2_138300_86460 n1_M2_139380_86460 0.988200
R11009 n1_M2_139380_86460 n1_M2_140460_86460 0.988200
R11010 n1_M2_140460_86460 n1_M2_141540_86460 0.988200
R11011 n1_M2_141540_86460 n1_M2_142620_86460 0.988200
R11012 n1_M2_142620_86460 n1_M2_143700_86460 0.988200
R11013 n1_M2_143700_86460 n1_M2_144780_86460 0.988200
R11014 n1_M2_144780_86460 n1_M2_145860_86460 0.988200
R11015 n1_M2_145860_86460 n1_M2_146940_86460 0.988200
R11016 n1_M2_60_87540 n1_M2_1140_87540 0.988200
R11017 n1_M2_1140_87540 n1_M2_2220_87540 0.988200
R11018 n1_M2_2220_87540 n1_M2_3300_87540 0.988200
R11019 n1_M2_3300_87540 n1_M2_4380_87540 0.988200
R11020 n1_M2_4380_87540 n1_M2_5460_87540 0.988200
R11021 n1_M2_5460_87540 n1_M2_6540_87540 0.988200
R11022 n1_M2_6540_87540 n1_M2_7620_87540 0.988200
R11023 n1_M2_7620_87540 n1_M2_8700_87540 0.988200
R11024 n1_M2_8700_87540 n1_M2_9780_87540 0.988200
R11025 n1_M2_9780_87540 n1_M2_10860_87540 0.988200
R11026 n1_M2_10860_87540 n1_M2_11940_87540 0.988200
R11027 n1_M2_11940_87540 n1_M2_13020_87540 0.988200
R11028 n1_M2_13020_87540 n1_M2_14100_87540 0.988200
R11029 n1_M2_14100_87540 n1_M2_15180_87540 0.988200
R11030 n1_M2_15180_87540 n1_M2_16260_87540 0.988200
R11031 n1_M2_16260_87540 n1_M2_17340_87540 0.988200
R11032 n1_M2_17340_87540 n1_M2_18420_87540 0.988200
R11033 n1_M2_18420_87540 n1_M2_19500_87540 0.988200
R11034 n1_M2_19500_87540 n1_M2_20580_87540 0.988200
R11035 n1_M2_20580_87540 n1_M2_21660_87540 0.988200
R11036 n1_M2_21660_87540 n1_M2_22740_87540 0.988200
R11037 n1_M2_22740_87540 n1_M2_23820_87540 0.988200
R11038 n1_M2_23820_87540 n1_M2_24900_87540 0.988200
R11039 n1_M2_24900_87540 n1_M2_25980_87540 0.988200
R11040 n1_M2_25980_87540 n1_M2_27060_87540 0.988200
R11041 n1_M2_27060_87540 n1_M2_28140_87540 0.988200
R11042 n1_M2_28140_87540 n1_M2_29220_87540 0.988200
R11043 n1_M2_29220_87540 n1_M2_30300_87540 0.988200
R11044 n1_M2_30300_87540 n1_M2_31380_87540 0.988200
R11045 n1_M2_31380_87540 n1_M2_32460_87540 0.988200
R11046 n1_M2_32460_87540 n1_M2_33540_87540 0.988200
R11047 n1_M2_33540_87540 n1_M2_34620_87540 0.988200
R11048 n1_M2_34620_87540 n1_M2_35700_87540 0.988200
R11049 n1_M2_35700_87540 n1_M2_36780_87540 0.988200
R11050 n1_M2_36780_87540 n1_M2_37860_87540 0.988200
R11051 n1_M2_37860_87540 n1_M2_38940_87540 0.988200
R11052 n1_M2_38940_87540 n1_M2_40020_87540 0.988200
R11053 n1_M2_40020_87540 n1_M2_41100_87540 0.988200
R11054 n1_M2_41100_87540 n1_M2_42180_87540 0.988200
R11055 n1_M2_42180_87540 n1_M2_43260_87540 0.988200
R11056 n1_M2_43260_87540 n1_M2_44340_87540 0.988200
R11057 n1_M2_44340_87540 n1_M2_45420_87540 0.988200
R11058 n1_M2_45420_87540 n1_M2_46500_87540 0.988200
R11059 n1_M2_46500_87540 n1_M2_47580_87540 0.988200
R11060 n1_M2_47580_87540 n1_M2_48660_87540 0.988200
R11061 n1_M2_48660_87540 n1_M2_49740_87540 0.988200
R11062 n1_M2_49740_87540 n1_M2_50820_87540 0.988200
R11063 n1_M2_50820_87540 n1_M2_51900_87540 0.988200
R11064 n1_M2_51900_87540 n1_M2_52980_87540 0.988200
R11065 n1_M2_52980_87540 n1_M2_54060_87540 0.988200
R11066 n1_M2_54060_87540 n1_M2_55140_87540 0.988200
R11067 n1_M2_55140_87540 n1_M2_56220_87540 0.988200
R11068 n1_M2_56220_87540 n1_M2_57300_87540 0.988200
R11069 n1_M2_57300_87540 n1_M2_58380_87540 0.988200
R11070 n1_M2_58380_87540 n1_M2_59460_87540 0.988200
R11071 n1_M2_59460_87540 n1_M2_60540_87540 0.988200
R11072 n1_M2_60540_87540 n1_M2_61620_87540 0.988200
R11073 n1_M2_61620_87540 n1_M2_62700_87540 0.988200
R11074 n1_M2_62700_87540 n1_M2_63780_87540 0.988200
R11075 n1_M2_63780_87540 n1_M2_64860_87540 0.988200
R11076 n1_M2_64860_87540 n1_M2_65940_87540 0.988200
R11077 n1_M2_65940_87540 n1_M2_67020_87540 0.988200
R11078 n1_M2_67020_87540 n1_M2_68100_87540 0.988200
R11079 n1_M2_68100_87540 n1_M2_69180_87540 0.988200
R11080 n1_M2_69180_87540 n1_M2_70260_87540 0.988200
R11081 n1_M2_70260_87540 n1_M2_71340_87540 0.988200
R11082 n1_M2_71340_87540 n1_M2_72420_87540 0.988200
R11083 n1_M2_72420_87540 n1_M2_73500_87540 0.988200
R11084 n1_M2_73500_87540 n1_M2_74580_87540 0.988200
R11085 n1_M2_74580_87540 n1_M2_75660_87540 0.988200
R11086 n1_M2_75660_87540 n1_M2_76740_87540 0.988200
R11087 n1_M2_76740_87540 n1_M2_77820_87540 0.988200
R11088 n1_M2_77820_87540 n1_M2_78900_87540 0.988200
R11089 n1_M2_78900_87540 n1_M2_79980_87540 0.988200
R11090 n1_M2_79980_87540 n1_M2_81060_87540 0.988200
R11091 n1_M2_81060_87540 n1_M2_82140_87540 0.988200
R11092 n1_M2_82140_87540 n1_M2_83220_87540 0.988200
R11093 n1_M2_83220_87540 n1_M2_84300_87540 0.988200
R11094 n1_M2_84300_87540 n1_M2_85380_87540 0.988200
R11095 n1_M2_85380_87540 n1_M2_86460_87540 0.988200
R11096 n1_M2_86460_87540 n1_M2_87540_87540 0.988200
R11097 n1_M2_87540_87540 n1_M2_88620_87540 0.988200
R11098 n1_M2_88620_87540 n1_M2_89700_87540 0.988200
R11099 n1_M2_89700_87540 n1_M2_90780_87540 0.988200
R11100 n1_M2_90780_87540 n1_M2_91860_87540 0.988200
R11101 n1_M2_91860_87540 n1_M2_92940_87540 0.988200
R11102 n1_M2_92940_87540 n1_M2_94020_87540 0.988200
R11103 n1_M2_94020_87540 n1_M2_95100_87540 0.988200
R11104 n1_M2_95100_87540 n1_M2_96180_87540 0.988200
R11105 n1_M2_96180_87540 n1_M2_97260_87540 0.988200
R11106 n1_M2_97260_87540 n1_M2_98340_87540 0.988200
R11107 n1_M2_98340_87540 n1_M2_99420_87540 0.988200
R11108 n1_M2_99420_87540 n1_M2_100500_87540 0.988200
R11109 n1_M2_100500_87540 n1_M2_101580_87540 0.988200
R11110 n1_M2_101580_87540 n1_M2_102660_87540 0.988200
R11111 n1_M2_102660_87540 n1_M2_103740_87540 0.988200
R11112 n1_M2_103740_87540 n1_M2_104820_87540 0.988200
R11113 n1_M2_104820_87540 n1_M2_105900_87540 0.988200
R11114 n1_M2_105900_87540 n1_M2_106980_87540 0.988200
R11115 n1_M2_106980_87540 n1_M2_108060_87540 0.988200
R11116 n1_M2_108060_87540 n1_M2_109140_87540 0.988200
R11117 n1_M2_109140_87540 n1_M2_110220_87540 0.988200
R11118 n1_M2_110220_87540 n1_M2_111300_87540 0.988200
R11119 n1_M2_111300_87540 n1_M2_112380_87540 0.988200
R11120 n1_M2_112380_87540 n1_M2_113460_87540 0.988200
R11121 n1_M2_113460_87540 n1_M2_114540_87540 0.988200
R11122 n1_M2_114540_87540 n1_M2_115620_87540 0.988200
R11123 n1_M2_115620_87540 n1_M2_116700_87540 0.988200
R11124 n1_M2_116700_87540 n1_M2_117780_87540 0.988200
R11125 n1_M2_117780_87540 n1_M2_118860_87540 0.988200
R11126 n1_M2_118860_87540 n1_M2_119940_87540 0.988200
R11127 n1_M2_119940_87540 n1_M2_121020_87540 0.988200
R11128 n1_M2_121020_87540 n1_M2_122100_87540 0.988200
R11129 n1_M2_122100_87540 n1_M2_123180_87540 0.988200
R11130 n1_M2_123180_87540 n1_M2_124260_87540 0.988200
R11131 n1_M2_124260_87540 n1_M2_125340_87540 0.988200
R11132 n1_M2_125340_87540 n1_M2_126420_87540 0.988200
R11133 n1_M2_126420_87540 n1_M2_127500_87540 0.988200
R11134 n1_M2_127500_87540 n1_M2_128580_87540 0.988200
R11135 n1_M2_128580_87540 n1_M2_129660_87540 0.988200
R11136 n1_M2_129660_87540 n1_M2_130740_87540 0.988200
R11137 n1_M2_130740_87540 n1_M2_131820_87540 0.988200
R11138 n1_M2_131820_87540 n1_M2_132900_87540 0.988200
R11139 n1_M2_132900_87540 n1_M2_133980_87540 0.988200
R11140 n1_M2_133980_87540 n1_M2_135060_87540 0.988200
R11141 n1_M2_135060_87540 n1_M2_136140_87540 0.988200
R11142 n1_M2_136140_87540 n1_M2_137220_87540 0.988200
R11143 n1_M2_137220_87540 n1_M2_138300_87540 0.988200
R11144 n1_M2_138300_87540 n1_M2_139380_87540 0.988200
R11145 n1_M2_139380_87540 n1_M2_140460_87540 0.988200
R11146 n1_M2_140460_87540 n1_M2_141540_87540 0.988200
R11147 n1_M2_141540_87540 n1_M2_142620_87540 0.988200
R11148 n1_M2_142620_87540 n1_M2_143700_87540 0.988200
R11149 n1_M2_143700_87540 n1_M2_144780_87540 0.988200
R11150 n1_M2_144780_87540 n1_M2_145860_87540 0.988200
R11151 n1_M2_145860_87540 n1_M2_146940_87540 0.988200
R11152 n1_M2_60_88620 n1_M2_1140_88620 0.988200
R11153 n1_M2_1140_88620 n1_M2_2220_88620 0.988200
R11154 n1_M2_2220_88620 n1_M2_3300_88620 0.988200
R11155 n1_M2_3300_88620 n1_M2_4380_88620 0.988200
R11156 n1_M2_4380_88620 n1_M2_5460_88620 0.988200
R11157 n1_M2_5460_88620 n1_M2_6540_88620 0.988200
R11158 n1_M2_6540_88620 n1_M2_7620_88620 0.988200
R11159 n1_M2_7620_88620 n1_M2_8700_88620 0.988200
R11160 n1_M2_8700_88620 n1_M2_9780_88620 0.988200
R11161 n1_M2_9780_88620 n1_M2_10860_88620 0.988200
R11162 n1_M2_10860_88620 n1_M2_11940_88620 0.988200
R11163 n1_M2_11940_88620 n1_M2_13020_88620 0.988200
R11164 n1_M2_13020_88620 n1_M2_14100_88620 0.988200
R11165 n1_M2_14100_88620 n1_M2_15180_88620 0.988200
R11166 n1_M2_15180_88620 n1_M2_16260_88620 0.988200
R11167 n1_M2_16260_88620 n1_M2_17340_88620 0.988200
R11168 n1_M2_17340_88620 n1_M2_18420_88620 0.988200
R11169 n1_M2_18420_88620 n1_M2_19500_88620 0.988200
R11170 n1_M2_19500_88620 n1_M2_20580_88620 0.988200
R11171 n1_M2_20580_88620 n1_M2_21660_88620 0.988200
R11172 n1_M2_21660_88620 n1_M2_22740_88620 0.988200
R11173 n1_M2_22740_88620 n1_M2_23820_88620 0.988200
R11174 n1_M2_23820_88620 n1_M2_24900_88620 0.988200
R11175 n1_M2_24900_88620 n1_M2_25980_88620 0.988200
R11176 n1_M2_25980_88620 n1_M2_27060_88620 0.988200
R11177 n1_M2_27060_88620 n1_M2_28140_88620 0.988200
R11178 n1_M2_28140_88620 n1_M2_29220_88620 0.988200
R11179 n1_M2_29220_88620 n1_M2_30300_88620 0.988200
R11180 n1_M2_30300_88620 n1_M2_31380_88620 0.988200
R11181 n1_M2_31380_88620 n1_M2_32460_88620 0.988200
R11182 n1_M2_32460_88620 n1_M2_33540_88620 0.988200
R11183 n1_M2_33540_88620 n1_M2_34620_88620 0.988200
R11184 n1_M2_34620_88620 n1_M2_35700_88620 0.988200
R11185 n1_M2_35700_88620 n1_M2_36780_88620 0.988200
R11186 n1_M2_36780_88620 n1_M2_37860_88620 0.988200
R11187 n1_M2_37860_88620 n1_M2_38940_88620 0.988200
R11188 n1_M2_38940_88620 n1_M2_40020_88620 0.988200
R11189 n1_M2_40020_88620 n1_M2_41100_88620 0.988200
R11190 n1_M2_41100_88620 n1_M2_42180_88620 0.988200
R11191 n1_M2_42180_88620 n1_M2_43260_88620 0.988200
R11192 n1_M2_43260_88620 n1_M2_44340_88620 0.988200
R11193 n1_M2_44340_88620 n1_M2_45420_88620 0.988200
R11194 n1_M2_45420_88620 n1_M2_46500_88620 0.988200
R11195 n1_M2_46500_88620 n1_M2_47580_88620 0.988200
R11196 n1_M2_47580_88620 n1_M2_48660_88620 0.988200
R11197 n1_M2_48660_88620 n1_M2_49740_88620 0.988200
R11198 n1_M2_49740_88620 n1_M2_50820_88620 0.988200
R11199 n1_M2_50820_88620 n1_M2_51900_88620 0.988200
R11200 n1_M2_51900_88620 n1_M2_52980_88620 0.988200
R11201 n1_M2_52980_88620 n1_M2_54060_88620 0.988200
R11202 n1_M2_54060_88620 n1_M2_55140_88620 0.988200
R11203 n1_M2_55140_88620 n1_M2_56220_88620 0.988200
R11204 n1_M2_56220_88620 n1_M2_57300_88620 0.988200
R11205 n1_M2_57300_88620 n1_M2_58380_88620 0.988200
R11206 n1_M2_58380_88620 n1_M2_59460_88620 0.988200
R11207 n1_M2_59460_88620 n1_M2_60540_88620 0.988200
R11208 n1_M2_60540_88620 n1_M2_61620_88620 0.988200
R11209 n1_M2_61620_88620 n1_M2_62700_88620 0.988200
R11210 n1_M2_62700_88620 n1_M2_63780_88620 0.988200
R11211 n1_M2_63780_88620 n1_M2_64860_88620 0.988200
R11212 n1_M2_64860_88620 n1_M2_65940_88620 0.988200
R11213 n1_M2_65940_88620 n1_M2_67020_88620 0.988200
R11214 n1_M2_67020_88620 n1_M2_68100_88620 0.988200
R11215 n1_M2_68100_88620 n1_M2_69180_88620 0.988200
R11216 n1_M2_69180_88620 n1_M2_70260_88620 0.988200
R11217 n1_M2_70260_88620 n1_M2_71340_88620 0.988200
R11218 n1_M2_71340_88620 n1_M2_72420_88620 0.988200
R11219 n1_M2_72420_88620 n1_M2_73500_88620 0.988200
R11220 n1_M2_73500_88620 n1_M2_74580_88620 0.988200
R11221 n1_M2_74580_88620 n1_M2_75660_88620 0.988200
R11222 n1_M2_75660_88620 n1_M2_76740_88620 0.988200
R11223 n1_M2_76740_88620 n1_M2_77820_88620 0.988200
R11224 n1_M2_77820_88620 n1_M2_78900_88620 0.988200
R11225 n1_M2_78900_88620 n1_M2_79980_88620 0.988200
R11226 n1_M2_79980_88620 n1_M2_81060_88620 0.988200
R11227 n1_M2_81060_88620 n1_M2_82140_88620 0.988200
R11228 n1_M2_82140_88620 n1_M2_83220_88620 0.988200
R11229 n1_M2_83220_88620 n1_M2_84300_88620 0.988200
R11230 n1_M2_84300_88620 n1_M2_85380_88620 0.988200
R11231 n1_M2_85380_88620 n1_M2_86460_88620 0.988200
R11232 n1_M2_86460_88620 n1_M2_87540_88620 0.988200
R11233 n1_M2_87540_88620 n1_M2_88620_88620 0.988200
R11234 n1_M2_88620_88620 n1_M2_89700_88620 0.988200
R11235 n1_M2_89700_88620 n1_M2_90780_88620 0.988200
R11236 n1_M2_90780_88620 n1_M2_91860_88620 0.988200
R11237 n1_M2_91860_88620 n1_M2_92940_88620 0.988200
R11238 n1_M2_92940_88620 n1_M2_94020_88620 0.988200
R11239 n1_M2_94020_88620 n1_M2_95100_88620 0.988200
R11240 n1_M2_95100_88620 n1_M2_96180_88620 0.988200
R11241 n1_M2_96180_88620 n1_M2_97260_88620 0.988200
R11242 n1_M2_97260_88620 n1_M2_98340_88620 0.988200
R11243 n1_M2_98340_88620 n1_M2_99420_88620 0.988200
R11244 n1_M2_99420_88620 n1_M2_100500_88620 0.988200
R11245 n1_M2_100500_88620 n1_M2_101580_88620 0.988200
R11246 n1_M2_101580_88620 n1_M2_102660_88620 0.988200
R11247 n1_M2_102660_88620 n1_M2_103740_88620 0.988200
R11248 n1_M2_103740_88620 n1_M2_104820_88620 0.988200
R11249 n1_M2_104820_88620 n1_M2_105900_88620 0.988200
R11250 n1_M2_105900_88620 n1_M2_106980_88620 0.988200
R11251 n1_M2_106980_88620 n1_M2_108060_88620 0.988200
R11252 n1_M2_108060_88620 n1_M2_109140_88620 0.988200
R11253 n1_M2_109140_88620 n1_M2_110220_88620 0.988200
R11254 n1_M2_110220_88620 n1_M2_111300_88620 0.988200
R11255 n1_M2_111300_88620 n1_M2_112380_88620 0.988200
R11256 n1_M2_112380_88620 n1_M2_113460_88620 0.988200
R11257 n1_M2_113460_88620 n1_M2_114540_88620 0.988200
R11258 n1_M2_114540_88620 n1_M2_115620_88620 0.988200
R11259 n1_M2_115620_88620 n1_M2_116700_88620 0.988200
R11260 n1_M2_116700_88620 n1_M2_117780_88620 0.988200
R11261 n1_M2_117780_88620 n1_M2_118860_88620 0.988200
R11262 n1_M2_118860_88620 n1_M2_119940_88620 0.988200
R11263 n1_M2_119940_88620 n1_M2_121020_88620 0.988200
R11264 n1_M2_121020_88620 n1_M2_122100_88620 0.988200
R11265 n1_M2_122100_88620 n1_M2_123180_88620 0.988200
R11266 n1_M2_123180_88620 n1_M2_124260_88620 0.988200
R11267 n1_M2_124260_88620 n1_M2_125340_88620 0.988200
R11268 n1_M2_125340_88620 n1_M2_126420_88620 0.988200
R11269 n1_M2_126420_88620 n1_M2_127500_88620 0.988200
R11270 n1_M2_127500_88620 n1_M2_128580_88620 0.988200
R11271 n1_M2_128580_88620 n1_M2_129660_88620 0.988200
R11272 n1_M2_129660_88620 n1_M2_130740_88620 0.988200
R11273 n1_M2_130740_88620 n1_M2_131820_88620 0.988200
R11274 n1_M2_131820_88620 n1_M2_132900_88620 0.988200
R11275 n1_M2_132900_88620 n1_M2_133980_88620 0.988200
R11276 n1_M2_133980_88620 n1_M2_135060_88620 0.988200
R11277 n1_M2_135060_88620 n1_M2_136140_88620 0.988200
R11278 n1_M2_136140_88620 n1_M2_137220_88620 0.988200
R11279 n1_M2_137220_88620 n1_M2_138300_88620 0.988200
R11280 n1_M2_138300_88620 n1_M2_139380_88620 0.988200
R11281 n1_M2_139380_88620 n1_M2_140460_88620 0.988200
R11282 n1_M2_140460_88620 n1_M2_141540_88620 0.988200
R11283 n1_M2_141540_88620 n1_M2_142620_88620 0.988200
R11284 n1_M2_142620_88620 n1_M2_143700_88620 0.988200
R11285 n1_M2_143700_88620 n1_M2_144780_88620 0.988200
R11286 n1_M2_144780_88620 n1_M2_145860_88620 0.988200
R11287 n1_M2_145860_88620 n1_M2_146940_88620 0.988200
R11288 n1_M2_60_89700 n1_M2_1140_89700 0.988200
R11289 n1_M2_1140_89700 n1_M2_2220_89700 0.988200
R11290 n1_M2_2220_89700 n1_M2_3300_89700 0.988200
R11291 n1_M2_3300_89700 n1_M2_4380_89700 0.988200
R11292 n1_M2_4380_89700 n1_M2_5460_89700 0.988200
R11293 n1_M2_5460_89700 n1_M2_6540_89700 0.988200
R11294 n1_M2_6540_89700 n1_M2_7620_89700 0.988200
R11295 n1_M2_7620_89700 n1_M2_8700_89700 0.988200
R11296 n1_M2_8700_89700 n1_M2_9780_89700 0.988200
R11297 n1_M2_9780_89700 n1_M2_10860_89700 0.988200
R11298 n1_M2_10860_89700 n1_M2_11940_89700 0.988200
R11299 n1_M2_11940_89700 n1_M2_13020_89700 0.988200
R11300 n1_M2_13020_89700 n1_M2_14100_89700 0.988200
R11301 n1_M2_14100_89700 n1_M2_15180_89700 0.988200
R11302 n1_M2_15180_89700 n1_M2_16260_89700 0.988200
R11303 n1_M2_16260_89700 n1_M2_17340_89700 0.988200
R11304 n1_M2_17340_89700 n1_M2_18420_89700 0.988200
R11305 n1_M2_18420_89700 n1_M2_19500_89700 0.988200
R11306 n1_M2_19500_89700 n1_M2_20580_89700 0.988200
R11307 n1_M2_20580_89700 n1_M2_21660_89700 0.988200
R11308 n1_M2_21660_89700 n1_M2_22740_89700 0.988200
R11309 n1_M2_22740_89700 n1_M2_23820_89700 0.988200
R11310 n1_M2_23820_89700 n1_M2_24900_89700 0.988200
R11311 n1_M2_24900_89700 n1_M2_25980_89700 0.988200
R11312 n1_M2_25980_89700 n1_M2_27060_89700 0.988200
R11313 n1_M2_27060_89700 n1_M2_28140_89700 0.988200
R11314 n1_M2_28140_89700 n1_M2_29220_89700 0.988200
R11315 n1_M2_29220_89700 n1_M2_30300_89700 0.988200
R11316 n1_M2_30300_89700 n1_M2_31380_89700 0.988200
R11317 n1_M2_31380_89700 n1_M2_32460_89700 0.988200
R11318 n1_M2_32460_89700 n1_M2_33540_89700 0.988200
R11319 n1_M2_33540_89700 n1_M2_34620_89700 0.988200
R11320 n1_M2_34620_89700 n1_M2_35700_89700 0.988200
R11321 n1_M2_35700_89700 n1_M2_36780_89700 0.988200
R11322 n1_M2_36780_89700 n1_M2_37860_89700 0.988200
R11323 n1_M2_37860_89700 n1_M2_38940_89700 0.988200
R11324 n1_M2_38940_89700 n1_M2_40020_89700 0.988200
R11325 n1_M2_40020_89700 n1_M2_41100_89700 0.988200
R11326 n1_M2_41100_89700 n1_M2_42180_89700 0.988200
R11327 n1_M2_42180_89700 n1_M2_43260_89700 0.988200
R11328 n1_M2_43260_89700 n1_M2_44340_89700 0.988200
R11329 n1_M2_44340_89700 n1_M2_45420_89700 0.988200
R11330 n1_M2_45420_89700 n1_M2_46500_89700 0.988200
R11331 n1_M2_46500_89700 n1_M2_47580_89700 0.988200
R11332 n1_M2_47580_89700 n1_M2_48660_89700 0.988200
R11333 n1_M2_48660_89700 n1_M2_49740_89700 0.988200
R11334 n1_M2_49740_89700 n1_M2_50820_89700 0.988200
R11335 n1_M2_50820_89700 n1_M2_51900_89700 0.988200
R11336 n1_M2_51900_89700 n1_M2_52980_89700 0.988200
R11337 n1_M2_52980_89700 n1_M2_54060_89700 0.988200
R11338 n1_M2_54060_89700 n1_M2_55140_89700 0.988200
R11339 n1_M2_55140_89700 n1_M2_56220_89700 0.988200
R11340 n1_M2_56220_89700 n1_M2_57300_89700 0.988200
R11341 n1_M2_57300_89700 n1_M2_58380_89700 0.988200
R11342 n1_M2_58380_89700 n1_M2_59460_89700 0.988200
R11343 n1_M2_59460_89700 n1_M2_60540_89700 0.988200
R11344 n1_M2_60540_89700 n1_M2_61620_89700 0.988200
R11345 n1_M2_61620_89700 n1_M2_62700_89700 0.988200
R11346 n1_M2_62700_89700 n1_M2_63780_89700 0.988200
R11347 n1_M2_63780_89700 n1_M2_64860_89700 0.988200
R11348 n1_M2_64860_89700 n1_M2_65940_89700 0.988200
R11349 n1_M2_65940_89700 n1_M2_67020_89700 0.988200
R11350 n1_M2_67020_89700 n1_M2_68100_89700 0.988200
R11351 n1_M2_68100_89700 n1_M2_69180_89700 0.988200
R11352 n1_M2_69180_89700 n1_M2_70260_89700 0.988200
R11353 n1_M2_70260_89700 n1_M2_71340_89700 0.988200
R11354 n1_M2_71340_89700 n1_M2_72420_89700 0.988200
R11355 n1_M2_72420_89700 n1_M2_73500_89700 0.988200
R11356 n1_M2_73500_89700 n1_M2_74580_89700 0.988200
R11357 n1_M2_74580_89700 n1_M2_75660_89700 0.988200
R11358 n1_M2_75660_89700 n1_M2_76740_89700 0.988200
R11359 n1_M2_76740_89700 n1_M2_77820_89700 0.988200
R11360 n1_M2_77820_89700 n1_M2_78900_89700 0.988200
R11361 n1_M2_78900_89700 n1_M2_79980_89700 0.988200
R11362 n1_M2_79980_89700 n1_M2_81060_89700 0.988200
R11363 n1_M2_81060_89700 n1_M2_82140_89700 0.988200
R11364 n1_M2_82140_89700 n1_M2_83220_89700 0.988200
R11365 n1_M2_83220_89700 n1_M2_84300_89700 0.988200
R11366 n1_M2_84300_89700 n1_M2_85380_89700 0.988200
R11367 n1_M2_85380_89700 n1_M2_86460_89700 0.988200
R11368 n1_M2_86460_89700 n1_M2_87540_89700 0.988200
R11369 n1_M2_87540_89700 n1_M2_88620_89700 0.988200
R11370 n1_M2_88620_89700 n1_M2_89700_89700 0.988200
R11371 n1_M2_89700_89700 n1_M2_90780_89700 0.988200
R11372 n1_M2_90780_89700 n1_M2_91860_89700 0.988200
R11373 n1_M2_91860_89700 n1_M2_92940_89700 0.988200
R11374 n1_M2_92940_89700 n1_M2_94020_89700 0.988200
R11375 n1_M2_94020_89700 n1_M2_95100_89700 0.988200
R11376 n1_M2_95100_89700 n1_M2_96180_89700 0.988200
R11377 n1_M2_96180_89700 n1_M2_97260_89700 0.988200
R11378 n1_M2_97260_89700 n1_M2_98340_89700 0.988200
R11379 n1_M2_98340_89700 n1_M2_99420_89700 0.988200
R11380 n1_M2_99420_89700 n1_M2_100500_89700 0.988200
R11381 n1_M2_100500_89700 n1_M2_101580_89700 0.988200
R11382 n1_M2_101580_89700 n1_M2_102660_89700 0.988200
R11383 n1_M2_102660_89700 n1_M2_103740_89700 0.988200
R11384 n1_M2_103740_89700 n1_M2_104820_89700 0.988200
R11385 n1_M2_104820_89700 n1_M2_105900_89700 0.988200
R11386 n1_M2_105900_89700 n1_M2_106980_89700 0.988200
R11387 n1_M2_106980_89700 n1_M2_108060_89700 0.988200
R11388 n1_M2_108060_89700 n1_M2_109140_89700 0.988200
R11389 n1_M2_109140_89700 n1_M2_110220_89700 0.988200
R11390 n1_M2_110220_89700 n1_M2_111300_89700 0.988200
R11391 n1_M2_111300_89700 n1_M2_112380_89700 0.988200
R11392 n1_M2_112380_89700 n1_M2_113460_89700 0.988200
R11393 n1_M2_113460_89700 n1_M2_114540_89700 0.988200
R11394 n1_M2_114540_89700 n1_M2_115620_89700 0.988200
R11395 n1_M2_115620_89700 n1_M2_116700_89700 0.988200
R11396 n1_M2_116700_89700 n1_M2_117780_89700 0.988200
R11397 n1_M2_117780_89700 n1_M2_118860_89700 0.988200
R11398 n1_M2_118860_89700 n1_M2_119940_89700 0.988200
R11399 n1_M2_119940_89700 n1_M2_121020_89700 0.988200
R11400 n1_M2_121020_89700 n1_M2_122100_89700 0.988200
R11401 n1_M2_122100_89700 n1_M2_123180_89700 0.988200
R11402 n1_M2_123180_89700 n1_M2_124260_89700 0.988200
R11403 n1_M2_124260_89700 n1_M2_125340_89700 0.988200
R11404 n1_M2_125340_89700 n1_M2_126420_89700 0.988200
R11405 n1_M2_126420_89700 n1_M2_127500_89700 0.988200
R11406 n1_M2_127500_89700 n1_M2_128580_89700 0.988200
R11407 n1_M2_128580_89700 n1_M2_129660_89700 0.988200
R11408 n1_M2_129660_89700 n1_M2_130740_89700 0.988200
R11409 n1_M2_130740_89700 n1_M2_131820_89700 0.988200
R11410 n1_M2_131820_89700 n1_M2_132900_89700 0.988200
R11411 n1_M2_132900_89700 n1_M2_133980_89700 0.988200
R11412 n1_M2_133980_89700 n1_M2_135060_89700 0.988200
R11413 n1_M2_135060_89700 n1_M2_136140_89700 0.988200
R11414 n1_M2_136140_89700 n1_M2_137220_89700 0.988200
R11415 n1_M2_137220_89700 n1_M2_138300_89700 0.988200
R11416 n1_M2_138300_89700 n1_M2_139380_89700 0.988200
R11417 n1_M2_139380_89700 n1_M2_140460_89700 0.988200
R11418 n1_M2_140460_89700 n1_M2_141540_89700 0.988200
R11419 n1_M2_141540_89700 n1_M2_142620_89700 0.988200
R11420 n1_M2_142620_89700 n1_M2_143700_89700 0.988200
R11421 n1_M2_143700_89700 n1_M2_144780_89700 0.988200
R11422 n1_M2_144780_89700 n1_M2_145860_89700 0.988200
R11423 n1_M2_145860_89700 n1_M2_146940_89700 0.988200
R11424 n1_M2_60_90780 n1_M2_1140_90780 0.988200
R11425 n1_M2_1140_90780 n1_M2_2220_90780 0.988200
R11426 n1_M2_2220_90780 n1_M2_3300_90780 0.988200
R11427 n1_M2_3300_90780 n1_M2_4380_90780 0.988200
R11428 n1_M2_4380_90780 n1_M2_5460_90780 0.988200
R11429 n1_M2_5460_90780 n1_M2_6540_90780 0.988200
R11430 n1_M2_6540_90780 n1_M2_7620_90780 0.988200
R11431 n1_M2_7620_90780 n1_M2_8700_90780 0.988200
R11432 n1_M2_8700_90780 n1_M2_9780_90780 0.988200
R11433 n1_M2_9780_90780 n1_M2_10860_90780 0.988200
R11434 n1_M2_10860_90780 n1_M2_11940_90780 0.988200
R11435 n1_M2_11940_90780 n1_M2_13020_90780 0.988200
R11436 n1_M2_13020_90780 n1_M2_14100_90780 0.988200
R11437 n1_M2_14100_90780 n1_M2_15180_90780 0.988200
R11438 n1_M2_15180_90780 n1_M2_16260_90780 0.988200
R11439 n1_M2_16260_90780 n1_M2_17340_90780 0.988200
R11440 n1_M2_17340_90780 n1_M2_18420_90780 0.988200
R11441 n1_M2_18420_90780 n1_M2_19500_90780 0.988200
R11442 n1_M2_19500_90780 n1_M2_20580_90780 0.988200
R11443 n1_M2_20580_90780 n1_M2_21660_90780 0.988200
R11444 n1_M2_21660_90780 n1_M2_22740_90780 0.988200
R11445 n1_M2_22740_90780 n1_M2_23820_90780 0.988200
R11446 n1_M2_23820_90780 n1_M2_24900_90780 0.988200
R11447 n1_M2_24900_90780 n1_M2_25980_90780 0.988200
R11448 n1_M2_25980_90780 n1_M2_27060_90780 0.988200
R11449 n1_M2_27060_90780 n1_M2_28140_90780 0.988200
R11450 n1_M2_28140_90780 n1_M2_29220_90780 0.988200
R11451 n1_M2_29220_90780 n1_M2_30300_90780 0.988200
R11452 n1_M2_30300_90780 n1_M2_31380_90780 0.988200
R11453 n1_M2_31380_90780 n1_M2_32460_90780 0.988200
R11454 n1_M2_32460_90780 n1_M2_33540_90780 0.988200
R11455 n1_M2_33540_90780 n1_M2_34620_90780 0.988200
R11456 n1_M2_34620_90780 n1_M2_35700_90780 0.988200
R11457 n1_M2_35700_90780 n1_M2_36780_90780 0.988200
R11458 n1_M2_36780_90780 n1_M2_37860_90780 0.988200
R11459 n1_M2_37860_90780 n1_M2_38940_90780 0.988200
R11460 n1_M2_38940_90780 n1_M2_40020_90780 0.988200
R11461 n1_M2_40020_90780 n1_M2_41100_90780 0.988200
R11462 n1_M2_41100_90780 n1_M2_42180_90780 0.988200
R11463 n1_M2_42180_90780 n1_M2_43260_90780 0.988200
R11464 n1_M2_43260_90780 n1_M2_44340_90780 0.988200
R11465 n1_M2_44340_90780 n1_M2_45420_90780 0.988200
R11466 n1_M2_45420_90780 n1_M2_46500_90780 0.988200
R11467 n1_M2_46500_90780 n1_M2_47580_90780 0.988200
R11468 n1_M2_47580_90780 n1_M2_48660_90780 0.988200
R11469 n1_M2_48660_90780 n1_M2_49740_90780 0.988200
R11470 n1_M2_49740_90780 n1_M2_50820_90780 0.988200
R11471 n1_M2_50820_90780 n1_M2_51900_90780 0.988200
R11472 n1_M2_51900_90780 n1_M2_52980_90780 0.988200
R11473 n1_M2_52980_90780 n1_M2_54060_90780 0.988200
R11474 n1_M2_54060_90780 n1_M2_55140_90780 0.988200
R11475 n1_M2_55140_90780 n1_M2_56220_90780 0.988200
R11476 n1_M2_56220_90780 n1_M2_57300_90780 0.988200
R11477 n1_M2_57300_90780 n1_M2_58380_90780 0.988200
R11478 n1_M2_58380_90780 n1_M2_59460_90780 0.988200
R11479 n1_M2_59460_90780 n1_M2_60540_90780 0.988200
R11480 n1_M2_60540_90780 n1_M2_61620_90780 0.988200
R11481 n1_M2_61620_90780 n1_M2_62700_90780 0.988200
R11482 n1_M2_62700_90780 n1_M2_63780_90780 0.988200
R11483 n1_M2_63780_90780 n1_M2_64860_90780 0.988200
R11484 n1_M2_64860_90780 n1_M2_65940_90780 0.988200
R11485 n1_M2_65940_90780 n1_M2_67020_90780 0.988200
R11486 n1_M2_67020_90780 n1_M2_68100_90780 0.988200
R11487 n1_M2_68100_90780 n1_M2_69180_90780 0.988200
R11488 n1_M2_69180_90780 n1_M2_70260_90780 0.988200
R11489 n1_M2_70260_90780 n1_M2_71340_90780 0.988200
R11490 n1_M2_71340_90780 n1_M2_72420_90780 0.988200
R11491 n1_M2_72420_90780 n1_M2_73500_90780 0.988200
R11492 n1_M2_73500_90780 n1_M2_74580_90780 0.988200
R11493 n1_M2_74580_90780 n1_M2_75660_90780 0.988200
R11494 n1_M2_75660_90780 n1_M2_76740_90780 0.988200
R11495 n1_M2_76740_90780 n1_M2_77820_90780 0.988200
R11496 n1_M2_77820_90780 n1_M2_78900_90780 0.988200
R11497 n1_M2_78900_90780 n1_M2_79980_90780 0.988200
R11498 n1_M2_79980_90780 n1_M2_81060_90780 0.988200
R11499 n1_M2_81060_90780 n1_M2_82140_90780 0.988200
R11500 n1_M2_82140_90780 n1_M2_83220_90780 0.988200
R11501 n1_M2_83220_90780 n1_M2_84300_90780 0.988200
R11502 n1_M2_84300_90780 n1_M2_85380_90780 0.988200
R11503 n1_M2_85380_90780 n1_M2_86460_90780 0.988200
R11504 n1_M2_86460_90780 n1_M2_87540_90780 0.988200
R11505 n1_M2_87540_90780 n1_M2_88620_90780 0.988200
R11506 n1_M2_88620_90780 n1_M2_89700_90780 0.988200
R11507 n1_M2_89700_90780 n1_M2_90780_90780 0.988200
R11508 n1_M2_90780_90780 n1_M2_91860_90780 0.988200
R11509 n1_M2_91860_90780 n1_M2_92940_90780 0.988200
R11510 n1_M2_92940_90780 n1_M2_94020_90780 0.988200
R11511 n1_M2_94020_90780 n1_M2_95100_90780 0.988200
R11512 n1_M2_95100_90780 n1_M2_96180_90780 0.988200
R11513 n1_M2_96180_90780 n1_M2_97260_90780 0.988200
R11514 n1_M2_97260_90780 n1_M2_98340_90780 0.988200
R11515 n1_M2_98340_90780 n1_M2_99420_90780 0.988200
R11516 n1_M2_99420_90780 n1_M2_100500_90780 0.988200
R11517 n1_M2_100500_90780 n1_M2_101580_90780 0.988200
R11518 n1_M2_101580_90780 n1_M2_102660_90780 0.988200
R11519 n1_M2_102660_90780 n1_M2_103740_90780 0.988200
R11520 n1_M2_103740_90780 n1_M2_104820_90780 0.988200
R11521 n1_M2_104820_90780 n1_M2_105900_90780 0.988200
R11522 n1_M2_105900_90780 n1_M2_106980_90780 0.988200
R11523 n1_M2_106980_90780 n1_M2_108060_90780 0.988200
R11524 n1_M2_108060_90780 n1_M2_109140_90780 0.988200
R11525 n1_M2_109140_90780 n1_M2_110220_90780 0.988200
R11526 n1_M2_110220_90780 n1_M2_111300_90780 0.988200
R11527 n1_M2_111300_90780 n1_M2_112380_90780 0.988200
R11528 n1_M2_112380_90780 n1_M2_113460_90780 0.988200
R11529 n1_M2_113460_90780 n1_M2_114540_90780 0.988200
R11530 n1_M2_114540_90780 n1_M2_115620_90780 0.988200
R11531 n1_M2_115620_90780 n1_M2_116700_90780 0.988200
R11532 n1_M2_116700_90780 n1_M2_117780_90780 0.988200
R11533 n1_M2_117780_90780 n1_M2_118860_90780 0.988200
R11534 n1_M2_118860_90780 n1_M2_119940_90780 0.988200
R11535 n1_M2_119940_90780 n1_M2_121020_90780 0.988200
R11536 n1_M2_121020_90780 n1_M2_122100_90780 0.988200
R11537 n1_M2_122100_90780 n1_M2_123180_90780 0.988200
R11538 n1_M2_123180_90780 n1_M2_124260_90780 0.988200
R11539 n1_M2_124260_90780 n1_M2_125340_90780 0.988200
R11540 n1_M2_125340_90780 n1_M2_126420_90780 0.988200
R11541 n1_M2_126420_90780 n1_M2_127500_90780 0.988200
R11542 n1_M2_127500_90780 n1_M2_128580_90780 0.988200
R11543 n1_M2_128580_90780 n1_M2_129660_90780 0.988200
R11544 n1_M2_129660_90780 n1_M2_130740_90780 0.988200
R11545 n1_M2_130740_90780 n1_M2_131820_90780 0.988200
R11546 n1_M2_131820_90780 n1_M2_132900_90780 0.988200
R11547 n1_M2_132900_90780 n1_M2_133980_90780 0.988200
R11548 n1_M2_133980_90780 n1_M2_135060_90780 0.988200
R11549 n1_M2_135060_90780 n1_M2_136140_90780 0.988200
R11550 n1_M2_136140_90780 n1_M2_137220_90780 0.988200
R11551 n1_M2_137220_90780 n1_M2_138300_90780 0.988200
R11552 n1_M2_138300_90780 n1_M2_139380_90780 0.988200
R11553 n1_M2_139380_90780 n1_M2_140460_90780 0.988200
R11554 n1_M2_140460_90780 n1_M2_141540_90780 0.988200
R11555 n1_M2_141540_90780 n1_M2_142620_90780 0.988200
R11556 n1_M2_142620_90780 n1_M2_143700_90780 0.988200
R11557 n1_M2_143700_90780 n1_M2_144780_90780 0.988200
R11558 n1_M2_144780_90780 n1_M2_145860_90780 0.988200
R11559 n1_M2_145860_90780 n1_M2_146940_90780 0.988200
R11560 n1_M2_60_91860 n1_M2_1140_91860 0.988200
R11561 n1_M2_1140_91860 n1_M2_2220_91860 0.988200
R11562 n1_M2_2220_91860 n1_M2_3300_91860 0.988200
R11563 n1_M2_3300_91860 n1_M2_4380_91860 0.988200
R11564 n1_M2_4380_91860 n1_M2_5460_91860 0.988200
R11565 n1_M2_5460_91860 n1_M2_6540_91860 0.988200
R11566 n1_M2_6540_91860 n1_M2_7620_91860 0.988200
R11567 n1_M2_7620_91860 n1_M2_8700_91860 0.988200
R11568 n1_M2_8700_91860 n1_M2_9780_91860 0.988200
R11569 n1_M2_9780_91860 n1_M2_10860_91860 0.988200
R11570 n1_M2_10860_91860 n1_M2_11940_91860 0.988200
R11571 n1_M2_11940_91860 n1_M2_13020_91860 0.988200
R11572 n1_M2_13020_91860 n1_M2_14100_91860 0.988200
R11573 n1_M2_14100_91860 n1_M2_15180_91860 0.988200
R11574 n1_M2_15180_91860 n1_M2_16260_91860 0.988200
R11575 n1_M2_16260_91860 n1_M2_17340_91860 0.988200
R11576 n1_M2_17340_91860 n1_M2_18420_91860 0.988200
R11577 n1_M2_18420_91860 n1_M2_19500_91860 0.988200
R11578 n1_M2_19500_91860 n1_M2_20580_91860 0.988200
R11579 n1_M2_20580_91860 n1_M2_21660_91860 0.988200
R11580 n1_M2_21660_91860 n1_M2_22740_91860 0.988200
R11581 n1_M2_22740_91860 n1_M2_23820_91860 0.988200
R11582 n1_M2_23820_91860 n1_M2_24900_91860 0.988200
R11583 n1_M2_24900_91860 n1_M2_25980_91860 0.988200
R11584 n1_M2_25980_91860 n1_M2_27060_91860 0.988200
R11585 n1_M2_27060_91860 n1_M2_28140_91860 0.988200
R11586 n1_M2_28140_91860 n1_M2_29220_91860 0.988200
R11587 n1_M2_29220_91860 n1_M2_30300_91860 0.988200
R11588 n1_M2_30300_91860 n1_M2_31380_91860 0.988200
R11589 n1_M2_31380_91860 n1_M2_32460_91860 0.988200
R11590 n1_M2_32460_91860 n1_M2_33540_91860 0.988200
R11591 n1_M2_33540_91860 n1_M2_34620_91860 0.988200
R11592 n1_M2_34620_91860 n1_M2_35700_91860 0.988200
R11593 n1_M2_35700_91860 n1_M2_36780_91860 0.988200
R11594 n1_M2_36780_91860 n1_M2_37860_91860 0.988200
R11595 n1_M2_37860_91860 n1_M2_38940_91860 0.988200
R11596 n1_M2_38940_91860 n1_M2_40020_91860 0.988200
R11597 n1_M2_40020_91860 n1_M2_41100_91860 0.988200
R11598 n1_M2_41100_91860 n1_M2_42180_91860 0.988200
R11599 n1_M2_42180_91860 n1_M2_43260_91860 0.988200
R11600 n1_M2_43260_91860 n1_M2_44340_91860 0.988200
R11601 n1_M2_44340_91860 n1_M2_45420_91860 0.988200
R11602 n1_M2_45420_91860 n1_M2_46500_91860 0.988200
R11603 n1_M2_46500_91860 n1_M2_47580_91860 0.988200
R11604 n1_M2_47580_91860 n1_M2_48660_91860 0.988200
R11605 n1_M2_48660_91860 n1_M2_49740_91860 0.988200
R11606 n1_M2_49740_91860 n1_M2_50820_91860 0.988200
R11607 n1_M2_50820_91860 n1_M2_51900_91860 0.988200
R11608 n1_M2_51900_91860 n1_M2_52980_91860 0.988200
R11609 n1_M2_52980_91860 n1_M2_54060_91860 0.988200
R11610 n1_M2_54060_91860 n1_M2_55140_91860 0.988200
R11611 n1_M2_55140_91860 n1_M2_56220_91860 0.988200
R11612 n1_M2_56220_91860 n1_M2_57300_91860 0.988200
R11613 n1_M2_57300_91860 n1_M2_58380_91860 0.988200
R11614 n1_M2_58380_91860 n1_M2_59460_91860 0.988200
R11615 n1_M2_59460_91860 n1_M2_60540_91860 0.988200
R11616 n1_M2_60540_91860 n1_M2_61620_91860 0.988200
R11617 n1_M2_61620_91860 n1_M2_62700_91860 0.988200
R11618 n1_M2_62700_91860 n1_M2_63780_91860 0.988200
R11619 n1_M2_63780_91860 n1_M2_64860_91860 0.988200
R11620 n1_M2_64860_91860 n1_M2_65940_91860 0.988200
R11621 n1_M2_65940_91860 n1_M2_67020_91860 0.988200
R11622 n1_M2_67020_91860 n1_M2_68100_91860 0.988200
R11623 n1_M2_68100_91860 n1_M2_69180_91860 0.988200
R11624 n1_M2_69180_91860 n1_M2_70260_91860 0.988200
R11625 n1_M2_70260_91860 n1_M2_71340_91860 0.988200
R11626 n1_M2_71340_91860 n1_M2_72420_91860 0.988200
R11627 n1_M2_72420_91860 n1_M2_73500_91860 0.988200
R11628 n1_M2_73500_91860 n1_M2_74580_91860 0.988200
R11629 n1_M2_74580_91860 n1_M2_75660_91860 0.988200
R11630 n1_M2_75660_91860 n1_M2_76740_91860 0.988200
R11631 n1_M2_76740_91860 n1_M2_77820_91860 0.988200
R11632 n1_M2_77820_91860 n1_M2_78900_91860 0.988200
R11633 n1_M2_78900_91860 n1_M2_79980_91860 0.988200
R11634 n1_M2_79980_91860 n1_M2_81060_91860 0.988200
R11635 n1_M2_81060_91860 n1_M2_82140_91860 0.988200
R11636 n1_M2_82140_91860 n1_M2_83220_91860 0.988200
R11637 n1_M2_83220_91860 n1_M2_84300_91860 0.988200
R11638 n1_M2_84300_91860 n1_M2_85380_91860 0.988200
R11639 n1_M2_85380_91860 n1_M2_86460_91860 0.988200
R11640 n1_M2_86460_91860 n1_M2_87540_91860 0.988200
R11641 n1_M2_87540_91860 n1_M2_88620_91860 0.988200
R11642 n1_M2_88620_91860 n1_M2_89700_91860 0.988200
R11643 n1_M2_89700_91860 n1_M2_90780_91860 0.988200
R11644 n1_M2_90780_91860 n1_M2_91860_91860 0.988200
R11645 n1_M2_91860_91860 n1_M2_92940_91860 0.988200
R11646 n1_M2_92940_91860 n1_M2_94020_91860 0.988200
R11647 n1_M2_94020_91860 n1_M2_95100_91860 0.988200
R11648 n1_M2_95100_91860 n1_M2_96180_91860 0.988200
R11649 n1_M2_96180_91860 n1_M2_97260_91860 0.988200
R11650 n1_M2_97260_91860 n1_M2_98340_91860 0.988200
R11651 n1_M2_98340_91860 n1_M2_99420_91860 0.988200
R11652 n1_M2_99420_91860 n1_M2_100500_91860 0.988200
R11653 n1_M2_100500_91860 n1_M2_101580_91860 0.988200
R11654 n1_M2_101580_91860 n1_M2_102660_91860 0.988200
R11655 n1_M2_102660_91860 n1_M2_103740_91860 0.988200
R11656 n1_M2_103740_91860 n1_M2_104820_91860 0.988200
R11657 n1_M2_104820_91860 n1_M2_105900_91860 0.988200
R11658 n1_M2_105900_91860 n1_M2_106980_91860 0.988200
R11659 n1_M2_106980_91860 n1_M2_108060_91860 0.988200
R11660 n1_M2_108060_91860 n1_M2_109140_91860 0.988200
R11661 n1_M2_109140_91860 n1_M2_110220_91860 0.988200
R11662 n1_M2_110220_91860 n1_M2_111300_91860 0.988200
R11663 n1_M2_111300_91860 n1_M2_112380_91860 0.988200
R11664 n1_M2_112380_91860 n1_M2_113460_91860 0.988200
R11665 n1_M2_113460_91860 n1_M2_114540_91860 0.988200
R11666 n1_M2_114540_91860 n1_M2_115620_91860 0.988200
R11667 n1_M2_115620_91860 n1_M2_116700_91860 0.988200
R11668 n1_M2_116700_91860 n1_M2_117780_91860 0.988200
R11669 n1_M2_117780_91860 n1_M2_118860_91860 0.988200
R11670 n1_M2_118860_91860 n1_M2_119940_91860 0.988200
R11671 n1_M2_119940_91860 n1_M2_121020_91860 0.988200
R11672 n1_M2_121020_91860 n1_M2_122100_91860 0.988200
R11673 n1_M2_122100_91860 n1_M2_123180_91860 0.988200
R11674 n1_M2_123180_91860 n1_M2_124260_91860 0.988200
R11675 n1_M2_124260_91860 n1_M2_125340_91860 0.988200
R11676 n1_M2_125340_91860 n1_M2_126420_91860 0.988200
R11677 n1_M2_126420_91860 n1_M2_127500_91860 0.988200
R11678 n1_M2_127500_91860 n1_M2_128580_91860 0.988200
R11679 n1_M2_128580_91860 n1_M2_129660_91860 0.988200
R11680 n1_M2_129660_91860 n1_M2_130740_91860 0.988200
R11681 n1_M2_130740_91860 n1_M2_131820_91860 0.988200
R11682 n1_M2_131820_91860 n1_M2_132900_91860 0.988200
R11683 n1_M2_132900_91860 n1_M2_133980_91860 0.988200
R11684 n1_M2_133980_91860 n1_M2_135060_91860 0.988200
R11685 n1_M2_135060_91860 n1_M2_136140_91860 0.988200
R11686 n1_M2_136140_91860 n1_M2_137220_91860 0.988200
R11687 n1_M2_137220_91860 n1_M2_138300_91860 0.988200
R11688 n1_M2_138300_91860 n1_M2_139380_91860 0.988200
R11689 n1_M2_139380_91860 n1_M2_140460_91860 0.988200
R11690 n1_M2_140460_91860 n1_M2_141540_91860 0.988200
R11691 n1_M2_141540_91860 n1_M2_142620_91860 0.988200
R11692 n1_M2_142620_91860 n1_M2_143700_91860 0.988200
R11693 n1_M2_143700_91860 n1_M2_144780_91860 0.988200
R11694 n1_M2_144780_91860 n1_M2_145860_91860 0.988200
R11695 n1_M2_145860_91860 n1_M2_146940_91860 0.988200
R11696 n1_M2_60_92940 n1_M2_1140_92940 0.988200
R11697 n1_M2_1140_92940 n1_M2_2220_92940 0.988200
R11698 n1_M2_2220_92940 n1_M2_3300_92940 0.988200
R11699 n1_M2_3300_92940 n1_M2_4380_92940 0.988200
R11700 n1_M2_4380_92940 n1_M2_5460_92940 0.988200
R11701 n1_M2_5460_92940 n1_M2_6540_92940 0.988200
R11702 n1_M2_6540_92940 n1_M2_7620_92940 0.988200
R11703 n1_M2_7620_92940 n1_M2_8700_92940 0.988200
R11704 n1_M2_8700_92940 n1_M2_9780_92940 0.988200
R11705 n1_M2_9780_92940 n1_M2_10860_92940 0.988200
R11706 n1_M2_10860_92940 n1_M2_11940_92940 0.988200
R11707 n1_M2_11940_92940 n1_M2_13020_92940 0.988200
R11708 n1_M2_13020_92940 n1_M2_14100_92940 0.988200
R11709 n1_M2_14100_92940 n1_M2_15180_92940 0.988200
R11710 n1_M2_15180_92940 n1_M2_16260_92940 0.988200
R11711 n1_M2_16260_92940 n1_M2_17340_92940 0.988200
R11712 n1_M2_17340_92940 n1_M2_18420_92940 0.988200
R11713 n1_M2_18420_92940 n1_M2_19500_92940 0.988200
R11714 n1_M2_19500_92940 n1_M2_20580_92940 0.988200
R11715 n1_M2_20580_92940 n1_M2_21660_92940 0.988200
R11716 n1_M2_21660_92940 n1_M2_22740_92940 0.988200
R11717 n1_M2_22740_92940 n1_M2_23820_92940 0.988200
R11718 n1_M2_23820_92940 n1_M2_24900_92940 0.988200
R11719 n1_M2_24900_92940 n1_M2_25980_92940 0.988200
R11720 n1_M2_25980_92940 n1_M2_27060_92940 0.988200
R11721 n1_M2_27060_92940 n1_M2_28140_92940 0.988200
R11722 n1_M2_28140_92940 n1_M2_29220_92940 0.988200
R11723 n1_M2_29220_92940 n1_M2_30300_92940 0.988200
R11724 n1_M2_30300_92940 n1_M2_31380_92940 0.988200
R11725 n1_M2_31380_92940 n1_M2_32460_92940 0.988200
R11726 n1_M2_32460_92940 n1_M2_33540_92940 0.988200
R11727 n1_M2_33540_92940 n1_M2_34620_92940 0.988200
R11728 n1_M2_34620_92940 n1_M2_35700_92940 0.988200
R11729 n1_M2_35700_92940 n1_M2_36780_92940 0.988200
R11730 n1_M2_36780_92940 n1_M2_37860_92940 0.988200
R11731 n1_M2_37860_92940 n1_M2_38940_92940 0.988200
R11732 n1_M2_38940_92940 n1_M2_40020_92940 0.988200
R11733 n1_M2_40020_92940 n1_M2_41100_92940 0.988200
R11734 n1_M2_41100_92940 n1_M2_42180_92940 0.988200
R11735 n1_M2_42180_92940 n1_M2_43260_92940 0.988200
R11736 n1_M2_43260_92940 n1_M2_44340_92940 0.988200
R11737 n1_M2_44340_92940 n1_M2_45420_92940 0.988200
R11738 n1_M2_45420_92940 n1_M2_46500_92940 0.988200
R11739 n1_M2_46500_92940 n1_M2_47580_92940 0.988200
R11740 n1_M2_47580_92940 n1_M2_48660_92940 0.988200
R11741 n1_M2_48660_92940 n1_M2_49740_92940 0.988200
R11742 n1_M2_49740_92940 n1_M2_50820_92940 0.988200
R11743 n1_M2_50820_92940 n1_M2_51900_92940 0.988200
R11744 n1_M2_51900_92940 n1_M2_52980_92940 0.988200
R11745 n1_M2_52980_92940 n1_M2_54060_92940 0.988200
R11746 n1_M2_54060_92940 n1_M2_55140_92940 0.988200
R11747 n1_M2_55140_92940 n1_M2_56220_92940 0.988200
R11748 n1_M2_56220_92940 n1_M2_57300_92940 0.988200
R11749 n1_M2_57300_92940 n1_M2_58380_92940 0.988200
R11750 n1_M2_58380_92940 n1_M2_59460_92940 0.988200
R11751 n1_M2_59460_92940 n1_M2_60540_92940 0.988200
R11752 n1_M2_60540_92940 n1_M2_61620_92940 0.988200
R11753 n1_M2_61620_92940 n1_M2_62700_92940 0.988200
R11754 n1_M2_62700_92940 n1_M2_63780_92940 0.988200
R11755 n1_M2_63780_92940 n1_M2_64860_92940 0.988200
R11756 n1_M2_64860_92940 n1_M2_65940_92940 0.988200
R11757 n1_M2_65940_92940 n1_M2_67020_92940 0.988200
R11758 n1_M2_67020_92940 n1_M2_68100_92940 0.988200
R11759 n1_M2_68100_92940 n1_M2_69180_92940 0.988200
R11760 n1_M2_69180_92940 n1_M2_70260_92940 0.988200
R11761 n1_M2_70260_92940 n1_M2_71340_92940 0.988200
R11762 n1_M2_71340_92940 n1_M2_72420_92940 0.988200
R11763 n1_M2_72420_92940 n1_M2_73500_92940 0.988200
R11764 n1_M2_73500_92940 n1_M2_74580_92940 0.988200
R11765 n1_M2_74580_92940 n1_M2_75660_92940 0.988200
R11766 n1_M2_75660_92940 n1_M2_76740_92940 0.988200
R11767 n1_M2_76740_92940 n1_M2_77820_92940 0.988200
R11768 n1_M2_77820_92940 n1_M2_78900_92940 0.988200
R11769 n1_M2_78900_92940 n1_M2_79980_92940 0.988200
R11770 n1_M2_79980_92940 n1_M2_81060_92940 0.988200
R11771 n1_M2_81060_92940 n1_M2_82140_92940 0.988200
R11772 n1_M2_82140_92940 n1_M2_83220_92940 0.988200
R11773 n1_M2_83220_92940 n1_M2_84300_92940 0.988200
R11774 n1_M2_84300_92940 n1_M2_85380_92940 0.988200
R11775 n1_M2_85380_92940 n1_M2_86460_92940 0.988200
R11776 n1_M2_86460_92940 n1_M2_87540_92940 0.988200
R11777 n1_M2_87540_92940 n1_M2_88620_92940 0.988200
R11778 n1_M2_88620_92940 n1_M2_89700_92940 0.988200
R11779 n1_M2_89700_92940 n1_M2_90780_92940 0.988200
R11780 n1_M2_90780_92940 n1_M2_91860_92940 0.988200
R11781 n1_M2_91860_92940 n1_M2_92940_92940 0.988200
R11782 n1_M2_92940_92940 n1_M2_94020_92940 0.988200
R11783 n1_M2_94020_92940 n1_M2_95100_92940 0.988200
R11784 n1_M2_95100_92940 n1_M2_96180_92940 0.988200
R11785 n1_M2_96180_92940 n1_M2_97260_92940 0.988200
R11786 n1_M2_97260_92940 n1_M2_98340_92940 0.988200
R11787 n1_M2_98340_92940 n1_M2_99420_92940 0.988200
R11788 n1_M2_99420_92940 n1_M2_100500_92940 0.988200
R11789 n1_M2_100500_92940 n1_M2_101580_92940 0.988200
R11790 n1_M2_101580_92940 n1_M2_102660_92940 0.988200
R11791 n1_M2_102660_92940 n1_M2_103740_92940 0.988200
R11792 n1_M2_103740_92940 n1_M2_104820_92940 0.988200
R11793 n1_M2_104820_92940 n1_M2_105900_92940 0.988200
R11794 n1_M2_105900_92940 n1_M2_106980_92940 0.988200
R11795 n1_M2_106980_92940 n1_M2_108060_92940 0.988200
R11796 n1_M2_108060_92940 n1_M2_109140_92940 0.988200
R11797 n1_M2_109140_92940 n1_M2_110220_92940 0.988200
R11798 n1_M2_110220_92940 n1_M2_111300_92940 0.988200
R11799 n1_M2_111300_92940 n1_M2_112380_92940 0.988200
R11800 n1_M2_112380_92940 n1_M2_113460_92940 0.988200
R11801 n1_M2_113460_92940 n1_M2_114540_92940 0.988200
R11802 n1_M2_114540_92940 n1_M2_115620_92940 0.988200
R11803 n1_M2_115620_92940 n1_M2_116700_92940 0.988200
R11804 n1_M2_116700_92940 n1_M2_117780_92940 0.988200
R11805 n1_M2_117780_92940 n1_M2_118860_92940 0.988200
R11806 n1_M2_118860_92940 n1_M2_119940_92940 0.988200
R11807 n1_M2_119940_92940 n1_M2_121020_92940 0.988200
R11808 n1_M2_121020_92940 n1_M2_122100_92940 0.988200
R11809 n1_M2_122100_92940 n1_M2_123180_92940 0.988200
R11810 n1_M2_123180_92940 n1_M2_124260_92940 0.988200
R11811 n1_M2_124260_92940 n1_M2_125340_92940 0.988200
R11812 n1_M2_125340_92940 n1_M2_126420_92940 0.988200
R11813 n1_M2_126420_92940 n1_M2_127500_92940 0.988200
R11814 n1_M2_127500_92940 n1_M2_128580_92940 0.988200
R11815 n1_M2_128580_92940 n1_M2_129660_92940 0.988200
R11816 n1_M2_129660_92940 n1_M2_130740_92940 0.988200
R11817 n1_M2_130740_92940 n1_M2_131820_92940 0.988200
R11818 n1_M2_131820_92940 n1_M2_132900_92940 0.988200
R11819 n1_M2_132900_92940 n1_M2_133980_92940 0.988200
R11820 n1_M2_133980_92940 n1_M2_135060_92940 0.988200
R11821 n1_M2_135060_92940 n1_M2_136140_92940 0.988200
R11822 n1_M2_136140_92940 n1_M2_137220_92940 0.988200
R11823 n1_M2_137220_92940 n1_M2_138300_92940 0.988200
R11824 n1_M2_138300_92940 n1_M2_139380_92940 0.988200
R11825 n1_M2_139380_92940 n1_M2_140460_92940 0.988200
R11826 n1_M2_140460_92940 n1_M2_141540_92940 0.988200
R11827 n1_M2_141540_92940 n1_M2_142620_92940 0.988200
R11828 n1_M2_142620_92940 n1_M2_143700_92940 0.988200
R11829 n1_M2_143700_92940 n1_M2_144780_92940 0.988200
R11830 n1_M2_144780_92940 n1_M2_145860_92940 0.988200
R11831 n1_M2_145860_92940 n1_M2_146940_92940 0.988200
R11832 n1_M2_60_94020 n1_M2_1140_94020 0.988200
R11833 n1_M2_1140_94020 n1_M2_2220_94020 0.988200
R11834 n1_M2_2220_94020 n1_M2_3300_94020 0.988200
R11835 n1_M2_3300_94020 n1_M2_4380_94020 0.988200
R11836 n1_M2_4380_94020 n1_M2_5460_94020 0.988200
R11837 n1_M2_5460_94020 n1_M2_6540_94020 0.988200
R11838 n1_M2_6540_94020 n1_M2_7620_94020 0.988200
R11839 n1_M2_7620_94020 n1_M2_8700_94020 0.988200
R11840 n1_M2_8700_94020 n1_M2_9780_94020 0.988200
R11841 n1_M2_9780_94020 n1_M2_10860_94020 0.988200
R11842 n1_M2_10860_94020 n1_M2_11940_94020 0.988200
R11843 n1_M2_11940_94020 n1_M2_13020_94020 0.988200
R11844 n1_M2_13020_94020 n1_M2_14100_94020 0.988200
R11845 n1_M2_14100_94020 n1_M2_15180_94020 0.988200
R11846 n1_M2_15180_94020 n1_M2_16260_94020 0.988200
R11847 n1_M2_16260_94020 n1_M2_17340_94020 0.988200
R11848 n1_M2_17340_94020 n1_M2_18420_94020 0.988200
R11849 n1_M2_18420_94020 n1_M2_19500_94020 0.988200
R11850 n1_M2_19500_94020 n1_M2_20580_94020 0.988200
R11851 n1_M2_20580_94020 n1_M2_21660_94020 0.988200
R11852 n1_M2_21660_94020 n1_M2_22740_94020 0.988200
R11853 n1_M2_22740_94020 n1_M2_23820_94020 0.988200
R11854 n1_M2_23820_94020 n1_M2_24900_94020 0.988200
R11855 n1_M2_24900_94020 n1_M2_25980_94020 0.988200
R11856 n1_M2_25980_94020 n1_M2_27060_94020 0.988200
R11857 n1_M2_27060_94020 n1_M2_28140_94020 0.988200
R11858 n1_M2_28140_94020 n1_M2_29220_94020 0.988200
R11859 n1_M2_29220_94020 n1_M2_30300_94020 0.988200
R11860 n1_M2_30300_94020 n1_M2_31380_94020 0.988200
R11861 n1_M2_31380_94020 n1_M2_32460_94020 0.988200
R11862 n1_M2_32460_94020 n1_M2_33540_94020 0.988200
R11863 n1_M2_33540_94020 n1_M2_34620_94020 0.988200
R11864 n1_M2_34620_94020 n1_M2_35700_94020 0.988200
R11865 n1_M2_35700_94020 n1_M2_36780_94020 0.988200
R11866 n1_M2_36780_94020 n1_M2_37860_94020 0.988200
R11867 n1_M2_37860_94020 n1_M2_38940_94020 0.988200
R11868 n1_M2_38940_94020 n1_M2_40020_94020 0.988200
R11869 n1_M2_40020_94020 n1_M2_41100_94020 0.988200
R11870 n1_M2_41100_94020 n1_M2_42180_94020 0.988200
R11871 n1_M2_42180_94020 n1_M2_43260_94020 0.988200
R11872 n1_M2_43260_94020 n1_M2_44340_94020 0.988200
R11873 n1_M2_44340_94020 n1_M2_45420_94020 0.988200
R11874 n1_M2_45420_94020 n1_M2_46500_94020 0.988200
R11875 n1_M2_46500_94020 n1_M2_47580_94020 0.988200
R11876 n1_M2_47580_94020 n1_M2_48660_94020 0.988200
R11877 n1_M2_48660_94020 n1_M2_49740_94020 0.988200
R11878 n1_M2_49740_94020 n1_M2_50820_94020 0.988200
R11879 n1_M2_50820_94020 n1_M2_51900_94020 0.988200
R11880 n1_M2_51900_94020 n1_M2_52980_94020 0.988200
R11881 n1_M2_52980_94020 n1_M2_54060_94020 0.988200
R11882 n1_M2_54060_94020 n1_M2_55140_94020 0.988200
R11883 n1_M2_55140_94020 n1_M2_56220_94020 0.988200
R11884 n1_M2_56220_94020 n1_M2_57300_94020 0.988200
R11885 n1_M2_57300_94020 n1_M2_58380_94020 0.988200
R11886 n1_M2_58380_94020 n1_M2_59460_94020 0.988200
R11887 n1_M2_59460_94020 n1_M2_60540_94020 0.988200
R11888 n1_M2_60540_94020 n1_M2_61620_94020 0.988200
R11889 n1_M2_61620_94020 n1_M2_62700_94020 0.988200
R11890 n1_M2_62700_94020 n1_M2_63780_94020 0.988200
R11891 n1_M2_63780_94020 n1_M2_64860_94020 0.988200
R11892 n1_M2_64860_94020 n1_M2_65940_94020 0.988200
R11893 n1_M2_65940_94020 n1_M2_67020_94020 0.988200
R11894 n1_M2_67020_94020 n1_M2_68100_94020 0.988200
R11895 n1_M2_68100_94020 n1_M2_69180_94020 0.988200
R11896 n1_M2_69180_94020 n1_M2_70260_94020 0.988200
R11897 n1_M2_70260_94020 n1_M2_71340_94020 0.988200
R11898 n1_M2_71340_94020 n1_M2_72420_94020 0.988200
R11899 n1_M2_72420_94020 n1_M2_73500_94020 0.988200
R11900 n1_M2_73500_94020 n1_M2_74580_94020 0.988200
R11901 n1_M2_74580_94020 n1_M2_75660_94020 0.988200
R11902 n1_M2_75660_94020 n1_M2_76740_94020 0.988200
R11903 n1_M2_76740_94020 n1_M2_77820_94020 0.988200
R11904 n1_M2_77820_94020 n1_M2_78900_94020 0.988200
R11905 n1_M2_78900_94020 n1_M2_79980_94020 0.988200
R11906 n1_M2_79980_94020 n1_M2_81060_94020 0.988200
R11907 n1_M2_81060_94020 n1_M2_82140_94020 0.988200
R11908 n1_M2_82140_94020 n1_M2_83220_94020 0.988200
R11909 n1_M2_83220_94020 n1_M2_84300_94020 0.988200
R11910 n1_M2_84300_94020 n1_M2_85380_94020 0.988200
R11911 n1_M2_85380_94020 n1_M2_86460_94020 0.988200
R11912 n1_M2_86460_94020 n1_M2_87540_94020 0.988200
R11913 n1_M2_87540_94020 n1_M2_88620_94020 0.988200
R11914 n1_M2_88620_94020 n1_M2_89700_94020 0.988200
R11915 n1_M2_89700_94020 n1_M2_90780_94020 0.988200
R11916 n1_M2_90780_94020 n1_M2_91860_94020 0.988200
R11917 n1_M2_91860_94020 n1_M2_92940_94020 0.988200
R11918 n1_M2_92940_94020 n1_M2_94020_94020 0.988200
R11919 n1_M2_94020_94020 n1_M2_95100_94020 0.988200
R11920 n1_M2_95100_94020 n1_M2_96180_94020 0.988200
R11921 n1_M2_96180_94020 n1_M2_97260_94020 0.988200
R11922 n1_M2_97260_94020 n1_M2_98340_94020 0.988200
R11923 n1_M2_98340_94020 n1_M2_99420_94020 0.988200
R11924 n1_M2_99420_94020 n1_M2_100500_94020 0.988200
R11925 n1_M2_100500_94020 n1_M2_101580_94020 0.988200
R11926 n1_M2_101580_94020 n1_M2_102660_94020 0.988200
R11927 n1_M2_102660_94020 n1_M2_103740_94020 0.988200
R11928 n1_M2_103740_94020 n1_M2_104820_94020 0.988200
R11929 n1_M2_104820_94020 n1_M2_105900_94020 0.988200
R11930 n1_M2_105900_94020 n1_M2_106980_94020 0.988200
R11931 n1_M2_106980_94020 n1_M2_108060_94020 0.988200
R11932 n1_M2_108060_94020 n1_M2_109140_94020 0.988200
R11933 n1_M2_109140_94020 n1_M2_110220_94020 0.988200
R11934 n1_M2_110220_94020 n1_M2_111300_94020 0.988200
R11935 n1_M2_111300_94020 n1_M2_112380_94020 0.988200
R11936 n1_M2_112380_94020 n1_M2_113460_94020 0.988200
R11937 n1_M2_113460_94020 n1_M2_114540_94020 0.988200
R11938 n1_M2_114540_94020 n1_M2_115620_94020 0.988200
R11939 n1_M2_115620_94020 n1_M2_116700_94020 0.988200
R11940 n1_M2_116700_94020 n1_M2_117780_94020 0.988200
R11941 n1_M2_117780_94020 n1_M2_118860_94020 0.988200
R11942 n1_M2_118860_94020 n1_M2_119940_94020 0.988200
R11943 n1_M2_119940_94020 n1_M2_121020_94020 0.988200
R11944 n1_M2_121020_94020 n1_M2_122100_94020 0.988200
R11945 n1_M2_122100_94020 n1_M2_123180_94020 0.988200
R11946 n1_M2_123180_94020 n1_M2_124260_94020 0.988200
R11947 n1_M2_124260_94020 n1_M2_125340_94020 0.988200
R11948 n1_M2_125340_94020 n1_M2_126420_94020 0.988200
R11949 n1_M2_126420_94020 n1_M2_127500_94020 0.988200
R11950 n1_M2_127500_94020 n1_M2_128580_94020 0.988200
R11951 n1_M2_128580_94020 n1_M2_129660_94020 0.988200
R11952 n1_M2_129660_94020 n1_M2_130740_94020 0.988200
R11953 n1_M2_130740_94020 n1_M2_131820_94020 0.988200
R11954 n1_M2_131820_94020 n1_M2_132900_94020 0.988200
R11955 n1_M2_132900_94020 n1_M2_133980_94020 0.988200
R11956 n1_M2_133980_94020 n1_M2_135060_94020 0.988200
R11957 n1_M2_135060_94020 n1_M2_136140_94020 0.988200
R11958 n1_M2_136140_94020 n1_M2_137220_94020 0.988200
R11959 n1_M2_137220_94020 n1_M2_138300_94020 0.988200
R11960 n1_M2_138300_94020 n1_M2_139380_94020 0.988200
R11961 n1_M2_139380_94020 n1_M2_140460_94020 0.988200
R11962 n1_M2_140460_94020 n1_M2_141540_94020 0.988200
R11963 n1_M2_141540_94020 n1_M2_142620_94020 0.988200
R11964 n1_M2_142620_94020 n1_M2_143700_94020 0.988200
R11965 n1_M2_143700_94020 n1_M2_144780_94020 0.988200
R11966 n1_M2_144780_94020 n1_M2_145860_94020 0.988200
R11967 n1_M2_145860_94020 n1_M2_146940_94020 0.988200
R11968 n1_M2_60_95100 n1_M2_1140_95100 0.988200
R11969 n1_M2_1140_95100 n1_M2_2220_95100 0.988200
R11970 n1_M2_2220_95100 n1_M2_3300_95100 0.988200
R11971 n1_M2_3300_95100 n1_M2_4380_95100 0.988200
R11972 n1_M2_4380_95100 n1_M2_5460_95100 0.988200
R11973 n1_M2_5460_95100 n1_M2_6540_95100 0.988200
R11974 n1_M2_6540_95100 n1_M2_7620_95100 0.988200
R11975 n1_M2_7620_95100 n1_M2_8700_95100 0.988200
R11976 n1_M2_8700_95100 n1_M2_9780_95100 0.988200
R11977 n1_M2_9780_95100 n1_M2_10860_95100 0.988200
R11978 n1_M2_10860_95100 n1_M2_11940_95100 0.988200
R11979 n1_M2_11940_95100 n1_M2_13020_95100 0.988200
R11980 n1_M2_13020_95100 n1_M2_14100_95100 0.988200
R11981 n1_M2_14100_95100 n1_M2_15180_95100 0.988200
R11982 n1_M2_15180_95100 n1_M2_16260_95100 0.988200
R11983 n1_M2_16260_95100 n1_M2_17340_95100 0.988200
R11984 n1_M2_17340_95100 n1_M2_18420_95100 0.988200
R11985 n1_M2_18420_95100 n1_M2_19500_95100 0.988200
R11986 n1_M2_19500_95100 n1_M2_20580_95100 0.988200
R11987 n1_M2_20580_95100 n1_M2_21660_95100 0.988200
R11988 n1_M2_21660_95100 n1_M2_22740_95100 0.988200
R11989 n1_M2_22740_95100 n1_M2_23820_95100 0.988200
R11990 n1_M2_23820_95100 n1_M2_24900_95100 0.988200
R11991 n1_M2_24900_95100 n1_M2_25980_95100 0.988200
R11992 n1_M2_25980_95100 n1_M2_27060_95100 0.988200
R11993 n1_M2_27060_95100 n1_M2_28140_95100 0.988200
R11994 n1_M2_28140_95100 n1_M2_29220_95100 0.988200
R11995 n1_M2_29220_95100 n1_M2_30300_95100 0.988200
R11996 n1_M2_30300_95100 n1_M2_31380_95100 0.988200
R11997 n1_M2_31380_95100 n1_M2_32460_95100 0.988200
R11998 n1_M2_32460_95100 n1_M2_33540_95100 0.988200
R11999 n1_M2_33540_95100 n1_M2_34620_95100 0.988200
R12000 n1_M2_34620_95100 n1_M2_35700_95100 0.988200
R12001 n1_M2_35700_95100 n1_M2_36780_95100 0.988200
R12002 n1_M2_36780_95100 n1_M2_37860_95100 0.988200
R12003 n1_M2_37860_95100 n1_M2_38940_95100 0.988200
R12004 n1_M2_38940_95100 n1_M2_40020_95100 0.988200
R12005 n1_M2_40020_95100 n1_M2_41100_95100 0.988200
R12006 n1_M2_41100_95100 n1_M2_42180_95100 0.988200
R12007 n1_M2_42180_95100 n1_M2_43260_95100 0.988200
R12008 n1_M2_43260_95100 n1_M2_44340_95100 0.988200
R12009 n1_M2_44340_95100 n1_M2_45420_95100 0.988200
R12010 n1_M2_45420_95100 n1_M2_46500_95100 0.988200
R12011 n1_M2_46500_95100 n1_M2_47580_95100 0.988200
R12012 n1_M2_47580_95100 n1_M2_48660_95100 0.988200
R12013 n1_M2_48660_95100 n1_M2_49740_95100 0.988200
R12014 n1_M2_49740_95100 n1_M2_50820_95100 0.988200
R12015 n1_M2_50820_95100 n1_M2_51900_95100 0.988200
R12016 n1_M2_51900_95100 n1_M2_52980_95100 0.988200
R12017 n1_M2_52980_95100 n1_M2_54060_95100 0.988200
R12018 n1_M2_54060_95100 n1_M2_55140_95100 0.988200
R12019 n1_M2_55140_95100 n1_M2_56220_95100 0.988200
R12020 n1_M2_56220_95100 n1_M2_57300_95100 0.988200
R12021 n1_M2_57300_95100 n1_M2_58380_95100 0.988200
R12022 n1_M2_58380_95100 n1_M2_59460_95100 0.988200
R12023 n1_M2_59460_95100 n1_M2_60540_95100 0.988200
R12024 n1_M2_60540_95100 n1_M2_61620_95100 0.988200
R12025 n1_M2_61620_95100 n1_M2_62700_95100 0.988200
R12026 n1_M2_62700_95100 n1_M2_63780_95100 0.988200
R12027 n1_M2_63780_95100 n1_M2_64860_95100 0.988200
R12028 n1_M2_64860_95100 n1_M2_65940_95100 0.988200
R12029 n1_M2_65940_95100 n1_M2_67020_95100 0.988200
R12030 n1_M2_67020_95100 n1_M2_68100_95100 0.988200
R12031 n1_M2_68100_95100 n1_M2_69180_95100 0.988200
R12032 n1_M2_69180_95100 n1_M2_70260_95100 0.988200
R12033 n1_M2_70260_95100 n1_M2_71340_95100 0.988200
R12034 n1_M2_71340_95100 n1_M2_72420_95100 0.988200
R12035 n1_M2_72420_95100 n1_M2_73500_95100 0.988200
R12036 n1_M2_73500_95100 n1_M2_74580_95100 0.988200
R12037 n1_M2_74580_95100 n1_M2_75660_95100 0.988200
R12038 n1_M2_75660_95100 n1_M2_76740_95100 0.988200
R12039 n1_M2_76740_95100 n1_M2_77820_95100 0.988200
R12040 n1_M2_77820_95100 n1_M2_78900_95100 0.988200
R12041 n1_M2_78900_95100 n1_M2_79980_95100 0.988200
R12042 n1_M2_79980_95100 n1_M2_81060_95100 0.988200
R12043 n1_M2_81060_95100 n1_M2_82140_95100 0.988200
R12044 n1_M2_82140_95100 n1_M2_83220_95100 0.988200
R12045 n1_M2_83220_95100 n1_M2_84300_95100 0.988200
R12046 n1_M2_84300_95100 n1_M2_85380_95100 0.988200
R12047 n1_M2_85380_95100 n1_M2_86460_95100 0.988200
R12048 n1_M2_86460_95100 n1_M2_87540_95100 0.988200
R12049 n1_M2_87540_95100 n1_M2_88620_95100 0.988200
R12050 n1_M2_88620_95100 n1_M2_89700_95100 0.988200
R12051 n1_M2_89700_95100 n1_M2_90780_95100 0.988200
R12052 n1_M2_90780_95100 n1_M2_91860_95100 0.988200
R12053 n1_M2_91860_95100 n1_M2_92940_95100 0.988200
R12054 n1_M2_92940_95100 n1_M2_94020_95100 0.988200
R12055 n1_M2_94020_95100 n1_M2_95100_95100 0.988200
R12056 n1_M2_95100_95100 n1_M2_96180_95100 0.988200
R12057 n1_M2_96180_95100 n1_M2_97260_95100 0.988200
R12058 n1_M2_97260_95100 n1_M2_98340_95100 0.988200
R12059 n1_M2_98340_95100 n1_M2_99420_95100 0.988200
R12060 n1_M2_99420_95100 n1_M2_100500_95100 0.988200
R12061 n1_M2_100500_95100 n1_M2_101580_95100 0.988200
R12062 n1_M2_101580_95100 n1_M2_102660_95100 0.988200
R12063 n1_M2_102660_95100 n1_M2_103740_95100 0.988200
R12064 n1_M2_103740_95100 n1_M2_104820_95100 0.988200
R12065 n1_M2_104820_95100 n1_M2_105900_95100 0.988200
R12066 n1_M2_105900_95100 n1_M2_106980_95100 0.988200
R12067 n1_M2_106980_95100 n1_M2_108060_95100 0.988200
R12068 n1_M2_108060_95100 n1_M2_109140_95100 0.988200
R12069 n1_M2_109140_95100 n1_M2_110220_95100 0.988200
R12070 n1_M2_110220_95100 n1_M2_111300_95100 0.988200
R12071 n1_M2_111300_95100 n1_M2_112380_95100 0.988200
R12072 n1_M2_112380_95100 n1_M2_113460_95100 0.988200
R12073 n1_M2_113460_95100 n1_M2_114540_95100 0.988200
R12074 n1_M2_114540_95100 n1_M2_115620_95100 0.988200
R12075 n1_M2_115620_95100 n1_M2_116700_95100 0.988200
R12076 n1_M2_116700_95100 n1_M2_117780_95100 0.988200
R12077 n1_M2_117780_95100 n1_M2_118860_95100 0.988200
R12078 n1_M2_118860_95100 n1_M2_119940_95100 0.988200
R12079 n1_M2_119940_95100 n1_M2_121020_95100 0.988200
R12080 n1_M2_121020_95100 n1_M2_122100_95100 0.988200
R12081 n1_M2_122100_95100 n1_M2_123180_95100 0.988200
R12082 n1_M2_123180_95100 n1_M2_124260_95100 0.988200
R12083 n1_M2_124260_95100 n1_M2_125340_95100 0.988200
R12084 n1_M2_125340_95100 n1_M2_126420_95100 0.988200
R12085 n1_M2_126420_95100 n1_M2_127500_95100 0.988200
R12086 n1_M2_127500_95100 n1_M2_128580_95100 0.988200
R12087 n1_M2_128580_95100 n1_M2_129660_95100 0.988200
R12088 n1_M2_129660_95100 n1_M2_130740_95100 0.988200
R12089 n1_M2_130740_95100 n1_M2_131820_95100 0.988200
R12090 n1_M2_131820_95100 n1_M2_132900_95100 0.988200
R12091 n1_M2_132900_95100 n1_M2_133980_95100 0.988200
R12092 n1_M2_133980_95100 n1_M2_135060_95100 0.988200
R12093 n1_M2_135060_95100 n1_M2_136140_95100 0.988200
R12094 n1_M2_136140_95100 n1_M2_137220_95100 0.988200
R12095 n1_M2_137220_95100 n1_M2_138300_95100 0.988200
R12096 n1_M2_138300_95100 n1_M2_139380_95100 0.988200
R12097 n1_M2_139380_95100 n1_M2_140460_95100 0.988200
R12098 n1_M2_140460_95100 n1_M2_141540_95100 0.988200
R12099 n1_M2_141540_95100 n1_M2_142620_95100 0.988200
R12100 n1_M2_142620_95100 n1_M2_143700_95100 0.988200
R12101 n1_M2_143700_95100 n1_M2_144780_95100 0.988200
R12102 n1_M2_144780_95100 n1_M2_145860_95100 0.988200
R12103 n1_M2_145860_95100 n1_M2_146940_95100 0.988200
R12104 n1_M2_60_96180 n1_M2_1140_96180 0.988200
R12105 n1_M2_1140_96180 n1_M2_2220_96180 0.988200
R12106 n1_M2_2220_96180 n1_M2_3300_96180 0.988200
R12107 n1_M2_3300_96180 n1_M2_4380_96180 0.988200
R12108 n1_M2_4380_96180 n1_M2_5460_96180 0.988200
R12109 n1_M2_5460_96180 n1_M2_6540_96180 0.988200
R12110 n1_M2_6540_96180 n1_M2_7620_96180 0.988200
R12111 n1_M2_7620_96180 n1_M2_8700_96180 0.988200
R12112 n1_M2_8700_96180 n1_M2_9780_96180 0.988200
R12113 n1_M2_9780_96180 n1_M2_10860_96180 0.988200
R12114 n1_M2_10860_96180 n1_M2_11940_96180 0.988200
R12115 n1_M2_11940_96180 n1_M2_13020_96180 0.988200
R12116 n1_M2_13020_96180 n1_M2_14100_96180 0.988200
R12117 n1_M2_14100_96180 n1_M2_15180_96180 0.988200
R12118 n1_M2_15180_96180 n1_M2_16260_96180 0.988200
R12119 n1_M2_16260_96180 n1_M2_17340_96180 0.988200
R12120 n1_M2_17340_96180 n1_M2_18420_96180 0.988200
R12121 n1_M2_18420_96180 n1_M2_19500_96180 0.988200
R12122 n1_M2_19500_96180 n1_M2_20580_96180 0.988200
R12123 n1_M2_20580_96180 n1_M2_21660_96180 0.988200
R12124 n1_M2_21660_96180 n1_M2_22740_96180 0.988200
R12125 n1_M2_22740_96180 n1_M2_23820_96180 0.988200
R12126 n1_M2_23820_96180 n1_M2_24900_96180 0.988200
R12127 n1_M2_24900_96180 n1_M2_25980_96180 0.988200
R12128 n1_M2_25980_96180 n1_M2_27060_96180 0.988200
R12129 n1_M2_27060_96180 n1_M2_28140_96180 0.988200
R12130 n1_M2_28140_96180 n1_M2_29220_96180 0.988200
R12131 n1_M2_29220_96180 n1_M2_30300_96180 0.988200
R12132 n1_M2_30300_96180 n1_M2_31380_96180 0.988200
R12133 n1_M2_31380_96180 n1_M2_32460_96180 0.988200
R12134 n1_M2_32460_96180 n1_M2_33540_96180 0.988200
R12135 n1_M2_33540_96180 n1_M2_34620_96180 0.988200
R12136 n1_M2_34620_96180 n1_M2_35700_96180 0.988200
R12137 n1_M2_35700_96180 n1_M2_36780_96180 0.988200
R12138 n1_M2_36780_96180 n1_M2_37860_96180 0.988200
R12139 n1_M2_37860_96180 n1_M2_38940_96180 0.988200
R12140 n1_M2_38940_96180 n1_M2_40020_96180 0.988200
R12141 n1_M2_40020_96180 n1_M2_41100_96180 0.988200
R12142 n1_M2_41100_96180 n1_M2_42180_96180 0.988200
R12143 n1_M2_42180_96180 n1_M2_43260_96180 0.988200
R12144 n1_M2_43260_96180 n1_M2_44340_96180 0.988200
R12145 n1_M2_44340_96180 n1_M2_45420_96180 0.988200
R12146 n1_M2_45420_96180 n1_M2_46500_96180 0.988200
R12147 n1_M2_46500_96180 n1_M2_47580_96180 0.988200
R12148 n1_M2_47580_96180 n1_M2_48660_96180 0.988200
R12149 n1_M2_48660_96180 n1_M2_49740_96180 0.988200
R12150 n1_M2_49740_96180 n1_M2_50820_96180 0.988200
R12151 n1_M2_50820_96180 n1_M2_51900_96180 0.988200
R12152 n1_M2_51900_96180 n1_M2_52980_96180 0.988200
R12153 n1_M2_52980_96180 n1_M2_54060_96180 0.988200
R12154 n1_M2_54060_96180 n1_M2_55140_96180 0.988200
R12155 n1_M2_55140_96180 n1_M2_56220_96180 0.988200
R12156 n1_M2_56220_96180 n1_M2_57300_96180 0.988200
R12157 n1_M2_57300_96180 n1_M2_58380_96180 0.988200
R12158 n1_M2_58380_96180 n1_M2_59460_96180 0.988200
R12159 n1_M2_59460_96180 n1_M2_60540_96180 0.988200
R12160 n1_M2_60540_96180 n1_M2_61620_96180 0.988200
R12161 n1_M2_61620_96180 n1_M2_62700_96180 0.988200
R12162 n1_M2_62700_96180 n1_M2_63780_96180 0.988200
R12163 n1_M2_63780_96180 n1_M2_64860_96180 0.988200
R12164 n1_M2_64860_96180 n1_M2_65940_96180 0.988200
R12165 n1_M2_65940_96180 n1_M2_67020_96180 0.988200
R12166 n1_M2_67020_96180 n1_M2_68100_96180 0.988200
R12167 n1_M2_68100_96180 n1_M2_69180_96180 0.988200
R12168 n1_M2_69180_96180 n1_M2_70260_96180 0.988200
R12169 n1_M2_70260_96180 n1_M2_71340_96180 0.988200
R12170 n1_M2_71340_96180 n1_M2_72420_96180 0.988200
R12171 n1_M2_72420_96180 n1_M2_73500_96180 0.988200
R12172 n1_M2_73500_96180 n1_M2_74580_96180 0.988200
R12173 n1_M2_74580_96180 n1_M2_75660_96180 0.988200
R12174 n1_M2_75660_96180 n1_M2_76740_96180 0.988200
R12175 n1_M2_76740_96180 n1_M2_77820_96180 0.988200
R12176 n1_M2_77820_96180 n1_M2_78900_96180 0.988200
R12177 n1_M2_78900_96180 n1_M2_79980_96180 0.988200
R12178 n1_M2_79980_96180 n1_M2_81060_96180 0.988200
R12179 n1_M2_81060_96180 n1_M2_82140_96180 0.988200
R12180 n1_M2_82140_96180 n1_M2_83220_96180 0.988200
R12181 n1_M2_83220_96180 n1_M2_84300_96180 0.988200
R12182 n1_M2_84300_96180 n1_M2_85380_96180 0.988200
R12183 n1_M2_85380_96180 n1_M2_86460_96180 0.988200
R12184 n1_M2_86460_96180 n1_M2_87540_96180 0.988200
R12185 n1_M2_87540_96180 n1_M2_88620_96180 0.988200
R12186 n1_M2_88620_96180 n1_M2_89700_96180 0.988200
R12187 n1_M2_89700_96180 n1_M2_90780_96180 0.988200
R12188 n1_M2_90780_96180 n1_M2_91860_96180 0.988200
R12189 n1_M2_91860_96180 n1_M2_92940_96180 0.988200
R12190 n1_M2_92940_96180 n1_M2_94020_96180 0.988200
R12191 n1_M2_94020_96180 n1_M2_95100_96180 0.988200
R12192 n1_M2_95100_96180 n1_M2_96180_96180 0.988200
R12193 n1_M2_96180_96180 n1_M2_97260_96180 0.988200
R12194 n1_M2_97260_96180 n1_M2_98340_96180 0.988200
R12195 n1_M2_98340_96180 n1_M2_99420_96180 0.988200
R12196 n1_M2_99420_96180 n1_M2_100500_96180 0.988200
R12197 n1_M2_100500_96180 n1_M2_101580_96180 0.988200
R12198 n1_M2_101580_96180 n1_M2_102660_96180 0.988200
R12199 n1_M2_102660_96180 n1_M2_103740_96180 0.988200
R12200 n1_M2_103740_96180 n1_M2_104820_96180 0.988200
R12201 n1_M2_104820_96180 n1_M2_105900_96180 0.988200
R12202 n1_M2_105900_96180 n1_M2_106980_96180 0.988200
R12203 n1_M2_106980_96180 n1_M2_108060_96180 0.988200
R12204 n1_M2_108060_96180 n1_M2_109140_96180 0.988200
R12205 n1_M2_109140_96180 n1_M2_110220_96180 0.988200
R12206 n1_M2_110220_96180 n1_M2_111300_96180 0.988200
R12207 n1_M2_111300_96180 n1_M2_112380_96180 0.988200
R12208 n1_M2_112380_96180 n1_M2_113460_96180 0.988200
R12209 n1_M2_113460_96180 n1_M2_114540_96180 0.988200
R12210 n1_M2_114540_96180 n1_M2_115620_96180 0.988200
R12211 n1_M2_115620_96180 n1_M2_116700_96180 0.988200
R12212 n1_M2_116700_96180 n1_M2_117780_96180 0.988200
R12213 n1_M2_117780_96180 n1_M2_118860_96180 0.988200
R12214 n1_M2_118860_96180 n1_M2_119940_96180 0.988200
R12215 n1_M2_119940_96180 n1_M2_121020_96180 0.988200
R12216 n1_M2_121020_96180 n1_M2_122100_96180 0.988200
R12217 n1_M2_122100_96180 n1_M2_123180_96180 0.988200
R12218 n1_M2_123180_96180 n1_M2_124260_96180 0.988200
R12219 n1_M2_124260_96180 n1_M2_125340_96180 0.988200
R12220 n1_M2_125340_96180 n1_M2_126420_96180 0.988200
R12221 n1_M2_126420_96180 n1_M2_127500_96180 0.988200
R12222 n1_M2_127500_96180 n1_M2_128580_96180 0.988200
R12223 n1_M2_128580_96180 n1_M2_129660_96180 0.988200
R12224 n1_M2_129660_96180 n1_M2_130740_96180 0.988200
R12225 n1_M2_130740_96180 n1_M2_131820_96180 0.988200
R12226 n1_M2_131820_96180 n1_M2_132900_96180 0.988200
R12227 n1_M2_132900_96180 n1_M2_133980_96180 0.988200
R12228 n1_M2_133980_96180 n1_M2_135060_96180 0.988200
R12229 n1_M2_135060_96180 n1_M2_136140_96180 0.988200
R12230 n1_M2_136140_96180 n1_M2_137220_96180 0.988200
R12231 n1_M2_137220_96180 n1_M2_138300_96180 0.988200
R12232 n1_M2_138300_96180 n1_M2_139380_96180 0.988200
R12233 n1_M2_139380_96180 n1_M2_140460_96180 0.988200
R12234 n1_M2_140460_96180 n1_M2_141540_96180 0.988200
R12235 n1_M2_141540_96180 n1_M2_142620_96180 0.988200
R12236 n1_M2_142620_96180 n1_M2_143700_96180 0.988200
R12237 n1_M2_143700_96180 n1_M2_144780_96180 0.988200
R12238 n1_M2_144780_96180 n1_M2_145860_96180 0.988200
R12239 n1_M2_145860_96180 n1_M2_146940_96180 0.988200
R12240 n1_M2_60_97260 n1_M2_1140_97260 0.988200
R12241 n1_M2_1140_97260 n1_M2_2220_97260 0.988200
R12242 n1_M2_2220_97260 n1_M2_3300_97260 0.988200
R12243 n1_M2_3300_97260 n1_M2_4380_97260 0.988200
R12244 n1_M2_4380_97260 n1_M2_5460_97260 0.988200
R12245 n1_M2_5460_97260 n1_M2_6540_97260 0.988200
R12246 n1_M2_6540_97260 n1_M2_7620_97260 0.988200
R12247 n1_M2_7620_97260 n1_M2_8700_97260 0.988200
R12248 n1_M2_8700_97260 n1_M2_9780_97260 0.988200
R12249 n1_M2_9780_97260 n1_M2_10860_97260 0.988200
R12250 n1_M2_10860_97260 n1_M2_11940_97260 0.988200
R12251 n1_M2_11940_97260 n1_M2_13020_97260 0.988200
R12252 n1_M2_13020_97260 n1_M2_14100_97260 0.988200
R12253 n1_M2_14100_97260 n1_M2_15180_97260 0.988200
R12254 n1_M2_15180_97260 n1_M2_16260_97260 0.988200
R12255 n1_M2_16260_97260 n1_M2_17340_97260 0.988200
R12256 n1_M2_17340_97260 n1_M2_18420_97260 0.988200
R12257 n1_M2_18420_97260 n1_M2_19500_97260 0.988200
R12258 n1_M2_19500_97260 n1_M2_20580_97260 0.988200
R12259 n1_M2_20580_97260 n1_M2_21660_97260 0.988200
R12260 n1_M2_21660_97260 n1_M2_22740_97260 0.988200
R12261 n1_M2_22740_97260 n1_M2_23820_97260 0.988200
R12262 n1_M2_23820_97260 n1_M2_24900_97260 0.988200
R12263 n1_M2_24900_97260 n1_M2_25980_97260 0.988200
R12264 n1_M2_25980_97260 n1_M2_27060_97260 0.988200
R12265 n1_M2_27060_97260 n1_M2_28140_97260 0.988200
R12266 n1_M2_28140_97260 n1_M2_29220_97260 0.988200
R12267 n1_M2_29220_97260 n1_M2_30300_97260 0.988200
R12268 n1_M2_30300_97260 n1_M2_31380_97260 0.988200
R12269 n1_M2_31380_97260 n1_M2_32460_97260 0.988200
R12270 n1_M2_32460_97260 n1_M2_33540_97260 0.988200
R12271 n1_M2_33540_97260 n1_M2_34620_97260 0.988200
R12272 n1_M2_34620_97260 n1_M2_35700_97260 0.988200
R12273 n1_M2_35700_97260 n1_M2_36780_97260 0.988200
R12274 n1_M2_36780_97260 n1_M2_37860_97260 0.988200
R12275 n1_M2_37860_97260 n1_M2_38940_97260 0.988200
R12276 n1_M2_38940_97260 n1_M2_40020_97260 0.988200
R12277 n1_M2_40020_97260 n1_M2_41100_97260 0.988200
R12278 n1_M2_41100_97260 n1_M2_42180_97260 0.988200
R12279 n1_M2_42180_97260 n1_M2_43260_97260 0.988200
R12280 n1_M2_43260_97260 n1_M2_44340_97260 0.988200
R12281 n1_M2_44340_97260 n1_M2_45420_97260 0.988200
R12282 n1_M2_45420_97260 n1_M2_46500_97260 0.988200
R12283 n1_M2_46500_97260 n1_M2_47580_97260 0.988200
R12284 n1_M2_47580_97260 n1_M2_48660_97260 0.988200
R12285 n1_M2_48660_97260 n1_M2_49740_97260 0.988200
R12286 n1_M2_49740_97260 n1_M2_50820_97260 0.988200
R12287 n1_M2_50820_97260 n1_M2_51900_97260 0.988200
R12288 n1_M2_51900_97260 n1_M2_52980_97260 0.988200
R12289 n1_M2_52980_97260 n1_M2_54060_97260 0.988200
R12290 n1_M2_54060_97260 n1_M2_55140_97260 0.988200
R12291 n1_M2_55140_97260 n1_M2_56220_97260 0.988200
R12292 n1_M2_56220_97260 n1_M2_57300_97260 0.988200
R12293 n1_M2_57300_97260 n1_M2_58380_97260 0.988200
R12294 n1_M2_58380_97260 n1_M2_59460_97260 0.988200
R12295 n1_M2_59460_97260 n1_M2_60540_97260 0.988200
R12296 n1_M2_60540_97260 n1_M2_61620_97260 0.988200
R12297 n1_M2_61620_97260 n1_M2_62700_97260 0.988200
R12298 n1_M2_62700_97260 n1_M2_63780_97260 0.988200
R12299 n1_M2_63780_97260 n1_M2_64860_97260 0.988200
R12300 n1_M2_64860_97260 n1_M2_65940_97260 0.988200
R12301 n1_M2_65940_97260 n1_M2_67020_97260 0.988200
R12302 n1_M2_67020_97260 n1_M2_68100_97260 0.988200
R12303 n1_M2_68100_97260 n1_M2_69180_97260 0.988200
R12304 n1_M2_69180_97260 n1_M2_70260_97260 0.988200
R12305 n1_M2_70260_97260 n1_M2_71340_97260 0.988200
R12306 n1_M2_71340_97260 n1_M2_72420_97260 0.988200
R12307 n1_M2_72420_97260 n1_M2_73500_97260 0.988200
R12308 n1_M2_73500_97260 n1_M2_74580_97260 0.988200
R12309 n1_M2_74580_97260 n1_M2_75660_97260 0.988200
R12310 n1_M2_75660_97260 n1_M2_76740_97260 0.988200
R12311 n1_M2_76740_97260 n1_M2_77820_97260 0.988200
R12312 n1_M2_77820_97260 n1_M2_78900_97260 0.988200
R12313 n1_M2_78900_97260 n1_M2_79980_97260 0.988200
R12314 n1_M2_79980_97260 n1_M2_81060_97260 0.988200
R12315 n1_M2_81060_97260 n1_M2_82140_97260 0.988200
R12316 n1_M2_82140_97260 n1_M2_83220_97260 0.988200
R12317 n1_M2_83220_97260 n1_M2_84300_97260 0.988200
R12318 n1_M2_84300_97260 n1_M2_85380_97260 0.988200
R12319 n1_M2_85380_97260 n1_M2_86460_97260 0.988200
R12320 n1_M2_86460_97260 n1_M2_87540_97260 0.988200
R12321 n1_M2_87540_97260 n1_M2_88620_97260 0.988200
R12322 n1_M2_88620_97260 n1_M2_89700_97260 0.988200
R12323 n1_M2_89700_97260 n1_M2_90780_97260 0.988200
R12324 n1_M2_90780_97260 n1_M2_91860_97260 0.988200
R12325 n1_M2_91860_97260 n1_M2_92940_97260 0.988200
R12326 n1_M2_92940_97260 n1_M2_94020_97260 0.988200
R12327 n1_M2_94020_97260 n1_M2_95100_97260 0.988200
R12328 n1_M2_95100_97260 n1_M2_96180_97260 0.988200
R12329 n1_M2_96180_97260 n1_M2_97260_97260 0.988200
R12330 n1_M2_97260_97260 n1_M2_98340_97260 0.988200
R12331 n1_M2_98340_97260 n1_M2_99420_97260 0.988200
R12332 n1_M2_99420_97260 n1_M2_100500_97260 0.988200
R12333 n1_M2_100500_97260 n1_M2_101580_97260 0.988200
R12334 n1_M2_101580_97260 n1_M2_102660_97260 0.988200
R12335 n1_M2_102660_97260 n1_M2_103740_97260 0.988200
R12336 n1_M2_103740_97260 n1_M2_104820_97260 0.988200
R12337 n1_M2_104820_97260 n1_M2_105900_97260 0.988200
R12338 n1_M2_105900_97260 n1_M2_106980_97260 0.988200
R12339 n1_M2_106980_97260 n1_M2_108060_97260 0.988200
R12340 n1_M2_108060_97260 n1_M2_109140_97260 0.988200
R12341 n1_M2_109140_97260 n1_M2_110220_97260 0.988200
R12342 n1_M2_110220_97260 n1_M2_111300_97260 0.988200
R12343 n1_M2_111300_97260 n1_M2_112380_97260 0.988200
R12344 n1_M2_112380_97260 n1_M2_113460_97260 0.988200
R12345 n1_M2_113460_97260 n1_M2_114540_97260 0.988200
R12346 n1_M2_114540_97260 n1_M2_115620_97260 0.988200
R12347 n1_M2_115620_97260 n1_M2_116700_97260 0.988200
R12348 n1_M2_116700_97260 n1_M2_117780_97260 0.988200
R12349 n1_M2_117780_97260 n1_M2_118860_97260 0.988200
R12350 n1_M2_118860_97260 n1_M2_119940_97260 0.988200
R12351 n1_M2_119940_97260 n1_M2_121020_97260 0.988200
R12352 n1_M2_121020_97260 n1_M2_122100_97260 0.988200
R12353 n1_M2_122100_97260 n1_M2_123180_97260 0.988200
R12354 n1_M2_123180_97260 n1_M2_124260_97260 0.988200
R12355 n1_M2_124260_97260 n1_M2_125340_97260 0.988200
R12356 n1_M2_125340_97260 n1_M2_126420_97260 0.988200
R12357 n1_M2_126420_97260 n1_M2_127500_97260 0.988200
R12358 n1_M2_127500_97260 n1_M2_128580_97260 0.988200
R12359 n1_M2_128580_97260 n1_M2_129660_97260 0.988200
R12360 n1_M2_129660_97260 n1_M2_130740_97260 0.988200
R12361 n1_M2_130740_97260 n1_M2_131820_97260 0.988200
R12362 n1_M2_131820_97260 n1_M2_132900_97260 0.988200
R12363 n1_M2_132900_97260 n1_M2_133980_97260 0.988200
R12364 n1_M2_133980_97260 n1_M2_135060_97260 0.988200
R12365 n1_M2_135060_97260 n1_M2_136140_97260 0.988200
R12366 n1_M2_136140_97260 n1_M2_137220_97260 0.988200
R12367 n1_M2_137220_97260 n1_M2_138300_97260 0.988200
R12368 n1_M2_138300_97260 n1_M2_139380_97260 0.988200
R12369 n1_M2_139380_97260 n1_M2_140460_97260 0.988200
R12370 n1_M2_140460_97260 n1_M2_141540_97260 0.988200
R12371 n1_M2_141540_97260 n1_M2_142620_97260 0.988200
R12372 n1_M2_142620_97260 n1_M2_143700_97260 0.988200
R12373 n1_M2_143700_97260 n1_M2_144780_97260 0.988200
R12374 n1_M2_144780_97260 n1_M2_145860_97260 0.988200
R12375 n1_M2_145860_97260 n1_M2_146940_97260 0.988200
R12376 n1_M2_60_98340 n1_M2_1140_98340 0.988200
R12377 n1_M2_1140_98340 n1_M2_2220_98340 0.988200
R12378 n1_M2_2220_98340 n1_M2_3300_98340 0.988200
R12379 n1_M2_3300_98340 n1_M2_4380_98340 0.988200
R12380 n1_M2_4380_98340 n1_M2_5460_98340 0.988200
R12381 n1_M2_5460_98340 n1_M2_6540_98340 0.988200
R12382 n1_M2_6540_98340 n1_M2_7620_98340 0.988200
R12383 n1_M2_7620_98340 n1_M2_8700_98340 0.988200
R12384 n1_M2_8700_98340 n1_M2_9780_98340 0.988200
R12385 n1_M2_9780_98340 n1_M2_10860_98340 0.988200
R12386 n1_M2_10860_98340 n1_M2_11940_98340 0.988200
R12387 n1_M2_11940_98340 n1_M2_13020_98340 0.988200
R12388 n1_M2_13020_98340 n1_M2_14100_98340 0.988200
R12389 n1_M2_14100_98340 n1_M2_15180_98340 0.988200
R12390 n1_M2_15180_98340 n1_M2_16260_98340 0.988200
R12391 n1_M2_16260_98340 n1_M2_17340_98340 0.988200
R12392 n1_M2_17340_98340 n1_M2_18420_98340 0.988200
R12393 n1_M2_18420_98340 n1_M2_19500_98340 0.988200
R12394 n1_M2_19500_98340 n1_M2_20580_98340 0.988200
R12395 n1_M2_20580_98340 n1_M2_21660_98340 0.988200
R12396 n1_M2_21660_98340 n1_M2_22740_98340 0.988200
R12397 n1_M2_22740_98340 n1_M2_23820_98340 0.988200
R12398 n1_M2_23820_98340 n1_M2_24900_98340 0.988200
R12399 n1_M2_24900_98340 n1_M2_25980_98340 0.988200
R12400 n1_M2_25980_98340 n1_M2_27060_98340 0.988200
R12401 n1_M2_27060_98340 n1_M2_28140_98340 0.988200
R12402 n1_M2_28140_98340 n1_M2_29220_98340 0.988200
R12403 n1_M2_29220_98340 n1_M2_30300_98340 0.988200
R12404 n1_M2_30300_98340 n1_M2_31380_98340 0.988200
R12405 n1_M2_31380_98340 n1_M2_32460_98340 0.988200
R12406 n1_M2_32460_98340 n1_M2_33540_98340 0.988200
R12407 n1_M2_33540_98340 n1_M2_34620_98340 0.988200
R12408 n1_M2_34620_98340 n1_M2_35700_98340 0.988200
R12409 n1_M2_35700_98340 n1_M2_36780_98340 0.988200
R12410 n1_M2_36780_98340 n1_M2_37860_98340 0.988200
R12411 n1_M2_37860_98340 n1_M2_38940_98340 0.988200
R12412 n1_M2_38940_98340 n1_M2_40020_98340 0.988200
R12413 n1_M2_40020_98340 n1_M2_41100_98340 0.988200
R12414 n1_M2_41100_98340 n1_M2_42180_98340 0.988200
R12415 n1_M2_42180_98340 n1_M2_43260_98340 0.988200
R12416 n1_M2_43260_98340 n1_M2_44340_98340 0.988200
R12417 n1_M2_44340_98340 n1_M2_45420_98340 0.988200
R12418 n1_M2_45420_98340 n1_M2_46500_98340 0.988200
R12419 n1_M2_46500_98340 n1_M2_47580_98340 0.988200
R12420 n1_M2_47580_98340 n1_M2_48660_98340 0.988200
R12421 n1_M2_48660_98340 n1_M2_49740_98340 0.988200
R12422 n1_M2_49740_98340 n1_M2_50820_98340 0.988200
R12423 n1_M2_50820_98340 n1_M2_51900_98340 0.988200
R12424 n1_M2_51900_98340 n1_M2_52980_98340 0.988200
R12425 n1_M2_52980_98340 n1_M2_54060_98340 0.988200
R12426 n1_M2_54060_98340 n1_M2_55140_98340 0.988200
R12427 n1_M2_55140_98340 n1_M2_56220_98340 0.988200
R12428 n1_M2_56220_98340 n1_M2_57300_98340 0.988200
R12429 n1_M2_57300_98340 n1_M2_58380_98340 0.988200
R12430 n1_M2_58380_98340 n1_M2_59460_98340 0.988200
R12431 n1_M2_59460_98340 n1_M2_60540_98340 0.988200
R12432 n1_M2_60540_98340 n1_M2_61620_98340 0.988200
R12433 n1_M2_61620_98340 n1_M2_62700_98340 0.988200
R12434 n1_M2_62700_98340 n1_M2_63780_98340 0.988200
R12435 n1_M2_63780_98340 n1_M2_64860_98340 0.988200
R12436 n1_M2_64860_98340 n1_M2_65940_98340 0.988200
R12437 n1_M2_65940_98340 n1_M2_67020_98340 0.988200
R12438 n1_M2_67020_98340 n1_M2_68100_98340 0.988200
R12439 n1_M2_68100_98340 n1_M2_69180_98340 0.988200
R12440 n1_M2_69180_98340 n1_M2_70260_98340 0.988200
R12441 n1_M2_70260_98340 n1_M2_71340_98340 0.988200
R12442 n1_M2_71340_98340 n1_M2_72420_98340 0.988200
R12443 n1_M2_72420_98340 n1_M2_73500_98340 0.988200
R12444 n1_M2_73500_98340 n1_M2_74580_98340 0.988200
R12445 n1_M2_74580_98340 n1_M2_75660_98340 0.988200
R12446 n1_M2_75660_98340 n1_M2_76740_98340 0.988200
R12447 n1_M2_76740_98340 n1_M2_77820_98340 0.988200
R12448 n1_M2_77820_98340 n1_M2_78900_98340 0.988200
R12449 n1_M2_78900_98340 n1_M2_79980_98340 0.988200
R12450 n1_M2_79980_98340 n1_M2_81060_98340 0.988200
R12451 n1_M2_81060_98340 n1_M2_82140_98340 0.988200
R12452 n1_M2_82140_98340 n1_M2_83220_98340 0.988200
R12453 n1_M2_83220_98340 n1_M2_84300_98340 0.988200
R12454 n1_M2_84300_98340 n1_M2_85380_98340 0.988200
R12455 n1_M2_85380_98340 n1_M2_86460_98340 0.988200
R12456 n1_M2_86460_98340 n1_M2_87540_98340 0.988200
R12457 n1_M2_87540_98340 n1_M2_88620_98340 0.988200
R12458 n1_M2_88620_98340 n1_M2_89700_98340 0.988200
R12459 n1_M2_89700_98340 n1_M2_90780_98340 0.988200
R12460 n1_M2_90780_98340 n1_M2_91860_98340 0.988200
R12461 n1_M2_91860_98340 n1_M2_92940_98340 0.988200
R12462 n1_M2_92940_98340 n1_M2_94020_98340 0.988200
R12463 n1_M2_94020_98340 n1_M2_95100_98340 0.988200
R12464 n1_M2_95100_98340 n1_M2_96180_98340 0.988200
R12465 n1_M2_96180_98340 n1_M2_97260_98340 0.988200
R12466 n1_M2_97260_98340 n1_M2_98340_98340 0.988200
R12467 n1_M2_98340_98340 n1_M2_99420_98340 0.988200
R12468 n1_M2_99420_98340 n1_M2_100500_98340 0.988200
R12469 n1_M2_100500_98340 n1_M2_101580_98340 0.988200
R12470 n1_M2_101580_98340 n1_M2_102660_98340 0.988200
R12471 n1_M2_102660_98340 n1_M2_103740_98340 0.988200
R12472 n1_M2_103740_98340 n1_M2_104820_98340 0.988200
R12473 n1_M2_104820_98340 n1_M2_105900_98340 0.988200
R12474 n1_M2_105900_98340 n1_M2_106980_98340 0.988200
R12475 n1_M2_106980_98340 n1_M2_108060_98340 0.988200
R12476 n1_M2_108060_98340 n1_M2_109140_98340 0.988200
R12477 n1_M2_109140_98340 n1_M2_110220_98340 0.988200
R12478 n1_M2_110220_98340 n1_M2_111300_98340 0.988200
R12479 n1_M2_111300_98340 n1_M2_112380_98340 0.988200
R12480 n1_M2_112380_98340 n1_M2_113460_98340 0.988200
R12481 n1_M2_113460_98340 n1_M2_114540_98340 0.988200
R12482 n1_M2_114540_98340 n1_M2_115620_98340 0.988200
R12483 n1_M2_115620_98340 n1_M2_116700_98340 0.988200
R12484 n1_M2_116700_98340 n1_M2_117780_98340 0.988200
R12485 n1_M2_117780_98340 n1_M2_118860_98340 0.988200
R12486 n1_M2_118860_98340 n1_M2_119940_98340 0.988200
R12487 n1_M2_119940_98340 n1_M2_121020_98340 0.988200
R12488 n1_M2_121020_98340 n1_M2_122100_98340 0.988200
R12489 n1_M2_122100_98340 n1_M2_123180_98340 0.988200
R12490 n1_M2_123180_98340 n1_M2_124260_98340 0.988200
R12491 n1_M2_124260_98340 n1_M2_125340_98340 0.988200
R12492 n1_M2_125340_98340 n1_M2_126420_98340 0.988200
R12493 n1_M2_126420_98340 n1_M2_127500_98340 0.988200
R12494 n1_M2_127500_98340 n1_M2_128580_98340 0.988200
R12495 n1_M2_128580_98340 n1_M2_129660_98340 0.988200
R12496 n1_M2_129660_98340 n1_M2_130740_98340 0.988200
R12497 n1_M2_130740_98340 n1_M2_131820_98340 0.988200
R12498 n1_M2_131820_98340 n1_M2_132900_98340 0.988200
R12499 n1_M2_132900_98340 n1_M2_133980_98340 0.988200
R12500 n1_M2_133980_98340 n1_M2_135060_98340 0.988200
R12501 n1_M2_135060_98340 n1_M2_136140_98340 0.988200
R12502 n1_M2_136140_98340 n1_M2_137220_98340 0.988200
R12503 n1_M2_137220_98340 n1_M2_138300_98340 0.988200
R12504 n1_M2_138300_98340 n1_M2_139380_98340 0.988200
R12505 n1_M2_139380_98340 n1_M2_140460_98340 0.988200
R12506 n1_M2_140460_98340 n1_M2_141540_98340 0.988200
R12507 n1_M2_141540_98340 n1_M2_142620_98340 0.988200
R12508 n1_M2_142620_98340 n1_M2_143700_98340 0.988200
R12509 n1_M2_143700_98340 n1_M2_144780_98340 0.988200
R12510 n1_M2_144780_98340 n1_M2_145860_98340 0.988200
R12511 n1_M2_145860_98340 n1_M2_146940_98340 0.988200
R12512 n1_M2_60_99420 n1_M2_1140_99420 0.988200
R12513 n1_M2_1140_99420 n1_M2_2220_99420 0.988200
R12514 n1_M2_2220_99420 n1_M2_3300_99420 0.988200
R12515 n1_M2_3300_99420 n1_M2_4380_99420 0.988200
R12516 n1_M2_4380_99420 n1_M2_5460_99420 0.988200
R12517 n1_M2_5460_99420 n1_M2_6540_99420 0.988200
R12518 n1_M2_6540_99420 n1_M2_7620_99420 0.988200
R12519 n1_M2_7620_99420 n1_M2_8700_99420 0.988200
R12520 n1_M2_8700_99420 n1_M2_9780_99420 0.988200
R12521 n1_M2_9780_99420 n1_M2_10860_99420 0.988200
R12522 n1_M2_10860_99420 n1_M2_11940_99420 0.988200
R12523 n1_M2_11940_99420 n1_M2_13020_99420 0.988200
R12524 n1_M2_13020_99420 n1_M2_14100_99420 0.988200
R12525 n1_M2_14100_99420 n1_M2_15180_99420 0.988200
R12526 n1_M2_15180_99420 n1_M2_16260_99420 0.988200
R12527 n1_M2_16260_99420 n1_M2_17340_99420 0.988200
R12528 n1_M2_17340_99420 n1_M2_18420_99420 0.988200
R12529 n1_M2_18420_99420 n1_M2_19500_99420 0.988200
R12530 n1_M2_19500_99420 n1_M2_20580_99420 0.988200
R12531 n1_M2_20580_99420 n1_M2_21660_99420 0.988200
R12532 n1_M2_21660_99420 n1_M2_22740_99420 0.988200
R12533 n1_M2_22740_99420 n1_M2_23820_99420 0.988200
R12534 n1_M2_23820_99420 n1_M2_24900_99420 0.988200
R12535 n1_M2_24900_99420 n1_M2_25980_99420 0.988200
R12536 n1_M2_25980_99420 n1_M2_27060_99420 0.988200
R12537 n1_M2_27060_99420 n1_M2_28140_99420 0.988200
R12538 n1_M2_28140_99420 n1_M2_29220_99420 0.988200
R12539 n1_M2_29220_99420 n1_M2_30300_99420 0.988200
R12540 n1_M2_30300_99420 n1_M2_31380_99420 0.988200
R12541 n1_M2_31380_99420 n1_M2_32460_99420 0.988200
R12542 n1_M2_32460_99420 n1_M2_33540_99420 0.988200
R12543 n1_M2_33540_99420 n1_M2_34620_99420 0.988200
R12544 n1_M2_34620_99420 n1_M2_35700_99420 0.988200
R12545 n1_M2_35700_99420 n1_M2_36780_99420 0.988200
R12546 n1_M2_36780_99420 n1_M2_37860_99420 0.988200
R12547 n1_M2_37860_99420 n1_M2_38940_99420 0.988200
R12548 n1_M2_38940_99420 n1_M2_40020_99420 0.988200
R12549 n1_M2_40020_99420 n1_M2_41100_99420 0.988200
R12550 n1_M2_41100_99420 n1_M2_42180_99420 0.988200
R12551 n1_M2_42180_99420 n1_M2_43260_99420 0.988200
R12552 n1_M2_43260_99420 n1_M2_44340_99420 0.988200
R12553 n1_M2_44340_99420 n1_M2_45420_99420 0.988200
R12554 n1_M2_45420_99420 n1_M2_46500_99420 0.988200
R12555 n1_M2_46500_99420 n1_M2_47580_99420 0.988200
R12556 n1_M2_47580_99420 n1_M2_48660_99420 0.988200
R12557 n1_M2_48660_99420 n1_M2_49740_99420 0.988200
R12558 n1_M2_49740_99420 n1_M2_50820_99420 0.988200
R12559 n1_M2_50820_99420 n1_M2_51900_99420 0.988200
R12560 n1_M2_51900_99420 n1_M2_52980_99420 0.988200
R12561 n1_M2_52980_99420 n1_M2_54060_99420 0.988200
R12562 n1_M2_54060_99420 n1_M2_55140_99420 0.988200
R12563 n1_M2_55140_99420 n1_M2_56220_99420 0.988200
R12564 n1_M2_56220_99420 n1_M2_57300_99420 0.988200
R12565 n1_M2_57300_99420 n1_M2_58380_99420 0.988200
R12566 n1_M2_58380_99420 n1_M2_59460_99420 0.988200
R12567 n1_M2_59460_99420 n1_M2_60540_99420 0.988200
R12568 n1_M2_60540_99420 n1_M2_61620_99420 0.988200
R12569 n1_M2_61620_99420 n1_M2_62700_99420 0.988200
R12570 n1_M2_62700_99420 n1_M2_63780_99420 0.988200
R12571 n1_M2_63780_99420 n1_M2_64860_99420 0.988200
R12572 n1_M2_64860_99420 n1_M2_65940_99420 0.988200
R12573 n1_M2_65940_99420 n1_M2_67020_99420 0.988200
R12574 n1_M2_67020_99420 n1_M2_68100_99420 0.988200
R12575 n1_M2_68100_99420 n1_M2_69180_99420 0.988200
R12576 n1_M2_69180_99420 n1_M2_70260_99420 0.988200
R12577 n1_M2_70260_99420 n1_M2_71340_99420 0.988200
R12578 n1_M2_71340_99420 n1_M2_72420_99420 0.988200
R12579 n1_M2_72420_99420 n1_M2_73500_99420 0.988200
R12580 n1_M2_73500_99420 n1_M2_74580_99420 0.988200
R12581 n1_M2_74580_99420 n1_M2_75660_99420 0.988200
R12582 n1_M2_75660_99420 n1_M2_76740_99420 0.988200
R12583 n1_M2_76740_99420 n1_M2_77820_99420 0.988200
R12584 n1_M2_77820_99420 n1_M2_78900_99420 0.988200
R12585 n1_M2_78900_99420 n1_M2_79980_99420 0.988200
R12586 n1_M2_79980_99420 n1_M2_81060_99420 0.988200
R12587 n1_M2_81060_99420 n1_M2_82140_99420 0.988200
R12588 n1_M2_82140_99420 n1_M2_83220_99420 0.988200
R12589 n1_M2_83220_99420 n1_M2_84300_99420 0.988200
R12590 n1_M2_84300_99420 n1_M2_85380_99420 0.988200
R12591 n1_M2_85380_99420 n1_M2_86460_99420 0.988200
R12592 n1_M2_86460_99420 n1_M2_87540_99420 0.988200
R12593 n1_M2_87540_99420 n1_M2_88620_99420 0.988200
R12594 n1_M2_88620_99420 n1_M2_89700_99420 0.988200
R12595 n1_M2_89700_99420 n1_M2_90780_99420 0.988200
R12596 n1_M2_90780_99420 n1_M2_91860_99420 0.988200
R12597 n1_M2_91860_99420 n1_M2_92940_99420 0.988200
R12598 n1_M2_92940_99420 n1_M2_94020_99420 0.988200
R12599 n1_M2_94020_99420 n1_M2_95100_99420 0.988200
R12600 n1_M2_95100_99420 n1_M2_96180_99420 0.988200
R12601 n1_M2_96180_99420 n1_M2_97260_99420 0.988200
R12602 n1_M2_97260_99420 n1_M2_98340_99420 0.988200
R12603 n1_M2_98340_99420 n1_M2_99420_99420 0.988200
R12604 n1_M2_99420_99420 n1_M2_100500_99420 0.988200
R12605 n1_M2_100500_99420 n1_M2_101580_99420 0.988200
R12606 n1_M2_101580_99420 n1_M2_102660_99420 0.988200
R12607 n1_M2_102660_99420 n1_M2_103740_99420 0.988200
R12608 n1_M2_103740_99420 n1_M2_104820_99420 0.988200
R12609 n1_M2_104820_99420 n1_M2_105900_99420 0.988200
R12610 n1_M2_105900_99420 n1_M2_106980_99420 0.988200
R12611 n1_M2_106980_99420 n1_M2_108060_99420 0.988200
R12612 n1_M2_108060_99420 n1_M2_109140_99420 0.988200
R12613 n1_M2_109140_99420 n1_M2_110220_99420 0.988200
R12614 n1_M2_110220_99420 n1_M2_111300_99420 0.988200
R12615 n1_M2_111300_99420 n1_M2_112380_99420 0.988200
R12616 n1_M2_112380_99420 n1_M2_113460_99420 0.988200
R12617 n1_M2_113460_99420 n1_M2_114540_99420 0.988200
R12618 n1_M2_114540_99420 n1_M2_115620_99420 0.988200
R12619 n1_M2_115620_99420 n1_M2_116700_99420 0.988200
R12620 n1_M2_116700_99420 n1_M2_117780_99420 0.988200
R12621 n1_M2_117780_99420 n1_M2_118860_99420 0.988200
R12622 n1_M2_118860_99420 n1_M2_119940_99420 0.988200
R12623 n1_M2_119940_99420 n1_M2_121020_99420 0.988200
R12624 n1_M2_121020_99420 n1_M2_122100_99420 0.988200
R12625 n1_M2_122100_99420 n1_M2_123180_99420 0.988200
R12626 n1_M2_123180_99420 n1_M2_124260_99420 0.988200
R12627 n1_M2_124260_99420 n1_M2_125340_99420 0.988200
R12628 n1_M2_125340_99420 n1_M2_126420_99420 0.988200
R12629 n1_M2_126420_99420 n1_M2_127500_99420 0.988200
R12630 n1_M2_127500_99420 n1_M2_128580_99420 0.988200
R12631 n1_M2_128580_99420 n1_M2_129660_99420 0.988200
R12632 n1_M2_129660_99420 n1_M2_130740_99420 0.988200
R12633 n1_M2_130740_99420 n1_M2_131820_99420 0.988200
R12634 n1_M2_131820_99420 n1_M2_132900_99420 0.988200
R12635 n1_M2_132900_99420 n1_M2_133980_99420 0.988200
R12636 n1_M2_133980_99420 n1_M2_135060_99420 0.988200
R12637 n1_M2_135060_99420 n1_M2_136140_99420 0.988200
R12638 n1_M2_136140_99420 n1_M2_137220_99420 0.988200
R12639 n1_M2_137220_99420 n1_M2_138300_99420 0.988200
R12640 n1_M2_138300_99420 n1_M2_139380_99420 0.988200
R12641 n1_M2_139380_99420 n1_M2_140460_99420 0.988200
R12642 n1_M2_140460_99420 n1_M2_141540_99420 0.988200
R12643 n1_M2_141540_99420 n1_M2_142620_99420 0.988200
R12644 n1_M2_142620_99420 n1_M2_143700_99420 0.988200
R12645 n1_M2_143700_99420 n1_M2_144780_99420 0.988200
R12646 n1_M2_144780_99420 n1_M2_145860_99420 0.988200
R12647 n1_M2_145860_99420 n1_M2_146940_99420 0.988200
R12648 n1_M2_60_100500 n1_M2_1140_100500 0.988200
R12649 n1_M2_1140_100500 n1_M2_2220_100500 0.988200
R12650 n1_M2_2220_100500 n1_M2_3300_100500 0.988200
R12651 n1_M2_3300_100500 n1_M2_4380_100500 0.988200
R12652 n1_M2_4380_100500 n1_M2_5460_100500 0.988200
R12653 n1_M2_5460_100500 n1_M2_6540_100500 0.988200
R12654 n1_M2_6540_100500 n1_M2_7620_100500 0.988200
R12655 n1_M2_7620_100500 n1_M2_8700_100500 0.988200
R12656 n1_M2_8700_100500 n1_M2_9780_100500 0.988200
R12657 n1_M2_9780_100500 n1_M2_10860_100500 0.988200
R12658 n1_M2_10860_100500 n1_M2_11940_100500 0.988200
R12659 n1_M2_11940_100500 n1_M2_13020_100500 0.988200
R12660 n1_M2_13020_100500 n1_M2_14100_100500 0.988200
R12661 n1_M2_14100_100500 n1_M2_15180_100500 0.988200
R12662 n1_M2_15180_100500 n1_M2_16260_100500 0.988200
R12663 n1_M2_16260_100500 n1_M2_17340_100500 0.988200
R12664 n1_M2_17340_100500 n1_M2_18420_100500 0.988200
R12665 n1_M2_18420_100500 n1_M2_19500_100500 0.988200
R12666 n1_M2_19500_100500 n1_M2_20580_100500 0.988200
R12667 n1_M2_20580_100500 n1_M2_21660_100500 0.988200
R12668 n1_M2_21660_100500 n1_M2_22740_100500 0.988200
R12669 n1_M2_22740_100500 n1_M2_23820_100500 0.988200
R12670 n1_M2_23820_100500 n1_M2_24900_100500 0.988200
R12671 n1_M2_24900_100500 n1_M2_25980_100500 0.988200
R12672 n1_M2_25980_100500 n1_M2_27060_100500 0.988200
R12673 n1_M2_27060_100500 n1_M2_28140_100500 0.988200
R12674 n1_M2_28140_100500 n1_M2_29220_100500 0.988200
R12675 n1_M2_29220_100500 n1_M2_30300_100500 0.988200
R12676 n1_M2_30300_100500 n1_M2_31380_100500 0.988200
R12677 n1_M2_31380_100500 n1_M2_32460_100500 0.988200
R12678 n1_M2_32460_100500 n1_M2_33540_100500 0.988200
R12679 n1_M2_33540_100500 n1_M2_34620_100500 0.988200
R12680 n1_M2_34620_100500 n1_M2_35700_100500 0.988200
R12681 n1_M2_35700_100500 n1_M2_36780_100500 0.988200
R12682 n1_M2_36780_100500 n1_M2_37860_100500 0.988200
R12683 n1_M2_37860_100500 n1_M2_38940_100500 0.988200
R12684 n1_M2_38940_100500 n1_M2_40020_100500 0.988200
R12685 n1_M2_40020_100500 n1_M2_41100_100500 0.988200
R12686 n1_M2_41100_100500 n1_M2_42180_100500 0.988200
R12687 n1_M2_42180_100500 n1_M2_43260_100500 0.988200
R12688 n1_M2_43260_100500 n1_M2_44340_100500 0.988200
R12689 n1_M2_44340_100500 n1_M2_45420_100500 0.988200
R12690 n1_M2_45420_100500 n1_M2_46500_100500 0.988200
R12691 n1_M2_46500_100500 n1_M2_47580_100500 0.988200
R12692 n1_M2_47580_100500 n1_M2_48660_100500 0.988200
R12693 n1_M2_48660_100500 n1_M2_49740_100500 0.988200
R12694 n1_M2_49740_100500 n1_M2_50820_100500 0.988200
R12695 n1_M2_50820_100500 n1_M2_51900_100500 0.988200
R12696 n1_M2_51900_100500 n1_M2_52980_100500 0.988200
R12697 n1_M2_52980_100500 n1_M2_54060_100500 0.988200
R12698 n1_M2_54060_100500 n1_M2_55140_100500 0.988200
R12699 n1_M2_55140_100500 n1_M2_56220_100500 0.988200
R12700 n1_M2_56220_100500 n1_M2_57300_100500 0.988200
R12701 n1_M2_57300_100500 n1_M2_58380_100500 0.988200
R12702 n1_M2_58380_100500 n1_M2_59460_100500 0.988200
R12703 n1_M2_59460_100500 n1_M2_60540_100500 0.988200
R12704 n1_M2_60540_100500 n1_M2_61620_100500 0.988200
R12705 n1_M2_61620_100500 n1_M2_62700_100500 0.988200
R12706 n1_M2_62700_100500 n1_M2_63780_100500 0.988200
R12707 n1_M2_63780_100500 n1_M2_64860_100500 0.988200
R12708 n1_M2_64860_100500 n1_M2_65940_100500 0.988200
R12709 n1_M2_65940_100500 n1_M2_67020_100500 0.988200
R12710 n1_M2_67020_100500 n1_M2_68100_100500 0.988200
R12711 n1_M2_68100_100500 n1_M2_69180_100500 0.988200
R12712 n1_M2_69180_100500 n1_M2_70260_100500 0.988200
R12713 n1_M2_70260_100500 n1_M2_71340_100500 0.988200
R12714 n1_M2_71340_100500 n1_M2_72420_100500 0.988200
R12715 n1_M2_72420_100500 n1_M2_73500_100500 0.988200
R12716 n1_M2_73500_100500 n1_M2_74580_100500 0.988200
R12717 n1_M2_74580_100500 n1_M2_75660_100500 0.988200
R12718 n1_M2_75660_100500 n1_M2_76740_100500 0.988200
R12719 n1_M2_76740_100500 n1_M2_77820_100500 0.988200
R12720 n1_M2_77820_100500 n1_M2_78900_100500 0.988200
R12721 n1_M2_78900_100500 n1_M2_79980_100500 0.988200
R12722 n1_M2_79980_100500 n1_M2_81060_100500 0.988200
R12723 n1_M2_81060_100500 n1_M2_82140_100500 0.988200
R12724 n1_M2_82140_100500 n1_M2_83220_100500 0.988200
R12725 n1_M2_83220_100500 n1_M2_84300_100500 0.988200
R12726 n1_M2_84300_100500 n1_M2_85380_100500 0.988200
R12727 n1_M2_85380_100500 n1_M2_86460_100500 0.988200
R12728 n1_M2_86460_100500 n1_M2_87540_100500 0.988200
R12729 n1_M2_87540_100500 n1_M2_88620_100500 0.988200
R12730 n1_M2_88620_100500 n1_M2_89700_100500 0.988200
R12731 n1_M2_89700_100500 n1_M2_90780_100500 0.988200
R12732 n1_M2_90780_100500 n1_M2_91860_100500 0.988200
R12733 n1_M2_91860_100500 n1_M2_92940_100500 0.988200
R12734 n1_M2_92940_100500 n1_M2_94020_100500 0.988200
R12735 n1_M2_94020_100500 n1_M2_95100_100500 0.988200
R12736 n1_M2_95100_100500 n1_M2_96180_100500 0.988200
R12737 n1_M2_96180_100500 n1_M2_97260_100500 0.988200
R12738 n1_M2_97260_100500 n1_M2_98340_100500 0.988200
R12739 n1_M2_98340_100500 n1_M2_99420_100500 0.988200
R12740 n1_M2_99420_100500 n1_M2_100500_100500 0.988200
R12741 n1_M2_100500_100500 n1_M2_101580_100500 0.988200
R12742 n1_M2_101580_100500 n1_M2_102660_100500 0.988200
R12743 n1_M2_102660_100500 n1_M2_103740_100500 0.988200
R12744 n1_M2_103740_100500 n1_M2_104820_100500 0.988200
R12745 n1_M2_104820_100500 n1_M2_105900_100500 0.988200
R12746 n1_M2_105900_100500 n1_M2_106980_100500 0.988200
R12747 n1_M2_106980_100500 n1_M2_108060_100500 0.988200
R12748 n1_M2_108060_100500 n1_M2_109140_100500 0.988200
R12749 n1_M2_109140_100500 n1_M2_110220_100500 0.988200
R12750 n1_M2_110220_100500 n1_M2_111300_100500 0.988200
R12751 n1_M2_111300_100500 n1_M2_112380_100500 0.988200
R12752 n1_M2_112380_100500 n1_M2_113460_100500 0.988200
R12753 n1_M2_113460_100500 n1_M2_114540_100500 0.988200
R12754 n1_M2_114540_100500 n1_M2_115620_100500 0.988200
R12755 n1_M2_115620_100500 n1_M2_116700_100500 0.988200
R12756 n1_M2_116700_100500 n1_M2_117780_100500 0.988200
R12757 n1_M2_117780_100500 n1_M2_118860_100500 0.988200
R12758 n1_M2_118860_100500 n1_M2_119940_100500 0.988200
R12759 n1_M2_119940_100500 n1_M2_121020_100500 0.988200
R12760 n1_M2_121020_100500 n1_M2_122100_100500 0.988200
R12761 n1_M2_122100_100500 n1_M2_123180_100500 0.988200
R12762 n1_M2_123180_100500 n1_M2_124260_100500 0.988200
R12763 n1_M2_124260_100500 n1_M2_125340_100500 0.988200
R12764 n1_M2_125340_100500 n1_M2_126420_100500 0.988200
R12765 n1_M2_126420_100500 n1_M2_127500_100500 0.988200
R12766 n1_M2_127500_100500 n1_M2_128580_100500 0.988200
R12767 n1_M2_128580_100500 n1_M2_129660_100500 0.988200
R12768 n1_M2_129660_100500 n1_M2_130740_100500 0.988200
R12769 n1_M2_130740_100500 n1_M2_131820_100500 0.988200
R12770 n1_M2_131820_100500 n1_M2_132900_100500 0.988200
R12771 n1_M2_132900_100500 n1_M2_133980_100500 0.988200
R12772 n1_M2_133980_100500 n1_M2_135060_100500 0.988200
R12773 n1_M2_135060_100500 n1_M2_136140_100500 0.988200
R12774 n1_M2_136140_100500 n1_M2_137220_100500 0.988200
R12775 n1_M2_137220_100500 n1_M2_138300_100500 0.988200
R12776 n1_M2_138300_100500 n1_M2_139380_100500 0.988200
R12777 n1_M2_139380_100500 n1_M2_140460_100500 0.988200
R12778 n1_M2_140460_100500 n1_M2_141540_100500 0.988200
R12779 n1_M2_141540_100500 n1_M2_142620_100500 0.988200
R12780 n1_M2_142620_100500 n1_M2_143700_100500 0.988200
R12781 n1_M2_143700_100500 n1_M2_144780_100500 0.988200
R12782 n1_M2_144780_100500 n1_M2_145860_100500 0.988200
R12783 n1_M2_145860_100500 n1_M2_146940_100500 0.988200
R12784 n1_M2_60_101580 n1_M2_1140_101580 0.988200
R12785 n1_M2_1140_101580 n1_M2_2220_101580 0.988200
R12786 n1_M2_2220_101580 n1_M2_3300_101580 0.988200
R12787 n1_M2_3300_101580 n1_M2_4380_101580 0.988200
R12788 n1_M2_4380_101580 n1_M2_5460_101580 0.988200
R12789 n1_M2_5460_101580 n1_M2_6540_101580 0.988200
R12790 n1_M2_6540_101580 n1_M2_7620_101580 0.988200
R12791 n1_M2_7620_101580 n1_M2_8700_101580 0.988200
R12792 n1_M2_8700_101580 n1_M2_9780_101580 0.988200
R12793 n1_M2_9780_101580 n1_M2_10860_101580 0.988200
R12794 n1_M2_10860_101580 n1_M2_11940_101580 0.988200
R12795 n1_M2_11940_101580 n1_M2_13020_101580 0.988200
R12796 n1_M2_13020_101580 n1_M2_14100_101580 0.988200
R12797 n1_M2_14100_101580 n1_M2_15180_101580 0.988200
R12798 n1_M2_15180_101580 n1_M2_16260_101580 0.988200
R12799 n1_M2_16260_101580 n1_M2_17340_101580 0.988200
R12800 n1_M2_17340_101580 n1_M2_18420_101580 0.988200
R12801 n1_M2_18420_101580 n1_M2_19500_101580 0.988200
R12802 n1_M2_19500_101580 n1_M2_20580_101580 0.988200
R12803 n1_M2_20580_101580 n1_M2_21660_101580 0.988200
R12804 n1_M2_21660_101580 n1_M2_22740_101580 0.988200
R12805 n1_M2_22740_101580 n1_M2_23820_101580 0.988200
R12806 n1_M2_23820_101580 n1_M2_24900_101580 0.988200
R12807 n1_M2_24900_101580 n1_M2_25980_101580 0.988200
R12808 n1_M2_25980_101580 n1_M2_27060_101580 0.988200
R12809 n1_M2_27060_101580 n1_M2_28140_101580 0.988200
R12810 n1_M2_28140_101580 n1_M2_29220_101580 0.988200
R12811 n1_M2_29220_101580 n1_M2_30300_101580 0.988200
R12812 n1_M2_30300_101580 n1_M2_31380_101580 0.988200
R12813 n1_M2_31380_101580 n1_M2_32460_101580 0.988200
R12814 n1_M2_32460_101580 n1_M2_33540_101580 0.988200
R12815 n1_M2_33540_101580 n1_M2_34620_101580 0.988200
R12816 n1_M2_34620_101580 n1_M2_35700_101580 0.988200
R12817 n1_M2_35700_101580 n1_M2_36780_101580 0.988200
R12818 n1_M2_36780_101580 n1_M2_37860_101580 0.988200
R12819 n1_M2_37860_101580 n1_M2_38940_101580 0.988200
R12820 n1_M2_38940_101580 n1_M2_40020_101580 0.988200
R12821 n1_M2_40020_101580 n1_M2_41100_101580 0.988200
R12822 n1_M2_41100_101580 n1_M2_42180_101580 0.988200
R12823 n1_M2_42180_101580 n1_M2_43260_101580 0.988200
R12824 n1_M2_43260_101580 n1_M2_44340_101580 0.988200
R12825 n1_M2_44340_101580 n1_M2_45420_101580 0.988200
R12826 n1_M2_45420_101580 n1_M2_46500_101580 0.988200
R12827 n1_M2_46500_101580 n1_M2_47580_101580 0.988200
R12828 n1_M2_47580_101580 n1_M2_48660_101580 0.988200
R12829 n1_M2_48660_101580 n1_M2_49740_101580 0.988200
R12830 n1_M2_49740_101580 n1_M2_50820_101580 0.988200
R12831 n1_M2_50820_101580 n1_M2_51900_101580 0.988200
R12832 n1_M2_51900_101580 n1_M2_52980_101580 0.988200
R12833 n1_M2_52980_101580 n1_M2_54060_101580 0.988200
R12834 n1_M2_54060_101580 n1_M2_55140_101580 0.988200
R12835 n1_M2_55140_101580 n1_M2_56220_101580 0.988200
R12836 n1_M2_56220_101580 n1_M2_57300_101580 0.988200
R12837 n1_M2_57300_101580 n1_M2_58380_101580 0.988200
R12838 n1_M2_58380_101580 n1_M2_59460_101580 0.988200
R12839 n1_M2_59460_101580 n1_M2_60540_101580 0.988200
R12840 n1_M2_60540_101580 n1_M2_61620_101580 0.988200
R12841 n1_M2_61620_101580 n1_M2_62700_101580 0.988200
R12842 n1_M2_62700_101580 n1_M2_63780_101580 0.988200
R12843 n1_M2_63780_101580 n1_M2_64860_101580 0.988200
R12844 n1_M2_64860_101580 n1_M2_65940_101580 0.988200
R12845 n1_M2_65940_101580 n1_M2_67020_101580 0.988200
R12846 n1_M2_67020_101580 n1_M2_68100_101580 0.988200
R12847 n1_M2_68100_101580 n1_M2_69180_101580 0.988200
R12848 n1_M2_69180_101580 n1_M2_70260_101580 0.988200
R12849 n1_M2_70260_101580 n1_M2_71340_101580 0.988200
R12850 n1_M2_71340_101580 n1_M2_72420_101580 0.988200
R12851 n1_M2_72420_101580 n1_M2_73500_101580 0.988200
R12852 n1_M2_73500_101580 n1_M2_74580_101580 0.988200
R12853 n1_M2_74580_101580 n1_M2_75660_101580 0.988200
R12854 n1_M2_75660_101580 n1_M2_76740_101580 0.988200
R12855 n1_M2_76740_101580 n1_M2_77820_101580 0.988200
R12856 n1_M2_77820_101580 n1_M2_78900_101580 0.988200
R12857 n1_M2_78900_101580 n1_M2_79980_101580 0.988200
R12858 n1_M2_79980_101580 n1_M2_81060_101580 0.988200
R12859 n1_M2_81060_101580 n1_M2_82140_101580 0.988200
R12860 n1_M2_82140_101580 n1_M2_83220_101580 0.988200
R12861 n1_M2_83220_101580 n1_M2_84300_101580 0.988200
R12862 n1_M2_84300_101580 n1_M2_85380_101580 0.988200
R12863 n1_M2_85380_101580 n1_M2_86460_101580 0.988200
R12864 n1_M2_86460_101580 n1_M2_87540_101580 0.988200
R12865 n1_M2_87540_101580 n1_M2_88620_101580 0.988200
R12866 n1_M2_88620_101580 n1_M2_89700_101580 0.988200
R12867 n1_M2_89700_101580 n1_M2_90780_101580 0.988200
R12868 n1_M2_90780_101580 n1_M2_91860_101580 0.988200
R12869 n1_M2_91860_101580 n1_M2_92940_101580 0.988200
R12870 n1_M2_92940_101580 n1_M2_94020_101580 0.988200
R12871 n1_M2_94020_101580 n1_M2_95100_101580 0.988200
R12872 n1_M2_95100_101580 n1_M2_96180_101580 0.988200
R12873 n1_M2_96180_101580 n1_M2_97260_101580 0.988200
R12874 n1_M2_97260_101580 n1_M2_98340_101580 0.988200
R12875 n1_M2_98340_101580 n1_M2_99420_101580 0.988200
R12876 n1_M2_99420_101580 n1_M2_100500_101580 0.988200
R12877 n1_M2_100500_101580 n1_M2_101580_101580 0.988200
R12878 n1_M2_101580_101580 n1_M2_102660_101580 0.988200
R12879 n1_M2_102660_101580 n1_M2_103740_101580 0.988200
R12880 n1_M2_103740_101580 n1_M2_104820_101580 0.988200
R12881 n1_M2_104820_101580 n1_M2_105900_101580 0.988200
R12882 n1_M2_105900_101580 n1_M2_106980_101580 0.988200
R12883 n1_M2_106980_101580 n1_M2_108060_101580 0.988200
R12884 n1_M2_108060_101580 n1_M2_109140_101580 0.988200
R12885 n1_M2_109140_101580 n1_M2_110220_101580 0.988200
R12886 n1_M2_110220_101580 n1_M2_111300_101580 0.988200
R12887 n1_M2_111300_101580 n1_M2_112380_101580 0.988200
R12888 n1_M2_112380_101580 n1_M2_113460_101580 0.988200
R12889 n1_M2_113460_101580 n1_M2_114540_101580 0.988200
R12890 n1_M2_114540_101580 n1_M2_115620_101580 0.988200
R12891 n1_M2_115620_101580 n1_M2_116700_101580 0.988200
R12892 n1_M2_116700_101580 n1_M2_117780_101580 0.988200
R12893 n1_M2_117780_101580 n1_M2_118860_101580 0.988200
R12894 n1_M2_118860_101580 n1_M2_119940_101580 0.988200
R12895 n1_M2_119940_101580 n1_M2_121020_101580 0.988200
R12896 n1_M2_121020_101580 n1_M2_122100_101580 0.988200
R12897 n1_M2_122100_101580 n1_M2_123180_101580 0.988200
R12898 n1_M2_123180_101580 n1_M2_124260_101580 0.988200
R12899 n1_M2_124260_101580 n1_M2_125340_101580 0.988200
R12900 n1_M2_125340_101580 n1_M2_126420_101580 0.988200
R12901 n1_M2_126420_101580 n1_M2_127500_101580 0.988200
R12902 n1_M2_127500_101580 n1_M2_128580_101580 0.988200
R12903 n1_M2_128580_101580 n1_M2_129660_101580 0.988200
R12904 n1_M2_129660_101580 n1_M2_130740_101580 0.988200
R12905 n1_M2_130740_101580 n1_M2_131820_101580 0.988200
R12906 n1_M2_131820_101580 n1_M2_132900_101580 0.988200
R12907 n1_M2_132900_101580 n1_M2_133980_101580 0.988200
R12908 n1_M2_133980_101580 n1_M2_135060_101580 0.988200
R12909 n1_M2_135060_101580 n1_M2_136140_101580 0.988200
R12910 n1_M2_136140_101580 n1_M2_137220_101580 0.988200
R12911 n1_M2_137220_101580 n1_M2_138300_101580 0.988200
R12912 n1_M2_138300_101580 n1_M2_139380_101580 0.988200
R12913 n1_M2_139380_101580 n1_M2_140460_101580 0.988200
R12914 n1_M2_140460_101580 n1_M2_141540_101580 0.988200
R12915 n1_M2_141540_101580 n1_M2_142620_101580 0.988200
R12916 n1_M2_142620_101580 n1_M2_143700_101580 0.988200
R12917 n1_M2_143700_101580 n1_M2_144780_101580 0.988200
R12918 n1_M2_144780_101580 n1_M2_145860_101580 0.988200
R12919 n1_M2_145860_101580 n1_M2_146940_101580 0.988200
R12920 n1_M2_60_102660 n1_M2_1140_102660 0.988200
R12921 n1_M2_1140_102660 n1_M2_2220_102660 0.988200
R12922 n1_M2_2220_102660 n1_M2_3300_102660 0.988200
R12923 n1_M2_3300_102660 n1_M2_4380_102660 0.988200
R12924 n1_M2_4380_102660 n1_M2_5460_102660 0.988200
R12925 n1_M2_5460_102660 n1_M2_6540_102660 0.988200
R12926 n1_M2_6540_102660 n1_M2_7620_102660 0.988200
R12927 n1_M2_7620_102660 n1_M2_8700_102660 0.988200
R12928 n1_M2_8700_102660 n1_M2_9780_102660 0.988200
R12929 n1_M2_9780_102660 n1_M2_10860_102660 0.988200
R12930 n1_M2_10860_102660 n1_M2_11940_102660 0.988200
R12931 n1_M2_11940_102660 n1_M2_13020_102660 0.988200
R12932 n1_M2_13020_102660 n1_M2_14100_102660 0.988200
R12933 n1_M2_14100_102660 n1_M2_15180_102660 0.988200
R12934 n1_M2_15180_102660 n1_M2_16260_102660 0.988200
R12935 n1_M2_16260_102660 n1_M2_17340_102660 0.988200
R12936 n1_M2_17340_102660 n1_M2_18420_102660 0.988200
R12937 n1_M2_18420_102660 n1_M2_19500_102660 0.988200
R12938 n1_M2_19500_102660 n1_M2_20580_102660 0.988200
R12939 n1_M2_20580_102660 n1_M2_21660_102660 0.988200
R12940 n1_M2_21660_102660 n1_M2_22740_102660 0.988200
R12941 n1_M2_22740_102660 n1_M2_23820_102660 0.988200
R12942 n1_M2_23820_102660 n1_M2_24900_102660 0.988200
R12943 n1_M2_24900_102660 n1_M2_25980_102660 0.988200
R12944 n1_M2_25980_102660 n1_M2_27060_102660 0.988200
R12945 n1_M2_27060_102660 n1_M2_28140_102660 0.988200
R12946 n1_M2_28140_102660 n1_M2_29220_102660 0.988200
R12947 n1_M2_29220_102660 n1_M2_30300_102660 0.988200
R12948 n1_M2_30300_102660 n1_M2_31380_102660 0.988200
R12949 n1_M2_31380_102660 n1_M2_32460_102660 0.988200
R12950 n1_M2_32460_102660 n1_M2_33540_102660 0.988200
R12951 n1_M2_33540_102660 n1_M2_34620_102660 0.988200
R12952 n1_M2_34620_102660 n1_M2_35700_102660 0.988200
R12953 n1_M2_35700_102660 n1_M2_36780_102660 0.988200
R12954 n1_M2_36780_102660 n1_M2_37860_102660 0.988200
R12955 n1_M2_37860_102660 n1_M2_38940_102660 0.988200
R12956 n1_M2_38940_102660 n1_M2_40020_102660 0.988200
R12957 n1_M2_40020_102660 n1_M2_41100_102660 0.988200
R12958 n1_M2_41100_102660 n1_M2_42180_102660 0.988200
R12959 n1_M2_42180_102660 n1_M2_43260_102660 0.988200
R12960 n1_M2_43260_102660 n1_M2_44340_102660 0.988200
R12961 n1_M2_44340_102660 n1_M2_45420_102660 0.988200
R12962 n1_M2_45420_102660 n1_M2_46500_102660 0.988200
R12963 n1_M2_46500_102660 n1_M2_47580_102660 0.988200
R12964 n1_M2_47580_102660 n1_M2_48660_102660 0.988200
R12965 n1_M2_48660_102660 n1_M2_49740_102660 0.988200
R12966 n1_M2_49740_102660 n1_M2_50820_102660 0.988200
R12967 n1_M2_50820_102660 n1_M2_51900_102660 0.988200
R12968 n1_M2_51900_102660 n1_M2_52980_102660 0.988200
R12969 n1_M2_52980_102660 n1_M2_54060_102660 0.988200
R12970 n1_M2_54060_102660 n1_M2_55140_102660 0.988200
R12971 n1_M2_55140_102660 n1_M2_56220_102660 0.988200
R12972 n1_M2_56220_102660 n1_M2_57300_102660 0.988200
R12973 n1_M2_57300_102660 n1_M2_58380_102660 0.988200
R12974 n1_M2_58380_102660 n1_M2_59460_102660 0.988200
R12975 n1_M2_59460_102660 n1_M2_60540_102660 0.988200
R12976 n1_M2_60540_102660 n1_M2_61620_102660 0.988200
R12977 n1_M2_61620_102660 n1_M2_62700_102660 0.988200
R12978 n1_M2_62700_102660 n1_M2_63780_102660 0.988200
R12979 n1_M2_63780_102660 n1_M2_64860_102660 0.988200
R12980 n1_M2_64860_102660 n1_M2_65940_102660 0.988200
R12981 n1_M2_65940_102660 n1_M2_67020_102660 0.988200
R12982 n1_M2_67020_102660 n1_M2_68100_102660 0.988200
R12983 n1_M2_68100_102660 n1_M2_69180_102660 0.988200
R12984 n1_M2_69180_102660 n1_M2_70260_102660 0.988200
R12985 n1_M2_70260_102660 n1_M2_71340_102660 0.988200
R12986 n1_M2_71340_102660 n1_M2_72420_102660 0.988200
R12987 n1_M2_72420_102660 n1_M2_73500_102660 0.988200
R12988 n1_M2_73500_102660 n1_M2_74580_102660 0.988200
R12989 n1_M2_74580_102660 n1_M2_75660_102660 0.988200
R12990 n1_M2_75660_102660 n1_M2_76740_102660 0.988200
R12991 n1_M2_76740_102660 n1_M2_77820_102660 0.988200
R12992 n1_M2_77820_102660 n1_M2_78900_102660 0.988200
R12993 n1_M2_78900_102660 n1_M2_79980_102660 0.988200
R12994 n1_M2_79980_102660 n1_M2_81060_102660 0.988200
R12995 n1_M2_81060_102660 n1_M2_82140_102660 0.988200
R12996 n1_M2_82140_102660 n1_M2_83220_102660 0.988200
R12997 n1_M2_83220_102660 n1_M2_84300_102660 0.988200
R12998 n1_M2_84300_102660 n1_M2_85380_102660 0.988200
R12999 n1_M2_85380_102660 n1_M2_86460_102660 0.988200
R13000 n1_M2_86460_102660 n1_M2_87540_102660 0.988200
R13001 n1_M2_87540_102660 n1_M2_88620_102660 0.988200
R13002 n1_M2_88620_102660 n1_M2_89700_102660 0.988200
R13003 n1_M2_89700_102660 n1_M2_90780_102660 0.988200
R13004 n1_M2_90780_102660 n1_M2_91860_102660 0.988200
R13005 n1_M2_91860_102660 n1_M2_92940_102660 0.988200
R13006 n1_M2_92940_102660 n1_M2_94020_102660 0.988200
R13007 n1_M2_94020_102660 n1_M2_95100_102660 0.988200
R13008 n1_M2_95100_102660 n1_M2_96180_102660 0.988200
R13009 n1_M2_96180_102660 n1_M2_97260_102660 0.988200
R13010 n1_M2_97260_102660 n1_M2_98340_102660 0.988200
R13011 n1_M2_98340_102660 n1_M2_99420_102660 0.988200
R13012 n1_M2_99420_102660 n1_M2_100500_102660 0.988200
R13013 n1_M2_100500_102660 n1_M2_101580_102660 0.988200
R13014 n1_M2_101580_102660 n1_M2_102660_102660 0.988200
R13015 n1_M2_102660_102660 n1_M2_103740_102660 0.988200
R13016 n1_M2_103740_102660 n1_M2_104820_102660 0.988200
R13017 n1_M2_104820_102660 n1_M2_105900_102660 0.988200
R13018 n1_M2_105900_102660 n1_M2_106980_102660 0.988200
R13019 n1_M2_106980_102660 n1_M2_108060_102660 0.988200
R13020 n1_M2_108060_102660 n1_M2_109140_102660 0.988200
R13021 n1_M2_109140_102660 n1_M2_110220_102660 0.988200
R13022 n1_M2_110220_102660 n1_M2_111300_102660 0.988200
R13023 n1_M2_111300_102660 n1_M2_112380_102660 0.988200
R13024 n1_M2_112380_102660 n1_M2_113460_102660 0.988200
R13025 n1_M2_113460_102660 n1_M2_114540_102660 0.988200
R13026 n1_M2_114540_102660 n1_M2_115620_102660 0.988200
R13027 n1_M2_115620_102660 n1_M2_116700_102660 0.988200
R13028 n1_M2_116700_102660 n1_M2_117780_102660 0.988200
R13029 n1_M2_117780_102660 n1_M2_118860_102660 0.988200
R13030 n1_M2_118860_102660 n1_M2_119940_102660 0.988200
R13031 n1_M2_119940_102660 n1_M2_121020_102660 0.988200
R13032 n1_M2_121020_102660 n1_M2_122100_102660 0.988200
R13033 n1_M2_122100_102660 n1_M2_123180_102660 0.988200
R13034 n1_M2_123180_102660 n1_M2_124260_102660 0.988200
R13035 n1_M2_124260_102660 n1_M2_125340_102660 0.988200
R13036 n1_M2_125340_102660 n1_M2_126420_102660 0.988200
R13037 n1_M2_126420_102660 n1_M2_127500_102660 0.988200
R13038 n1_M2_127500_102660 n1_M2_128580_102660 0.988200
R13039 n1_M2_128580_102660 n1_M2_129660_102660 0.988200
R13040 n1_M2_129660_102660 n1_M2_130740_102660 0.988200
R13041 n1_M2_130740_102660 n1_M2_131820_102660 0.988200
R13042 n1_M2_131820_102660 n1_M2_132900_102660 0.988200
R13043 n1_M2_132900_102660 n1_M2_133980_102660 0.988200
R13044 n1_M2_133980_102660 n1_M2_135060_102660 0.988200
R13045 n1_M2_135060_102660 n1_M2_136140_102660 0.988200
R13046 n1_M2_136140_102660 n1_M2_137220_102660 0.988200
R13047 n1_M2_137220_102660 n1_M2_138300_102660 0.988200
R13048 n1_M2_138300_102660 n1_M2_139380_102660 0.988200
R13049 n1_M2_139380_102660 n1_M2_140460_102660 0.988200
R13050 n1_M2_140460_102660 n1_M2_141540_102660 0.988200
R13051 n1_M2_141540_102660 n1_M2_142620_102660 0.988200
R13052 n1_M2_142620_102660 n1_M2_143700_102660 0.988200
R13053 n1_M2_143700_102660 n1_M2_144780_102660 0.988200
R13054 n1_M2_144780_102660 n1_M2_145860_102660 0.988200
R13055 n1_M2_145860_102660 n1_M2_146940_102660 0.988200
R13056 n1_M2_60_103740 n1_M2_1140_103740 0.988200
R13057 n1_M2_1140_103740 n1_M2_2220_103740 0.988200
R13058 n1_M2_2220_103740 n1_M2_3300_103740 0.988200
R13059 n1_M2_3300_103740 n1_M2_4380_103740 0.988200
R13060 n1_M2_4380_103740 n1_M2_5460_103740 0.988200
R13061 n1_M2_5460_103740 n1_M2_6540_103740 0.988200
R13062 n1_M2_6540_103740 n1_M2_7620_103740 0.988200
R13063 n1_M2_7620_103740 n1_M2_8700_103740 0.988200
R13064 n1_M2_8700_103740 n1_M2_9780_103740 0.988200
R13065 n1_M2_9780_103740 n1_M2_10860_103740 0.988200
R13066 n1_M2_10860_103740 n1_M2_11940_103740 0.988200
R13067 n1_M2_11940_103740 n1_M2_13020_103740 0.988200
R13068 n1_M2_13020_103740 n1_M2_14100_103740 0.988200
R13069 n1_M2_14100_103740 n1_M2_15180_103740 0.988200
R13070 n1_M2_15180_103740 n1_M2_16260_103740 0.988200
R13071 n1_M2_16260_103740 n1_M2_17340_103740 0.988200
R13072 n1_M2_17340_103740 n1_M2_18420_103740 0.988200
R13073 n1_M2_18420_103740 n1_M2_19500_103740 0.988200
R13074 n1_M2_19500_103740 n1_M2_20580_103740 0.988200
R13075 n1_M2_20580_103740 n1_M2_21660_103740 0.988200
R13076 n1_M2_21660_103740 n1_M2_22740_103740 0.988200
R13077 n1_M2_22740_103740 n1_M2_23820_103740 0.988200
R13078 n1_M2_23820_103740 n1_M2_24900_103740 0.988200
R13079 n1_M2_24900_103740 n1_M2_25980_103740 0.988200
R13080 n1_M2_25980_103740 n1_M2_27060_103740 0.988200
R13081 n1_M2_27060_103740 n1_M2_28140_103740 0.988200
R13082 n1_M2_28140_103740 n1_M2_29220_103740 0.988200
R13083 n1_M2_29220_103740 n1_M2_30300_103740 0.988200
R13084 n1_M2_30300_103740 n1_M2_31380_103740 0.988200
R13085 n1_M2_31380_103740 n1_M2_32460_103740 0.988200
R13086 n1_M2_32460_103740 n1_M2_33540_103740 0.988200
R13087 n1_M2_33540_103740 n1_M2_34620_103740 0.988200
R13088 n1_M2_34620_103740 n1_M2_35700_103740 0.988200
R13089 n1_M2_35700_103740 n1_M2_36780_103740 0.988200
R13090 n1_M2_36780_103740 n1_M2_37860_103740 0.988200
R13091 n1_M2_37860_103740 n1_M2_38940_103740 0.988200
R13092 n1_M2_38940_103740 n1_M2_40020_103740 0.988200
R13093 n1_M2_40020_103740 n1_M2_41100_103740 0.988200
R13094 n1_M2_41100_103740 n1_M2_42180_103740 0.988200
R13095 n1_M2_42180_103740 n1_M2_43260_103740 0.988200
R13096 n1_M2_43260_103740 n1_M2_44340_103740 0.988200
R13097 n1_M2_44340_103740 n1_M2_45420_103740 0.988200
R13098 n1_M2_45420_103740 n1_M2_46500_103740 0.988200
R13099 n1_M2_46500_103740 n1_M2_47580_103740 0.988200
R13100 n1_M2_47580_103740 n1_M2_48660_103740 0.988200
R13101 n1_M2_48660_103740 n1_M2_49740_103740 0.988200
R13102 n1_M2_49740_103740 n1_M2_50820_103740 0.988200
R13103 n1_M2_50820_103740 n1_M2_51900_103740 0.988200
R13104 n1_M2_51900_103740 n1_M2_52980_103740 0.988200
R13105 n1_M2_52980_103740 n1_M2_54060_103740 0.988200
R13106 n1_M2_54060_103740 n1_M2_55140_103740 0.988200
R13107 n1_M2_55140_103740 n1_M2_56220_103740 0.988200
R13108 n1_M2_56220_103740 n1_M2_57300_103740 0.988200
R13109 n1_M2_57300_103740 n1_M2_58380_103740 0.988200
R13110 n1_M2_58380_103740 n1_M2_59460_103740 0.988200
R13111 n1_M2_59460_103740 n1_M2_60540_103740 0.988200
R13112 n1_M2_60540_103740 n1_M2_61620_103740 0.988200
R13113 n1_M2_61620_103740 n1_M2_62700_103740 0.988200
R13114 n1_M2_62700_103740 n1_M2_63780_103740 0.988200
R13115 n1_M2_63780_103740 n1_M2_64860_103740 0.988200
R13116 n1_M2_64860_103740 n1_M2_65940_103740 0.988200
R13117 n1_M2_65940_103740 n1_M2_67020_103740 0.988200
R13118 n1_M2_67020_103740 n1_M2_68100_103740 0.988200
R13119 n1_M2_68100_103740 n1_M2_69180_103740 0.988200
R13120 n1_M2_69180_103740 n1_M2_70260_103740 0.988200
R13121 n1_M2_70260_103740 n1_M2_71340_103740 0.988200
R13122 n1_M2_71340_103740 n1_M2_72420_103740 0.988200
R13123 n1_M2_72420_103740 n1_M2_73500_103740 0.988200
R13124 n1_M2_73500_103740 n1_M2_74580_103740 0.988200
R13125 n1_M2_74580_103740 n1_M2_75660_103740 0.988200
R13126 n1_M2_75660_103740 n1_M2_76740_103740 0.988200
R13127 n1_M2_76740_103740 n1_M2_77820_103740 0.988200
R13128 n1_M2_77820_103740 n1_M2_78900_103740 0.988200
R13129 n1_M2_78900_103740 n1_M2_79980_103740 0.988200
R13130 n1_M2_79980_103740 n1_M2_81060_103740 0.988200
R13131 n1_M2_81060_103740 n1_M2_82140_103740 0.988200
R13132 n1_M2_82140_103740 n1_M2_83220_103740 0.988200
R13133 n1_M2_83220_103740 n1_M2_84300_103740 0.988200
R13134 n1_M2_84300_103740 n1_M2_85380_103740 0.988200
R13135 n1_M2_85380_103740 n1_M2_86460_103740 0.988200
R13136 n1_M2_86460_103740 n1_M2_87540_103740 0.988200
R13137 n1_M2_87540_103740 n1_M2_88620_103740 0.988200
R13138 n1_M2_88620_103740 n1_M2_89700_103740 0.988200
R13139 n1_M2_89700_103740 n1_M2_90780_103740 0.988200
R13140 n1_M2_90780_103740 n1_M2_91860_103740 0.988200
R13141 n1_M2_91860_103740 n1_M2_92940_103740 0.988200
R13142 n1_M2_92940_103740 n1_M2_94020_103740 0.988200
R13143 n1_M2_94020_103740 n1_M2_95100_103740 0.988200
R13144 n1_M2_95100_103740 n1_M2_96180_103740 0.988200
R13145 n1_M2_96180_103740 n1_M2_97260_103740 0.988200
R13146 n1_M2_97260_103740 n1_M2_98340_103740 0.988200
R13147 n1_M2_98340_103740 n1_M2_99420_103740 0.988200
R13148 n1_M2_99420_103740 n1_M2_100500_103740 0.988200
R13149 n1_M2_100500_103740 n1_M2_101580_103740 0.988200
R13150 n1_M2_101580_103740 n1_M2_102660_103740 0.988200
R13151 n1_M2_102660_103740 n1_M2_103740_103740 0.988200
R13152 n1_M2_103740_103740 n1_M2_104820_103740 0.988200
R13153 n1_M2_104820_103740 n1_M2_105900_103740 0.988200
R13154 n1_M2_105900_103740 n1_M2_106980_103740 0.988200
R13155 n1_M2_106980_103740 n1_M2_108060_103740 0.988200
R13156 n1_M2_108060_103740 n1_M2_109140_103740 0.988200
R13157 n1_M2_109140_103740 n1_M2_110220_103740 0.988200
R13158 n1_M2_110220_103740 n1_M2_111300_103740 0.988200
R13159 n1_M2_111300_103740 n1_M2_112380_103740 0.988200
R13160 n1_M2_112380_103740 n1_M2_113460_103740 0.988200
R13161 n1_M2_113460_103740 n1_M2_114540_103740 0.988200
R13162 n1_M2_114540_103740 n1_M2_115620_103740 0.988200
R13163 n1_M2_115620_103740 n1_M2_116700_103740 0.988200
R13164 n1_M2_116700_103740 n1_M2_117780_103740 0.988200
R13165 n1_M2_117780_103740 n1_M2_118860_103740 0.988200
R13166 n1_M2_118860_103740 n1_M2_119940_103740 0.988200
R13167 n1_M2_119940_103740 n1_M2_121020_103740 0.988200
R13168 n1_M2_121020_103740 n1_M2_122100_103740 0.988200
R13169 n1_M2_122100_103740 n1_M2_123180_103740 0.988200
R13170 n1_M2_123180_103740 n1_M2_124260_103740 0.988200
R13171 n1_M2_124260_103740 n1_M2_125340_103740 0.988200
R13172 n1_M2_125340_103740 n1_M2_126420_103740 0.988200
R13173 n1_M2_126420_103740 n1_M2_127500_103740 0.988200
R13174 n1_M2_127500_103740 n1_M2_128580_103740 0.988200
R13175 n1_M2_128580_103740 n1_M2_129660_103740 0.988200
R13176 n1_M2_129660_103740 n1_M2_130740_103740 0.988200
R13177 n1_M2_130740_103740 n1_M2_131820_103740 0.988200
R13178 n1_M2_131820_103740 n1_M2_132900_103740 0.988200
R13179 n1_M2_132900_103740 n1_M2_133980_103740 0.988200
R13180 n1_M2_133980_103740 n1_M2_135060_103740 0.988200
R13181 n1_M2_135060_103740 n1_M2_136140_103740 0.988200
R13182 n1_M2_136140_103740 n1_M2_137220_103740 0.988200
R13183 n1_M2_137220_103740 n1_M2_138300_103740 0.988200
R13184 n1_M2_138300_103740 n1_M2_139380_103740 0.988200
R13185 n1_M2_139380_103740 n1_M2_140460_103740 0.988200
R13186 n1_M2_140460_103740 n1_M2_141540_103740 0.988200
R13187 n1_M2_141540_103740 n1_M2_142620_103740 0.988200
R13188 n1_M2_142620_103740 n1_M2_143700_103740 0.988200
R13189 n1_M2_143700_103740 n1_M2_144780_103740 0.988200
R13190 n1_M2_144780_103740 n1_M2_145860_103740 0.988200
R13191 n1_M2_145860_103740 n1_M2_146940_103740 0.988200
R13192 n1_M2_60_104820 n1_M2_1140_104820 0.988200
R13193 n1_M2_1140_104820 n1_M2_2220_104820 0.988200
R13194 n1_M2_2220_104820 n1_M2_3300_104820 0.988200
R13195 n1_M2_3300_104820 n1_M2_4380_104820 0.988200
R13196 n1_M2_4380_104820 n1_M2_5460_104820 0.988200
R13197 n1_M2_5460_104820 n1_M2_6540_104820 0.988200
R13198 n1_M2_6540_104820 n1_M2_7620_104820 0.988200
R13199 n1_M2_7620_104820 n1_M2_8700_104820 0.988200
R13200 n1_M2_8700_104820 n1_M2_9780_104820 0.988200
R13201 n1_M2_9780_104820 n1_M2_10860_104820 0.988200
R13202 n1_M2_10860_104820 n1_M2_11940_104820 0.988200
R13203 n1_M2_11940_104820 n1_M2_13020_104820 0.988200
R13204 n1_M2_13020_104820 n1_M2_14100_104820 0.988200
R13205 n1_M2_14100_104820 n1_M2_15180_104820 0.988200
R13206 n1_M2_15180_104820 n1_M2_16260_104820 0.988200
R13207 n1_M2_16260_104820 n1_M2_17340_104820 0.988200
R13208 n1_M2_17340_104820 n1_M2_18420_104820 0.988200
R13209 n1_M2_18420_104820 n1_M2_19500_104820 0.988200
R13210 n1_M2_19500_104820 n1_M2_20580_104820 0.988200
R13211 n1_M2_20580_104820 n1_M2_21660_104820 0.988200
R13212 n1_M2_21660_104820 n1_M2_22740_104820 0.988200
R13213 n1_M2_22740_104820 n1_M2_23820_104820 0.988200
R13214 n1_M2_23820_104820 n1_M2_24900_104820 0.988200
R13215 n1_M2_24900_104820 n1_M2_25980_104820 0.988200
R13216 n1_M2_25980_104820 n1_M2_27060_104820 0.988200
R13217 n1_M2_27060_104820 n1_M2_28140_104820 0.988200
R13218 n1_M2_28140_104820 n1_M2_29220_104820 0.988200
R13219 n1_M2_29220_104820 n1_M2_30300_104820 0.988200
R13220 n1_M2_30300_104820 n1_M2_31380_104820 0.988200
R13221 n1_M2_31380_104820 n1_M2_32460_104820 0.988200
R13222 n1_M2_32460_104820 n1_M2_33540_104820 0.988200
R13223 n1_M2_33540_104820 n1_M2_34620_104820 0.988200
R13224 n1_M2_34620_104820 n1_M2_35700_104820 0.988200
R13225 n1_M2_35700_104820 n1_M2_36780_104820 0.988200
R13226 n1_M2_36780_104820 n1_M2_37860_104820 0.988200
R13227 n1_M2_37860_104820 n1_M2_38940_104820 0.988200
R13228 n1_M2_38940_104820 n1_M2_40020_104820 0.988200
R13229 n1_M2_40020_104820 n1_M2_41100_104820 0.988200
R13230 n1_M2_41100_104820 n1_M2_42180_104820 0.988200
R13231 n1_M2_42180_104820 n1_M2_43260_104820 0.988200
R13232 n1_M2_43260_104820 n1_M2_44340_104820 0.988200
R13233 n1_M2_44340_104820 n1_M2_45420_104820 0.988200
R13234 n1_M2_45420_104820 n1_M2_46500_104820 0.988200
R13235 n1_M2_46500_104820 n1_M2_47580_104820 0.988200
R13236 n1_M2_47580_104820 n1_M2_48660_104820 0.988200
R13237 n1_M2_48660_104820 n1_M2_49740_104820 0.988200
R13238 n1_M2_49740_104820 n1_M2_50820_104820 0.988200
R13239 n1_M2_50820_104820 n1_M2_51900_104820 0.988200
R13240 n1_M2_51900_104820 n1_M2_52980_104820 0.988200
R13241 n1_M2_52980_104820 n1_M2_54060_104820 0.988200
R13242 n1_M2_54060_104820 n1_M2_55140_104820 0.988200
R13243 n1_M2_55140_104820 n1_M2_56220_104820 0.988200
R13244 n1_M2_56220_104820 n1_M2_57300_104820 0.988200
R13245 n1_M2_57300_104820 n1_M2_58380_104820 0.988200
R13246 n1_M2_58380_104820 n1_M2_59460_104820 0.988200
R13247 n1_M2_59460_104820 n1_M2_60540_104820 0.988200
R13248 n1_M2_60540_104820 n1_M2_61620_104820 0.988200
R13249 n1_M2_61620_104820 n1_M2_62700_104820 0.988200
R13250 n1_M2_62700_104820 n1_M2_63780_104820 0.988200
R13251 n1_M2_63780_104820 n1_M2_64860_104820 0.988200
R13252 n1_M2_64860_104820 n1_M2_65940_104820 0.988200
R13253 n1_M2_65940_104820 n1_M2_67020_104820 0.988200
R13254 n1_M2_67020_104820 n1_M2_68100_104820 0.988200
R13255 n1_M2_68100_104820 n1_M2_69180_104820 0.988200
R13256 n1_M2_69180_104820 n1_M2_70260_104820 0.988200
R13257 n1_M2_70260_104820 n1_M2_71340_104820 0.988200
R13258 n1_M2_71340_104820 n1_M2_72420_104820 0.988200
R13259 n1_M2_72420_104820 n1_M2_73500_104820 0.988200
R13260 n1_M2_73500_104820 n1_M2_74580_104820 0.988200
R13261 n1_M2_74580_104820 n1_M2_75660_104820 0.988200
R13262 n1_M2_75660_104820 n1_M2_76740_104820 0.988200
R13263 n1_M2_76740_104820 n1_M2_77820_104820 0.988200
R13264 n1_M2_77820_104820 n1_M2_78900_104820 0.988200
R13265 n1_M2_78900_104820 n1_M2_79980_104820 0.988200
R13266 n1_M2_79980_104820 n1_M2_81060_104820 0.988200
R13267 n1_M2_81060_104820 n1_M2_82140_104820 0.988200
R13268 n1_M2_82140_104820 n1_M2_83220_104820 0.988200
R13269 n1_M2_83220_104820 n1_M2_84300_104820 0.988200
R13270 n1_M2_84300_104820 n1_M2_85380_104820 0.988200
R13271 n1_M2_85380_104820 n1_M2_86460_104820 0.988200
R13272 n1_M2_86460_104820 n1_M2_87540_104820 0.988200
R13273 n1_M2_87540_104820 n1_M2_88620_104820 0.988200
R13274 n1_M2_88620_104820 n1_M2_89700_104820 0.988200
R13275 n1_M2_89700_104820 n1_M2_90780_104820 0.988200
R13276 n1_M2_90780_104820 n1_M2_91860_104820 0.988200
R13277 n1_M2_91860_104820 n1_M2_92940_104820 0.988200
R13278 n1_M2_92940_104820 n1_M2_94020_104820 0.988200
R13279 n1_M2_94020_104820 n1_M2_95100_104820 0.988200
R13280 n1_M2_95100_104820 n1_M2_96180_104820 0.988200
R13281 n1_M2_96180_104820 n1_M2_97260_104820 0.988200
R13282 n1_M2_97260_104820 n1_M2_98340_104820 0.988200
R13283 n1_M2_98340_104820 n1_M2_99420_104820 0.988200
R13284 n1_M2_99420_104820 n1_M2_100500_104820 0.988200
R13285 n1_M2_100500_104820 n1_M2_101580_104820 0.988200
R13286 n1_M2_101580_104820 n1_M2_102660_104820 0.988200
R13287 n1_M2_102660_104820 n1_M2_103740_104820 0.988200
R13288 n1_M2_103740_104820 n1_M2_104820_104820 0.988200
R13289 n1_M2_104820_104820 n1_M2_105900_104820 0.988200
R13290 n1_M2_105900_104820 n1_M2_106980_104820 0.988200
R13291 n1_M2_106980_104820 n1_M2_108060_104820 0.988200
R13292 n1_M2_108060_104820 n1_M2_109140_104820 0.988200
R13293 n1_M2_109140_104820 n1_M2_110220_104820 0.988200
R13294 n1_M2_110220_104820 n1_M2_111300_104820 0.988200
R13295 n1_M2_111300_104820 n1_M2_112380_104820 0.988200
R13296 n1_M2_112380_104820 n1_M2_113460_104820 0.988200
R13297 n1_M2_113460_104820 n1_M2_114540_104820 0.988200
R13298 n1_M2_114540_104820 n1_M2_115620_104820 0.988200
R13299 n1_M2_115620_104820 n1_M2_116700_104820 0.988200
R13300 n1_M2_116700_104820 n1_M2_117780_104820 0.988200
R13301 n1_M2_117780_104820 n1_M2_118860_104820 0.988200
R13302 n1_M2_118860_104820 n1_M2_119940_104820 0.988200
R13303 n1_M2_119940_104820 n1_M2_121020_104820 0.988200
R13304 n1_M2_121020_104820 n1_M2_122100_104820 0.988200
R13305 n1_M2_122100_104820 n1_M2_123180_104820 0.988200
R13306 n1_M2_123180_104820 n1_M2_124260_104820 0.988200
R13307 n1_M2_124260_104820 n1_M2_125340_104820 0.988200
R13308 n1_M2_125340_104820 n1_M2_126420_104820 0.988200
R13309 n1_M2_126420_104820 n1_M2_127500_104820 0.988200
R13310 n1_M2_127500_104820 n1_M2_128580_104820 0.988200
R13311 n1_M2_128580_104820 n1_M2_129660_104820 0.988200
R13312 n1_M2_129660_104820 n1_M2_130740_104820 0.988200
R13313 n1_M2_130740_104820 n1_M2_131820_104820 0.988200
R13314 n1_M2_131820_104820 n1_M2_132900_104820 0.988200
R13315 n1_M2_132900_104820 n1_M2_133980_104820 0.988200
R13316 n1_M2_133980_104820 n1_M2_135060_104820 0.988200
R13317 n1_M2_135060_104820 n1_M2_136140_104820 0.988200
R13318 n1_M2_136140_104820 n1_M2_137220_104820 0.988200
R13319 n1_M2_137220_104820 n1_M2_138300_104820 0.988200
R13320 n1_M2_138300_104820 n1_M2_139380_104820 0.988200
R13321 n1_M2_139380_104820 n1_M2_140460_104820 0.988200
R13322 n1_M2_140460_104820 n1_M2_141540_104820 0.988200
R13323 n1_M2_141540_104820 n1_M2_142620_104820 0.988200
R13324 n1_M2_142620_104820 n1_M2_143700_104820 0.988200
R13325 n1_M2_143700_104820 n1_M2_144780_104820 0.988200
R13326 n1_M2_144780_104820 n1_M2_145860_104820 0.988200
R13327 n1_M2_145860_104820 n1_M2_146940_104820 0.988200
R13328 n1_M2_60_105900 n1_M2_1140_105900 0.988200
R13329 n1_M2_1140_105900 n1_M2_2220_105900 0.988200
R13330 n1_M2_2220_105900 n1_M2_3300_105900 0.988200
R13331 n1_M2_3300_105900 n1_M2_4380_105900 0.988200
R13332 n1_M2_4380_105900 n1_M2_5460_105900 0.988200
R13333 n1_M2_5460_105900 n1_M2_6540_105900 0.988200
R13334 n1_M2_6540_105900 n1_M2_7620_105900 0.988200
R13335 n1_M2_7620_105900 n1_M2_8700_105900 0.988200
R13336 n1_M2_8700_105900 n1_M2_9780_105900 0.988200
R13337 n1_M2_9780_105900 n1_M2_10860_105900 0.988200
R13338 n1_M2_10860_105900 n1_M2_11940_105900 0.988200
R13339 n1_M2_11940_105900 n1_M2_13020_105900 0.988200
R13340 n1_M2_13020_105900 n1_M2_14100_105900 0.988200
R13341 n1_M2_14100_105900 n1_M2_15180_105900 0.988200
R13342 n1_M2_15180_105900 n1_M2_16260_105900 0.988200
R13343 n1_M2_16260_105900 n1_M2_17340_105900 0.988200
R13344 n1_M2_17340_105900 n1_M2_18420_105900 0.988200
R13345 n1_M2_18420_105900 n1_M2_19500_105900 0.988200
R13346 n1_M2_19500_105900 n1_M2_20580_105900 0.988200
R13347 n1_M2_20580_105900 n1_M2_21660_105900 0.988200
R13348 n1_M2_21660_105900 n1_M2_22740_105900 0.988200
R13349 n1_M2_22740_105900 n1_M2_23820_105900 0.988200
R13350 n1_M2_23820_105900 n1_M2_24900_105900 0.988200
R13351 n1_M2_24900_105900 n1_M2_25980_105900 0.988200
R13352 n1_M2_25980_105900 n1_M2_27060_105900 0.988200
R13353 n1_M2_27060_105900 n1_M2_28140_105900 0.988200
R13354 n1_M2_28140_105900 n1_M2_29220_105900 0.988200
R13355 n1_M2_29220_105900 n1_M2_30300_105900 0.988200
R13356 n1_M2_30300_105900 n1_M2_31380_105900 0.988200
R13357 n1_M2_31380_105900 n1_M2_32460_105900 0.988200
R13358 n1_M2_32460_105900 n1_M2_33540_105900 0.988200
R13359 n1_M2_33540_105900 n1_M2_34620_105900 0.988200
R13360 n1_M2_34620_105900 n1_M2_35700_105900 0.988200
R13361 n1_M2_35700_105900 n1_M2_36780_105900 0.988200
R13362 n1_M2_36780_105900 n1_M2_37860_105900 0.988200
R13363 n1_M2_37860_105900 n1_M2_38940_105900 0.988200
R13364 n1_M2_38940_105900 n1_M2_40020_105900 0.988200
R13365 n1_M2_40020_105900 n1_M2_41100_105900 0.988200
R13366 n1_M2_41100_105900 n1_M2_42180_105900 0.988200
R13367 n1_M2_42180_105900 n1_M2_43260_105900 0.988200
R13368 n1_M2_43260_105900 n1_M2_44340_105900 0.988200
R13369 n1_M2_44340_105900 n1_M2_45420_105900 0.988200
R13370 n1_M2_45420_105900 n1_M2_46500_105900 0.988200
R13371 n1_M2_46500_105900 n1_M2_47580_105900 0.988200
R13372 n1_M2_47580_105900 n1_M2_48660_105900 0.988200
R13373 n1_M2_48660_105900 n1_M2_49740_105900 0.988200
R13374 n1_M2_49740_105900 n1_M2_50820_105900 0.988200
R13375 n1_M2_50820_105900 n1_M2_51900_105900 0.988200
R13376 n1_M2_51900_105900 n1_M2_52980_105900 0.988200
R13377 n1_M2_52980_105900 n1_M2_54060_105900 0.988200
R13378 n1_M2_54060_105900 n1_M2_55140_105900 0.988200
R13379 n1_M2_55140_105900 n1_M2_56220_105900 0.988200
R13380 n1_M2_56220_105900 n1_M2_57300_105900 0.988200
R13381 n1_M2_57300_105900 n1_M2_58380_105900 0.988200
R13382 n1_M2_58380_105900 n1_M2_59460_105900 0.988200
R13383 n1_M2_59460_105900 n1_M2_60540_105900 0.988200
R13384 n1_M2_60540_105900 n1_M2_61620_105900 0.988200
R13385 n1_M2_61620_105900 n1_M2_62700_105900 0.988200
R13386 n1_M2_62700_105900 n1_M2_63780_105900 0.988200
R13387 n1_M2_63780_105900 n1_M2_64860_105900 0.988200
R13388 n1_M2_64860_105900 n1_M2_65940_105900 0.988200
R13389 n1_M2_65940_105900 n1_M2_67020_105900 0.988200
R13390 n1_M2_67020_105900 n1_M2_68100_105900 0.988200
R13391 n1_M2_68100_105900 n1_M2_69180_105900 0.988200
R13392 n1_M2_69180_105900 n1_M2_70260_105900 0.988200
R13393 n1_M2_70260_105900 n1_M2_71340_105900 0.988200
R13394 n1_M2_71340_105900 n1_M2_72420_105900 0.988200
R13395 n1_M2_72420_105900 n1_M2_73500_105900 0.988200
R13396 n1_M2_73500_105900 n1_M2_74580_105900 0.988200
R13397 n1_M2_74580_105900 n1_M2_75660_105900 0.988200
R13398 n1_M2_75660_105900 n1_M2_76740_105900 0.988200
R13399 n1_M2_76740_105900 n1_M2_77820_105900 0.988200
R13400 n1_M2_77820_105900 n1_M2_78900_105900 0.988200
R13401 n1_M2_78900_105900 n1_M2_79980_105900 0.988200
R13402 n1_M2_79980_105900 n1_M2_81060_105900 0.988200
R13403 n1_M2_81060_105900 n1_M2_82140_105900 0.988200
R13404 n1_M2_82140_105900 n1_M2_83220_105900 0.988200
R13405 n1_M2_83220_105900 n1_M2_84300_105900 0.988200
R13406 n1_M2_84300_105900 n1_M2_85380_105900 0.988200
R13407 n1_M2_85380_105900 n1_M2_86460_105900 0.988200
R13408 n1_M2_86460_105900 n1_M2_87540_105900 0.988200
R13409 n1_M2_87540_105900 n1_M2_88620_105900 0.988200
R13410 n1_M2_88620_105900 n1_M2_89700_105900 0.988200
R13411 n1_M2_89700_105900 n1_M2_90780_105900 0.988200
R13412 n1_M2_90780_105900 n1_M2_91860_105900 0.988200
R13413 n1_M2_91860_105900 n1_M2_92940_105900 0.988200
R13414 n1_M2_92940_105900 n1_M2_94020_105900 0.988200
R13415 n1_M2_94020_105900 n1_M2_95100_105900 0.988200
R13416 n1_M2_95100_105900 n1_M2_96180_105900 0.988200
R13417 n1_M2_96180_105900 n1_M2_97260_105900 0.988200
R13418 n1_M2_97260_105900 n1_M2_98340_105900 0.988200
R13419 n1_M2_98340_105900 n1_M2_99420_105900 0.988200
R13420 n1_M2_99420_105900 n1_M2_100500_105900 0.988200
R13421 n1_M2_100500_105900 n1_M2_101580_105900 0.988200
R13422 n1_M2_101580_105900 n1_M2_102660_105900 0.988200
R13423 n1_M2_102660_105900 n1_M2_103740_105900 0.988200
R13424 n1_M2_103740_105900 n1_M2_104820_105900 0.988200
R13425 n1_M2_104820_105900 n1_M2_105900_105900 0.988200
R13426 n1_M2_105900_105900 n1_M2_106980_105900 0.988200
R13427 n1_M2_106980_105900 n1_M2_108060_105900 0.988200
R13428 n1_M2_108060_105900 n1_M2_109140_105900 0.988200
R13429 n1_M2_109140_105900 n1_M2_110220_105900 0.988200
R13430 n1_M2_110220_105900 n1_M2_111300_105900 0.988200
R13431 n1_M2_111300_105900 n1_M2_112380_105900 0.988200
R13432 n1_M2_112380_105900 n1_M2_113460_105900 0.988200
R13433 n1_M2_113460_105900 n1_M2_114540_105900 0.988200
R13434 n1_M2_114540_105900 n1_M2_115620_105900 0.988200
R13435 n1_M2_115620_105900 n1_M2_116700_105900 0.988200
R13436 n1_M2_116700_105900 n1_M2_117780_105900 0.988200
R13437 n1_M2_117780_105900 n1_M2_118860_105900 0.988200
R13438 n1_M2_118860_105900 n1_M2_119940_105900 0.988200
R13439 n1_M2_119940_105900 n1_M2_121020_105900 0.988200
R13440 n1_M2_121020_105900 n1_M2_122100_105900 0.988200
R13441 n1_M2_122100_105900 n1_M2_123180_105900 0.988200
R13442 n1_M2_123180_105900 n1_M2_124260_105900 0.988200
R13443 n1_M2_124260_105900 n1_M2_125340_105900 0.988200
R13444 n1_M2_125340_105900 n1_M2_126420_105900 0.988200
R13445 n1_M2_126420_105900 n1_M2_127500_105900 0.988200
R13446 n1_M2_127500_105900 n1_M2_128580_105900 0.988200
R13447 n1_M2_128580_105900 n1_M2_129660_105900 0.988200
R13448 n1_M2_129660_105900 n1_M2_130740_105900 0.988200
R13449 n1_M2_130740_105900 n1_M2_131820_105900 0.988200
R13450 n1_M2_131820_105900 n1_M2_132900_105900 0.988200
R13451 n1_M2_132900_105900 n1_M2_133980_105900 0.988200
R13452 n1_M2_133980_105900 n1_M2_135060_105900 0.988200
R13453 n1_M2_135060_105900 n1_M2_136140_105900 0.988200
R13454 n1_M2_136140_105900 n1_M2_137220_105900 0.988200
R13455 n1_M2_137220_105900 n1_M2_138300_105900 0.988200
R13456 n1_M2_138300_105900 n1_M2_139380_105900 0.988200
R13457 n1_M2_139380_105900 n1_M2_140460_105900 0.988200
R13458 n1_M2_140460_105900 n1_M2_141540_105900 0.988200
R13459 n1_M2_141540_105900 n1_M2_142620_105900 0.988200
R13460 n1_M2_142620_105900 n1_M2_143700_105900 0.988200
R13461 n1_M2_143700_105900 n1_M2_144780_105900 0.988200
R13462 n1_M2_144780_105900 n1_M2_145860_105900 0.988200
R13463 n1_M2_145860_105900 n1_M2_146940_105900 0.988200
R13464 n1_M2_60_106980 n1_M2_1140_106980 0.988200
R13465 n1_M2_1140_106980 n1_M2_2220_106980 0.988200
R13466 n1_M2_2220_106980 n1_M2_3300_106980 0.988200
R13467 n1_M2_3300_106980 n1_M2_4380_106980 0.988200
R13468 n1_M2_4380_106980 n1_M2_5460_106980 0.988200
R13469 n1_M2_5460_106980 n1_M2_6540_106980 0.988200
R13470 n1_M2_6540_106980 n1_M2_7620_106980 0.988200
R13471 n1_M2_7620_106980 n1_M2_8700_106980 0.988200
R13472 n1_M2_8700_106980 n1_M2_9780_106980 0.988200
R13473 n1_M2_9780_106980 n1_M2_10860_106980 0.988200
R13474 n1_M2_10860_106980 n1_M2_11940_106980 0.988200
R13475 n1_M2_11940_106980 n1_M2_13020_106980 0.988200
R13476 n1_M2_13020_106980 n1_M2_14100_106980 0.988200
R13477 n1_M2_14100_106980 n1_M2_15180_106980 0.988200
R13478 n1_M2_15180_106980 n1_M2_16260_106980 0.988200
R13479 n1_M2_16260_106980 n1_M2_17340_106980 0.988200
R13480 n1_M2_17340_106980 n1_M2_18420_106980 0.988200
R13481 n1_M2_18420_106980 n1_M2_19500_106980 0.988200
R13482 n1_M2_19500_106980 n1_M2_20580_106980 0.988200
R13483 n1_M2_20580_106980 n1_M2_21660_106980 0.988200
R13484 n1_M2_21660_106980 n1_M2_22740_106980 0.988200
R13485 n1_M2_22740_106980 n1_M2_23820_106980 0.988200
R13486 n1_M2_23820_106980 n1_M2_24900_106980 0.988200
R13487 n1_M2_24900_106980 n1_M2_25980_106980 0.988200
R13488 n1_M2_25980_106980 n1_M2_27060_106980 0.988200
R13489 n1_M2_27060_106980 n1_M2_28140_106980 0.988200
R13490 n1_M2_28140_106980 n1_M2_29220_106980 0.988200
R13491 n1_M2_29220_106980 n1_M2_30300_106980 0.988200
R13492 n1_M2_30300_106980 n1_M2_31380_106980 0.988200
R13493 n1_M2_31380_106980 n1_M2_32460_106980 0.988200
R13494 n1_M2_32460_106980 n1_M2_33540_106980 0.988200
R13495 n1_M2_33540_106980 n1_M2_34620_106980 0.988200
R13496 n1_M2_34620_106980 n1_M2_35700_106980 0.988200
R13497 n1_M2_35700_106980 n1_M2_36780_106980 0.988200
R13498 n1_M2_36780_106980 n1_M2_37860_106980 0.988200
R13499 n1_M2_37860_106980 n1_M2_38940_106980 0.988200
R13500 n1_M2_38940_106980 n1_M2_40020_106980 0.988200
R13501 n1_M2_40020_106980 n1_M2_41100_106980 0.988200
R13502 n1_M2_41100_106980 n1_M2_42180_106980 0.988200
R13503 n1_M2_42180_106980 n1_M2_43260_106980 0.988200
R13504 n1_M2_43260_106980 n1_M2_44340_106980 0.988200
R13505 n1_M2_44340_106980 n1_M2_45420_106980 0.988200
R13506 n1_M2_45420_106980 n1_M2_46500_106980 0.988200
R13507 n1_M2_46500_106980 n1_M2_47580_106980 0.988200
R13508 n1_M2_47580_106980 n1_M2_48660_106980 0.988200
R13509 n1_M2_48660_106980 n1_M2_49740_106980 0.988200
R13510 n1_M2_49740_106980 n1_M2_50820_106980 0.988200
R13511 n1_M2_50820_106980 n1_M2_51900_106980 0.988200
R13512 n1_M2_51900_106980 n1_M2_52980_106980 0.988200
R13513 n1_M2_52980_106980 n1_M2_54060_106980 0.988200
R13514 n1_M2_54060_106980 n1_M2_55140_106980 0.988200
R13515 n1_M2_55140_106980 n1_M2_56220_106980 0.988200
R13516 n1_M2_56220_106980 n1_M2_57300_106980 0.988200
R13517 n1_M2_57300_106980 n1_M2_58380_106980 0.988200
R13518 n1_M2_58380_106980 n1_M2_59460_106980 0.988200
R13519 n1_M2_59460_106980 n1_M2_60540_106980 0.988200
R13520 n1_M2_60540_106980 n1_M2_61620_106980 0.988200
R13521 n1_M2_61620_106980 n1_M2_62700_106980 0.988200
R13522 n1_M2_62700_106980 n1_M2_63780_106980 0.988200
R13523 n1_M2_63780_106980 n1_M2_64860_106980 0.988200
R13524 n1_M2_64860_106980 n1_M2_65940_106980 0.988200
R13525 n1_M2_65940_106980 n1_M2_67020_106980 0.988200
R13526 n1_M2_67020_106980 n1_M2_68100_106980 0.988200
R13527 n1_M2_68100_106980 n1_M2_69180_106980 0.988200
R13528 n1_M2_69180_106980 n1_M2_70260_106980 0.988200
R13529 n1_M2_70260_106980 n1_M2_71340_106980 0.988200
R13530 n1_M2_71340_106980 n1_M2_72420_106980 0.988200
R13531 n1_M2_72420_106980 n1_M2_73500_106980 0.988200
R13532 n1_M2_73500_106980 n1_M2_74580_106980 0.988200
R13533 n1_M2_74580_106980 n1_M2_75660_106980 0.988200
R13534 n1_M2_75660_106980 n1_M2_76740_106980 0.988200
R13535 n1_M2_76740_106980 n1_M2_77820_106980 0.988200
R13536 n1_M2_77820_106980 n1_M2_78900_106980 0.988200
R13537 n1_M2_78900_106980 n1_M2_79980_106980 0.988200
R13538 n1_M2_79980_106980 n1_M2_81060_106980 0.988200
R13539 n1_M2_81060_106980 n1_M2_82140_106980 0.988200
R13540 n1_M2_82140_106980 n1_M2_83220_106980 0.988200
R13541 n1_M2_83220_106980 n1_M2_84300_106980 0.988200
R13542 n1_M2_84300_106980 n1_M2_85380_106980 0.988200
R13543 n1_M2_85380_106980 n1_M2_86460_106980 0.988200
R13544 n1_M2_86460_106980 n1_M2_87540_106980 0.988200
R13545 n1_M2_87540_106980 n1_M2_88620_106980 0.988200
R13546 n1_M2_88620_106980 n1_M2_89700_106980 0.988200
R13547 n1_M2_89700_106980 n1_M2_90780_106980 0.988200
R13548 n1_M2_90780_106980 n1_M2_91860_106980 0.988200
R13549 n1_M2_91860_106980 n1_M2_92940_106980 0.988200
R13550 n1_M2_92940_106980 n1_M2_94020_106980 0.988200
R13551 n1_M2_94020_106980 n1_M2_95100_106980 0.988200
R13552 n1_M2_95100_106980 n1_M2_96180_106980 0.988200
R13553 n1_M2_96180_106980 n1_M2_97260_106980 0.988200
R13554 n1_M2_97260_106980 n1_M2_98340_106980 0.988200
R13555 n1_M2_98340_106980 n1_M2_99420_106980 0.988200
R13556 n1_M2_99420_106980 n1_M2_100500_106980 0.988200
R13557 n1_M2_100500_106980 n1_M2_101580_106980 0.988200
R13558 n1_M2_101580_106980 n1_M2_102660_106980 0.988200
R13559 n1_M2_102660_106980 n1_M2_103740_106980 0.988200
R13560 n1_M2_103740_106980 n1_M2_104820_106980 0.988200
R13561 n1_M2_104820_106980 n1_M2_105900_106980 0.988200
R13562 n1_M2_105900_106980 n1_M2_106980_106980 0.988200
R13563 n1_M2_106980_106980 n1_M2_108060_106980 0.988200
R13564 n1_M2_108060_106980 n1_M2_109140_106980 0.988200
R13565 n1_M2_109140_106980 n1_M2_110220_106980 0.988200
R13566 n1_M2_110220_106980 n1_M2_111300_106980 0.988200
R13567 n1_M2_111300_106980 n1_M2_112380_106980 0.988200
R13568 n1_M2_112380_106980 n1_M2_113460_106980 0.988200
R13569 n1_M2_113460_106980 n1_M2_114540_106980 0.988200
R13570 n1_M2_114540_106980 n1_M2_115620_106980 0.988200
R13571 n1_M2_115620_106980 n1_M2_116700_106980 0.988200
R13572 n1_M2_116700_106980 n1_M2_117780_106980 0.988200
R13573 n1_M2_117780_106980 n1_M2_118860_106980 0.988200
R13574 n1_M2_118860_106980 n1_M2_119940_106980 0.988200
R13575 n1_M2_119940_106980 n1_M2_121020_106980 0.988200
R13576 n1_M2_121020_106980 n1_M2_122100_106980 0.988200
R13577 n1_M2_122100_106980 n1_M2_123180_106980 0.988200
R13578 n1_M2_123180_106980 n1_M2_124260_106980 0.988200
R13579 n1_M2_124260_106980 n1_M2_125340_106980 0.988200
R13580 n1_M2_125340_106980 n1_M2_126420_106980 0.988200
R13581 n1_M2_126420_106980 n1_M2_127500_106980 0.988200
R13582 n1_M2_127500_106980 n1_M2_128580_106980 0.988200
R13583 n1_M2_128580_106980 n1_M2_129660_106980 0.988200
R13584 n1_M2_129660_106980 n1_M2_130740_106980 0.988200
R13585 n1_M2_130740_106980 n1_M2_131820_106980 0.988200
R13586 n1_M2_131820_106980 n1_M2_132900_106980 0.988200
R13587 n1_M2_132900_106980 n1_M2_133980_106980 0.988200
R13588 n1_M2_133980_106980 n1_M2_135060_106980 0.988200
R13589 n1_M2_135060_106980 n1_M2_136140_106980 0.988200
R13590 n1_M2_136140_106980 n1_M2_137220_106980 0.988200
R13591 n1_M2_137220_106980 n1_M2_138300_106980 0.988200
R13592 n1_M2_138300_106980 n1_M2_139380_106980 0.988200
R13593 n1_M2_139380_106980 n1_M2_140460_106980 0.988200
R13594 n1_M2_140460_106980 n1_M2_141540_106980 0.988200
R13595 n1_M2_141540_106980 n1_M2_142620_106980 0.988200
R13596 n1_M2_142620_106980 n1_M2_143700_106980 0.988200
R13597 n1_M2_143700_106980 n1_M2_144780_106980 0.988200
R13598 n1_M2_144780_106980 n1_M2_145860_106980 0.988200
R13599 n1_M2_145860_106980 n1_M2_146940_106980 0.988200
R13600 n1_M2_60_108060 n1_M2_1140_108060 0.988200
R13601 n1_M2_1140_108060 n1_M2_2220_108060 0.988200
R13602 n1_M2_2220_108060 n1_M2_3300_108060 0.988200
R13603 n1_M2_3300_108060 n1_M2_4380_108060 0.988200
R13604 n1_M2_4380_108060 n1_M2_5460_108060 0.988200
R13605 n1_M2_5460_108060 n1_M2_6540_108060 0.988200
R13606 n1_M2_6540_108060 n1_M2_7620_108060 0.988200
R13607 n1_M2_7620_108060 n1_M2_8700_108060 0.988200
R13608 n1_M2_8700_108060 n1_M2_9780_108060 0.988200
R13609 n1_M2_9780_108060 n1_M2_10860_108060 0.988200
R13610 n1_M2_10860_108060 n1_M2_11940_108060 0.988200
R13611 n1_M2_11940_108060 n1_M2_13020_108060 0.988200
R13612 n1_M2_13020_108060 n1_M2_14100_108060 0.988200
R13613 n1_M2_14100_108060 n1_M2_15180_108060 0.988200
R13614 n1_M2_15180_108060 n1_M2_16260_108060 0.988200
R13615 n1_M2_16260_108060 n1_M2_17340_108060 0.988200
R13616 n1_M2_17340_108060 n1_M2_18420_108060 0.988200
R13617 n1_M2_18420_108060 n1_M2_19500_108060 0.988200
R13618 n1_M2_19500_108060 n1_M2_20580_108060 0.988200
R13619 n1_M2_20580_108060 n1_M2_21660_108060 0.988200
R13620 n1_M2_21660_108060 n1_M2_22740_108060 0.988200
R13621 n1_M2_22740_108060 n1_M2_23820_108060 0.988200
R13622 n1_M2_23820_108060 n1_M2_24900_108060 0.988200
R13623 n1_M2_24900_108060 n1_M2_25980_108060 0.988200
R13624 n1_M2_25980_108060 n1_M2_27060_108060 0.988200
R13625 n1_M2_27060_108060 n1_M2_28140_108060 0.988200
R13626 n1_M2_28140_108060 n1_M2_29220_108060 0.988200
R13627 n1_M2_29220_108060 n1_M2_30300_108060 0.988200
R13628 n1_M2_30300_108060 n1_M2_31380_108060 0.988200
R13629 n1_M2_31380_108060 n1_M2_32460_108060 0.988200
R13630 n1_M2_32460_108060 n1_M2_33540_108060 0.988200
R13631 n1_M2_33540_108060 n1_M2_34620_108060 0.988200
R13632 n1_M2_34620_108060 n1_M2_35700_108060 0.988200
R13633 n1_M2_35700_108060 n1_M2_36780_108060 0.988200
R13634 n1_M2_36780_108060 n1_M2_37860_108060 0.988200
R13635 n1_M2_37860_108060 n1_M2_38940_108060 0.988200
R13636 n1_M2_38940_108060 n1_M2_40020_108060 0.988200
R13637 n1_M2_40020_108060 n1_M2_41100_108060 0.988200
R13638 n1_M2_41100_108060 n1_M2_42180_108060 0.988200
R13639 n1_M2_42180_108060 n1_M2_43260_108060 0.988200
R13640 n1_M2_43260_108060 n1_M2_44340_108060 0.988200
R13641 n1_M2_44340_108060 n1_M2_45420_108060 0.988200
R13642 n1_M2_45420_108060 n1_M2_46500_108060 0.988200
R13643 n1_M2_46500_108060 n1_M2_47580_108060 0.988200
R13644 n1_M2_47580_108060 n1_M2_48660_108060 0.988200
R13645 n1_M2_48660_108060 n1_M2_49740_108060 0.988200
R13646 n1_M2_49740_108060 n1_M2_50820_108060 0.988200
R13647 n1_M2_50820_108060 n1_M2_51900_108060 0.988200
R13648 n1_M2_51900_108060 n1_M2_52980_108060 0.988200
R13649 n1_M2_52980_108060 n1_M2_54060_108060 0.988200
R13650 n1_M2_54060_108060 n1_M2_55140_108060 0.988200
R13651 n1_M2_55140_108060 n1_M2_56220_108060 0.988200
R13652 n1_M2_56220_108060 n1_M2_57300_108060 0.988200
R13653 n1_M2_57300_108060 n1_M2_58380_108060 0.988200
R13654 n1_M2_58380_108060 n1_M2_59460_108060 0.988200
R13655 n1_M2_59460_108060 n1_M2_60540_108060 0.988200
R13656 n1_M2_60540_108060 n1_M2_61620_108060 0.988200
R13657 n1_M2_61620_108060 n1_M2_62700_108060 0.988200
R13658 n1_M2_62700_108060 n1_M2_63780_108060 0.988200
R13659 n1_M2_63780_108060 n1_M2_64860_108060 0.988200
R13660 n1_M2_64860_108060 n1_M2_65940_108060 0.988200
R13661 n1_M2_65940_108060 n1_M2_67020_108060 0.988200
R13662 n1_M2_67020_108060 n1_M2_68100_108060 0.988200
R13663 n1_M2_68100_108060 n1_M2_69180_108060 0.988200
R13664 n1_M2_69180_108060 n1_M2_70260_108060 0.988200
R13665 n1_M2_70260_108060 n1_M2_71340_108060 0.988200
R13666 n1_M2_71340_108060 n1_M2_72420_108060 0.988200
R13667 n1_M2_72420_108060 n1_M2_73500_108060 0.988200
R13668 n1_M2_73500_108060 n1_M2_74580_108060 0.988200
R13669 n1_M2_74580_108060 n1_M2_75660_108060 0.988200
R13670 n1_M2_75660_108060 n1_M2_76740_108060 0.988200
R13671 n1_M2_76740_108060 n1_M2_77820_108060 0.988200
R13672 n1_M2_77820_108060 n1_M2_78900_108060 0.988200
R13673 n1_M2_78900_108060 n1_M2_79980_108060 0.988200
R13674 n1_M2_79980_108060 n1_M2_81060_108060 0.988200
R13675 n1_M2_81060_108060 n1_M2_82140_108060 0.988200
R13676 n1_M2_82140_108060 n1_M2_83220_108060 0.988200
R13677 n1_M2_83220_108060 n1_M2_84300_108060 0.988200
R13678 n1_M2_84300_108060 n1_M2_85380_108060 0.988200
R13679 n1_M2_85380_108060 n1_M2_86460_108060 0.988200
R13680 n1_M2_86460_108060 n1_M2_87540_108060 0.988200
R13681 n1_M2_87540_108060 n1_M2_88620_108060 0.988200
R13682 n1_M2_88620_108060 n1_M2_89700_108060 0.988200
R13683 n1_M2_89700_108060 n1_M2_90780_108060 0.988200
R13684 n1_M2_90780_108060 n1_M2_91860_108060 0.988200
R13685 n1_M2_91860_108060 n1_M2_92940_108060 0.988200
R13686 n1_M2_92940_108060 n1_M2_94020_108060 0.988200
R13687 n1_M2_94020_108060 n1_M2_95100_108060 0.988200
R13688 n1_M2_95100_108060 n1_M2_96180_108060 0.988200
R13689 n1_M2_96180_108060 n1_M2_97260_108060 0.988200
R13690 n1_M2_97260_108060 n1_M2_98340_108060 0.988200
R13691 n1_M2_98340_108060 n1_M2_99420_108060 0.988200
R13692 n1_M2_99420_108060 n1_M2_100500_108060 0.988200
R13693 n1_M2_100500_108060 n1_M2_101580_108060 0.988200
R13694 n1_M2_101580_108060 n1_M2_102660_108060 0.988200
R13695 n1_M2_102660_108060 n1_M2_103740_108060 0.988200
R13696 n1_M2_103740_108060 n1_M2_104820_108060 0.988200
R13697 n1_M2_104820_108060 n1_M2_105900_108060 0.988200
R13698 n1_M2_105900_108060 n1_M2_106980_108060 0.988200
R13699 n1_M2_106980_108060 n1_M2_108060_108060 0.988200
R13700 n1_M2_108060_108060 n1_M2_109140_108060 0.988200
R13701 n1_M2_109140_108060 n1_M2_110220_108060 0.988200
R13702 n1_M2_110220_108060 n1_M2_111300_108060 0.988200
R13703 n1_M2_111300_108060 n1_M2_112380_108060 0.988200
R13704 n1_M2_112380_108060 n1_M2_113460_108060 0.988200
R13705 n1_M2_113460_108060 n1_M2_114540_108060 0.988200
R13706 n1_M2_114540_108060 n1_M2_115620_108060 0.988200
R13707 n1_M2_115620_108060 n1_M2_116700_108060 0.988200
R13708 n1_M2_116700_108060 n1_M2_117780_108060 0.988200
R13709 n1_M2_117780_108060 n1_M2_118860_108060 0.988200
R13710 n1_M2_118860_108060 n1_M2_119940_108060 0.988200
R13711 n1_M2_119940_108060 n1_M2_121020_108060 0.988200
R13712 n1_M2_121020_108060 n1_M2_122100_108060 0.988200
R13713 n1_M2_122100_108060 n1_M2_123180_108060 0.988200
R13714 n1_M2_123180_108060 n1_M2_124260_108060 0.988200
R13715 n1_M2_124260_108060 n1_M2_125340_108060 0.988200
R13716 n1_M2_125340_108060 n1_M2_126420_108060 0.988200
R13717 n1_M2_126420_108060 n1_M2_127500_108060 0.988200
R13718 n1_M2_127500_108060 n1_M2_128580_108060 0.988200
R13719 n1_M2_128580_108060 n1_M2_129660_108060 0.988200
R13720 n1_M2_129660_108060 n1_M2_130740_108060 0.988200
R13721 n1_M2_130740_108060 n1_M2_131820_108060 0.988200
R13722 n1_M2_131820_108060 n1_M2_132900_108060 0.988200
R13723 n1_M2_132900_108060 n1_M2_133980_108060 0.988200
R13724 n1_M2_133980_108060 n1_M2_135060_108060 0.988200
R13725 n1_M2_135060_108060 n1_M2_136140_108060 0.988200
R13726 n1_M2_136140_108060 n1_M2_137220_108060 0.988200
R13727 n1_M2_137220_108060 n1_M2_138300_108060 0.988200
R13728 n1_M2_138300_108060 n1_M2_139380_108060 0.988200
R13729 n1_M2_139380_108060 n1_M2_140460_108060 0.988200
R13730 n1_M2_140460_108060 n1_M2_141540_108060 0.988200
R13731 n1_M2_141540_108060 n1_M2_142620_108060 0.988200
R13732 n1_M2_142620_108060 n1_M2_143700_108060 0.988200
R13733 n1_M2_143700_108060 n1_M2_144780_108060 0.988200
R13734 n1_M2_144780_108060 n1_M2_145860_108060 0.988200
R13735 n1_M2_145860_108060 n1_M2_146940_108060 0.988200
R13736 n1_M2_60_109140 n1_M2_1140_109140 0.988200
R13737 n1_M2_1140_109140 n1_M2_2220_109140 0.988200
R13738 n1_M2_2220_109140 n1_M2_3300_109140 0.988200
R13739 n1_M2_3300_109140 n1_M2_4380_109140 0.988200
R13740 n1_M2_4380_109140 n1_M2_5460_109140 0.988200
R13741 n1_M2_5460_109140 n1_M2_6540_109140 0.988200
R13742 n1_M2_6540_109140 n1_M2_7620_109140 0.988200
R13743 n1_M2_7620_109140 n1_M2_8700_109140 0.988200
R13744 n1_M2_8700_109140 n1_M2_9780_109140 0.988200
R13745 n1_M2_9780_109140 n1_M2_10860_109140 0.988200
R13746 n1_M2_10860_109140 n1_M2_11940_109140 0.988200
R13747 n1_M2_11940_109140 n1_M2_13020_109140 0.988200
R13748 n1_M2_13020_109140 n1_M2_14100_109140 0.988200
R13749 n1_M2_14100_109140 n1_M2_15180_109140 0.988200
R13750 n1_M2_15180_109140 n1_M2_16260_109140 0.988200
R13751 n1_M2_16260_109140 n1_M2_17340_109140 0.988200
R13752 n1_M2_17340_109140 n1_M2_18420_109140 0.988200
R13753 n1_M2_18420_109140 n1_M2_19500_109140 0.988200
R13754 n1_M2_19500_109140 n1_M2_20580_109140 0.988200
R13755 n1_M2_20580_109140 n1_M2_21660_109140 0.988200
R13756 n1_M2_21660_109140 n1_M2_22740_109140 0.988200
R13757 n1_M2_22740_109140 n1_M2_23820_109140 0.988200
R13758 n1_M2_23820_109140 n1_M2_24900_109140 0.988200
R13759 n1_M2_24900_109140 n1_M2_25980_109140 0.988200
R13760 n1_M2_25980_109140 n1_M2_27060_109140 0.988200
R13761 n1_M2_27060_109140 n1_M2_28140_109140 0.988200
R13762 n1_M2_28140_109140 n1_M2_29220_109140 0.988200
R13763 n1_M2_29220_109140 n1_M2_30300_109140 0.988200
R13764 n1_M2_30300_109140 n1_M2_31380_109140 0.988200
R13765 n1_M2_31380_109140 n1_M2_32460_109140 0.988200
R13766 n1_M2_32460_109140 n1_M2_33540_109140 0.988200
R13767 n1_M2_33540_109140 n1_M2_34620_109140 0.988200
R13768 n1_M2_34620_109140 n1_M2_35700_109140 0.988200
R13769 n1_M2_35700_109140 n1_M2_36780_109140 0.988200
R13770 n1_M2_36780_109140 n1_M2_37860_109140 0.988200
R13771 n1_M2_37860_109140 n1_M2_38940_109140 0.988200
R13772 n1_M2_38940_109140 n1_M2_40020_109140 0.988200
R13773 n1_M2_40020_109140 n1_M2_41100_109140 0.988200
R13774 n1_M2_41100_109140 n1_M2_42180_109140 0.988200
R13775 n1_M2_42180_109140 n1_M2_43260_109140 0.988200
R13776 n1_M2_43260_109140 n1_M2_44340_109140 0.988200
R13777 n1_M2_44340_109140 n1_M2_45420_109140 0.988200
R13778 n1_M2_45420_109140 n1_M2_46500_109140 0.988200
R13779 n1_M2_46500_109140 n1_M2_47580_109140 0.988200
R13780 n1_M2_47580_109140 n1_M2_48660_109140 0.988200
R13781 n1_M2_48660_109140 n1_M2_49740_109140 0.988200
R13782 n1_M2_49740_109140 n1_M2_50820_109140 0.988200
R13783 n1_M2_50820_109140 n1_M2_51900_109140 0.988200
R13784 n1_M2_51900_109140 n1_M2_52980_109140 0.988200
R13785 n1_M2_52980_109140 n1_M2_54060_109140 0.988200
R13786 n1_M2_54060_109140 n1_M2_55140_109140 0.988200
R13787 n1_M2_55140_109140 n1_M2_56220_109140 0.988200
R13788 n1_M2_56220_109140 n1_M2_57300_109140 0.988200
R13789 n1_M2_57300_109140 n1_M2_58380_109140 0.988200
R13790 n1_M2_58380_109140 n1_M2_59460_109140 0.988200
R13791 n1_M2_59460_109140 n1_M2_60540_109140 0.988200
R13792 n1_M2_60540_109140 n1_M2_61620_109140 0.988200
R13793 n1_M2_61620_109140 n1_M2_62700_109140 0.988200
R13794 n1_M2_62700_109140 n1_M2_63780_109140 0.988200
R13795 n1_M2_63780_109140 n1_M2_64860_109140 0.988200
R13796 n1_M2_64860_109140 n1_M2_65940_109140 0.988200
R13797 n1_M2_65940_109140 n1_M2_67020_109140 0.988200
R13798 n1_M2_67020_109140 n1_M2_68100_109140 0.988200
R13799 n1_M2_68100_109140 n1_M2_69180_109140 0.988200
R13800 n1_M2_69180_109140 n1_M2_70260_109140 0.988200
R13801 n1_M2_70260_109140 n1_M2_71340_109140 0.988200
R13802 n1_M2_71340_109140 n1_M2_72420_109140 0.988200
R13803 n1_M2_72420_109140 n1_M2_73500_109140 0.988200
R13804 n1_M2_73500_109140 n1_M2_74580_109140 0.988200
R13805 n1_M2_74580_109140 n1_M2_75660_109140 0.988200
R13806 n1_M2_75660_109140 n1_M2_76740_109140 0.988200
R13807 n1_M2_76740_109140 n1_M2_77820_109140 0.988200
R13808 n1_M2_77820_109140 n1_M2_78900_109140 0.988200
R13809 n1_M2_78900_109140 n1_M2_79980_109140 0.988200
R13810 n1_M2_79980_109140 n1_M2_81060_109140 0.988200
R13811 n1_M2_81060_109140 n1_M2_82140_109140 0.988200
R13812 n1_M2_82140_109140 n1_M2_83220_109140 0.988200
R13813 n1_M2_83220_109140 n1_M2_84300_109140 0.988200
R13814 n1_M2_84300_109140 n1_M2_85380_109140 0.988200
R13815 n1_M2_85380_109140 n1_M2_86460_109140 0.988200
R13816 n1_M2_86460_109140 n1_M2_87540_109140 0.988200
R13817 n1_M2_87540_109140 n1_M2_88620_109140 0.988200
R13818 n1_M2_88620_109140 n1_M2_89700_109140 0.988200
R13819 n1_M2_89700_109140 n1_M2_90780_109140 0.988200
R13820 n1_M2_90780_109140 n1_M2_91860_109140 0.988200
R13821 n1_M2_91860_109140 n1_M2_92940_109140 0.988200
R13822 n1_M2_92940_109140 n1_M2_94020_109140 0.988200
R13823 n1_M2_94020_109140 n1_M2_95100_109140 0.988200
R13824 n1_M2_95100_109140 n1_M2_96180_109140 0.988200
R13825 n1_M2_96180_109140 n1_M2_97260_109140 0.988200
R13826 n1_M2_97260_109140 n1_M2_98340_109140 0.988200
R13827 n1_M2_98340_109140 n1_M2_99420_109140 0.988200
R13828 n1_M2_99420_109140 n1_M2_100500_109140 0.988200
R13829 n1_M2_100500_109140 n1_M2_101580_109140 0.988200
R13830 n1_M2_101580_109140 n1_M2_102660_109140 0.988200
R13831 n1_M2_102660_109140 n1_M2_103740_109140 0.988200
R13832 n1_M2_103740_109140 n1_M2_104820_109140 0.988200
R13833 n1_M2_104820_109140 n1_M2_105900_109140 0.988200
R13834 n1_M2_105900_109140 n1_M2_106980_109140 0.988200
R13835 n1_M2_106980_109140 n1_M2_108060_109140 0.988200
R13836 n1_M2_108060_109140 n1_M2_109140_109140 0.988200
R13837 n1_M2_109140_109140 n1_M2_110220_109140 0.988200
R13838 n1_M2_110220_109140 n1_M2_111300_109140 0.988200
R13839 n1_M2_111300_109140 n1_M2_112380_109140 0.988200
R13840 n1_M2_112380_109140 n1_M2_113460_109140 0.988200
R13841 n1_M2_113460_109140 n1_M2_114540_109140 0.988200
R13842 n1_M2_114540_109140 n1_M2_115620_109140 0.988200
R13843 n1_M2_115620_109140 n1_M2_116700_109140 0.988200
R13844 n1_M2_116700_109140 n1_M2_117780_109140 0.988200
R13845 n1_M2_117780_109140 n1_M2_118860_109140 0.988200
R13846 n1_M2_118860_109140 n1_M2_119940_109140 0.988200
R13847 n1_M2_119940_109140 n1_M2_121020_109140 0.988200
R13848 n1_M2_121020_109140 n1_M2_122100_109140 0.988200
R13849 n1_M2_122100_109140 n1_M2_123180_109140 0.988200
R13850 n1_M2_123180_109140 n1_M2_124260_109140 0.988200
R13851 n1_M2_124260_109140 n1_M2_125340_109140 0.988200
R13852 n1_M2_125340_109140 n1_M2_126420_109140 0.988200
R13853 n1_M2_126420_109140 n1_M2_127500_109140 0.988200
R13854 n1_M2_127500_109140 n1_M2_128580_109140 0.988200
R13855 n1_M2_128580_109140 n1_M2_129660_109140 0.988200
R13856 n1_M2_129660_109140 n1_M2_130740_109140 0.988200
R13857 n1_M2_130740_109140 n1_M2_131820_109140 0.988200
R13858 n1_M2_131820_109140 n1_M2_132900_109140 0.988200
R13859 n1_M2_132900_109140 n1_M2_133980_109140 0.988200
R13860 n1_M2_133980_109140 n1_M2_135060_109140 0.988200
R13861 n1_M2_135060_109140 n1_M2_136140_109140 0.988200
R13862 n1_M2_136140_109140 n1_M2_137220_109140 0.988200
R13863 n1_M2_137220_109140 n1_M2_138300_109140 0.988200
R13864 n1_M2_138300_109140 n1_M2_139380_109140 0.988200
R13865 n1_M2_139380_109140 n1_M2_140460_109140 0.988200
R13866 n1_M2_140460_109140 n1_M2_141540_109140 0.988200
R13867 n1_M2_141540_109140 n1_M2_142620_109140 0.988200
R13868 n1_M2_142620_109140 n1_M2_143700_109140 0.988200
R13869 n1_M2_143700_109140 n1_M2_144780_109140 0.988200
R13870 n1_M2_144780_109140 n1_M2_145860_109140 0.988200
R13871 n1_M2_145860_109140 n1_M2_146940_109140 0.988200
R13872 n1_M2_60_110220 n1_M2_1140_110220 0.988200
R13873 n1_M2_1140_110220 n1_M2_2220_110220 0.988200
R13874 n1_M2_2220_110220 n1_M2_3300_110220 0.988200
R13875 n1_M2_3300_110220 n1_M2_4380_110220 0.988200
R13876 n1_M2_4380_110220 n1_M2_5460_110220 0.988200
R13877 n1_M2_5460_110220 n1_M2_6540_110220 0.988200
R13878 n1_M2_6540_110220 n1_M2_7620_110220 0.988200
R13879 n1_M2_7620_110220 n1_M2_8700_110220 0.988200
R13880 n1_M2_8700_110220 n1_M2_9780_110220 0.988200
R13881 n1_M2_9780_110220 n1_M2_10860_110220 0.988200
R13882 n1_M2_10860_110220 n1_M2_11940_110220 0.988200
R13883 n1_M2_11940_110220 n1_M2_13020_110220 0.988200
R13884 n1_M2_13020_110220 n1_M2_14100_110220 0.988200
R13885 n1_M2_14100_110220 n1_M2_15180_110220 0.988200
R13886 n1_M2_15180_110220 n1_M2_16260_110220 0.988200
R13887 n1_M2_16260_110220 n1_M2_17340_110220 0.988200
R13888 n1_M2_17340_110220 n1_M2_18420_110220 0.988200
R13889 n1_M2_18420_110220 n1_M2_19500_110220 0.988200
R13890 n1_M2_19500_110220 n1_M2_20580_110220 0.988200
R13891 n1_M2_20580_110220 n1_M2_21660_110220 0.988200
R13892 n1_M2_21660_110220 n1_M2_22740_110220 0.988200
R13893 n1_M2_22740_110220 n1_M2_23820_110220 0.988200
R13894 n1_M2_23820_110220 n1_M2_24900_110220 0.988200
R13895 n1_M2_24900_110220 n1_M2_25980_110220 0.988200
R13896 n1_M2_25980_110220 n1_M2_27060_110220 0.988200
R13897 n1_M2_27060_110220 n1_M2_28140_110220 0.988200
R13898 n1_M2_28140_110220 n1_M2_29220_110220 0.988200
R13899 n1_M2_29220_110220 n1_M2_30300_110220 0.988200
R13900 n1_M2_30300_110220 n1_M2_31380_110220 0.988200
R13901 n1_M2_31380_110220 n1_M2_32460_110220 0.988200
R13902 n1_M2_32460_110220 n1_M2_33540_110220 0.988200
R13903 n1_M2_33540_110220 n1_M2_34620_110220 0.988200
R13904 n1_M2_34620_110220 n1_M2_35700_110220 0.988200
R13905 n1_M2_35700_110220 n1_M2_36780_110220 0.988200
R13906 n1_M2_36780_110220 n1_M2_37860_110220 0.988200
R13907 n1_M2_37860_110220 n1_M2_38940_110220 0.988200
R13908 n1_M2_38940_110220 n1_M2_40020_110220 0.988200
R13909 n1_M2_40020_110220 n1_M2_41100_110220 0.988200
R13910 n1_M2_41100_110220 n1_M2_42180_110220 0.988200
R13911 n1_M2_42180_110220 n1_M2_43260_110220 0.988200
R13912 n1_M2_43260_110220 n1_M2_44340_110220 0.988200
R13913 n1_M2_44340_110220 n1_M2_45420_110220 0.988200
R13914 n1_M2_45420_110220 n1_M2_46500_110220 0.988200
R13915 n1_M2_46500_110220 n1_M2_47580_110220 0.988200
R13916 n1_M2_47580_110220 n1_M2_48660_110220 0.988200
R13917 n1_M2_48660_110220 n1_M2_49740_110220 0.988200
R13918 n1_M2_49740_110220 n1_M2_50820_110220 0.988200
R13919 n1_M2_50820_110220 n1_M2_51900_110220 0.988200
R13920 n1_M2_51900_110220 n1_M2_52980_110220 0.988200
R13921 n1_M2_52980_110220 n1_M2_54060_110220 0.988200
R13922 n1_M2_54060_110220 n1_M2_55140_110220 0.988200
R13923 n1_M2_55140_110220 n1_M2_56220_110220 0.988200
R13924 n1_M2_56220_110220 n1_M2_57300_110220 0.988200
R13925 n1_M2_57300_110220 n1_M2_58380_110220 0.988200
R13926 n1_M2_58380_110220 n1_M2_59460_110220 0.988200
R13927 n1_M2_59460_110220 n1_M2_60540_110220 0.988200
R13928 n1_M2_60540_110220 n1_M2_61620_110220 0.988200
R13929 n1_M2_61620_110220 n1_M2_62700_110220 0.988200
R13930 n1_M2_62700_110220 n1_M2_63780_110220 0.988200
R13931 n1_M2_63780_110220 n1_M2_64860_110220 0.988200
R13932 n1_M2_64860_110220 n1_M2_65940_110220 0.988200
R13933 n1_M2_65940_110220 n1_M2_67020_110220 0.988200
R13934 n1_M2_67020_110220 n1_M2_68100_110220 0.988200
R13935 n1_M2_68100_110220 n1_M2_69180_110220 0.988200
R13936 n1_M2_69180_110220 n1_M2_70260_110220 0.988200
R13937 n1_M2_70260_110220 n1_M2_71340_110220 0.988200
R13938 n1_M2_71340_110220 n1_M2_72420_110220 0.988200
R13939 n1_M2_72420_110220 n1_M2_73500_110220 0.988200
R13940 n1_M2_73500_110220 n1_M2_74580_110220 0.988200
R13941 n1_M2_74580_110220 n1_M2_75660_110220 0.988200
R13942 n1_M2_75660_110220 n1_M2_76740_110220 0.988200
R13943 n1_M2_76740_110220 n1_M2_77820_110220 0.988200
R13944 n1_M2_77820_110220 n1_M2_78900_110220 0.988200
R13945 n1_M2_78900_110220 n1_M2_79980_110220 0.988200
R13946 n1_M2_79980_110220 n1_M2_81060_110220 0.988200
R13947 n1_M2_81060_110220 n1_M2_82140_110220 0.988200
R13948 n1_M2_82140_110220 n1_M2_83220_110220 0.988200
R13949 n1_M2_83220_110220 n1_M2_84300_110220 0.988200
R13950 n1_M2_84300_110220 n1_M2_85380_110220 0.988200
R13951 n1_M2_85380_110220 n1_M2_86460_110220 0.988200
R13952 n1_M2_86460_110220 n1_M2_87540_110220 0.988200
R13953 n1_M2_87540_110220 n1_M2_88620_110220 0.988200
R13954 n1_M2_88620_110220 n1_M2_89700_110220 0.988200
R13955 n1_M2_89700_110220 n1_M2_90780_110220 0.988200
R13956 n1_M2_90780_110220 n1_M2_91860_110220 0.988200
R13957 n1_M2_91860_110220 n1_M2_92940_110220 0.988200
R13958 n1_M2_92940_110220 n1_M2_94020_110220 0.988200
R13959 n1_M2_94020_110220 n1_M2_95100_110220 0.988200
R13960 n1_M2_95100_110220 n1_M2_96180_110220 0.988200
R13961 n1_M2_96180_110220 n1_M2_97260_110220 0.988200
R13962 n1_M2_97260_110220 n1_M2_98340_110220 0.988200
R13963 n1_M2_98340_110220 n1_M2_99420_110220 0.988200
R13964 n1_M2_99420_110220 n1_M2_100500_110220 0.988200
R13965 n1_M2_100500_110220 n1_M2_101580_110220 0.988200
R13966 n1_M2_101580_110220 n1_M2_102660_110220 0.988200
R13967 n1_M2_102660_110220 n1_M2_103740_110220 0.988200
R13968 n1_M2_103740_110220 n1_M2_104820_110220 0.988200
R13969 n1_M2_104820_110220 n1_M2_105900_110220 0.988200
R13970 n1_M2_105900_110220 n1_M2_106980_110220 0.988200
R13971 n1_M2_106980_110220 n1_M2_108060_110220 0.988200
R13972 n1_M2_108060_110220 n1_M2_109140_110220 0.988200
R13973 n1_M2_109140_110220 n1_M2_110220_110220 0.988200
R13974 n1_M2_110220_110220 n1_M2_111300_110220 0.988200
R13975 n1_M2_111300_110220 n1_M2_112380_110220 0.988200
R13976 n1_M2_112380_110220 n1_M2_113460_110220 0.988200
R13977 n1_M2_113460_110220 n1_M2_114540_110220 0.988200
R13978 n1_M2_114540_110220 n1_M2_115620_110220 0.988200
R13979 n1_M2_115620_110220 n1_M2_116700_110220 0.988200
R13980 n1_M2_116700_110220 n1_M2_117780_110220 0.988200
R13981 n1_M2_117780_110220 n1_M2_118860_110220 0.988200
R13982 n1_M2_118860_110220 n1_M2_119940_110220 0.988200
R13983 n1_M2_119940_110220 n1_M2_121020_110220 0.988200
R13984 n1_M2_121020_110220 n1_M2_122100_110220 0.988200
R13985 n1_M2_122100_110220 n1_M2_123180_110220 0.988200
R13986 n1_M2_123180_110220 n1_M2_124260_110220 0.988200
R13987 n1_M2_124260_110220 n1_M2_125340_110220 0.988200
R13988 n1_M2_125340_110220 n1_M2_126420_110220 0.988200
R13989 n1_M2_126420_110220 n1_M2_127500_110220 0.988200
R13990 n1_M2_127500_110220 n1_M2_128580_110220 0.988200
R13991 n1_M2_128580_110220 n1_M2_129660_110220 0.988200
R13992 n1_M2_129660_110220 n1_M2_130740_110220 0.988200
R13993 n1_M2_130740_110220 n1_M2_131820_110220 0.988200
R13994 n1_M2_131820_110220 n1_M2_132900_110220 0.988200
R13995 n1_M2_132900_110220 n1_M2_133980_110220 0.988200
R13996 n1_M2_133980_110220 n1_M2_135060_110220 0.988200
R13997 n1_M2_135060_110220 n1_M2_136140_110220 0.988200
R13998 n1_M2_136140_110220 n1_M2_137220_110220 0.988200
R13999 n1_M2_137220_110220 n1_M2_138300_110220 0.988200
R14000 n1_M2_138300_110220 n1_M2_139380_110220 0.988200
R14001 n1_M2_139380_110220 n1_M2_140460_110220 0.988200
R14002 n1_M2_140460_110220 n1_M2_141540_110220 0.988200
R14003 n1_M2_141540_110220 n1_M2_142620_110220 0.988200
R14004 n1_M2_142620_110220 n1_M2_143700_110220 0.988200
R14005 n1_M2_143700_110220 n1_M2_144780_110220 0.988200
R14006 n1_M2_144780_110220 n1_M2_145860_110220 0.988200
R14007 n1_M2_145860_110220 n1_M2_146940_110220 0.988200
R14008 n1_M2_60_111300 n1_M2_1140_111300 0.988200
R14009 n1_M2_1140_111300 n1_M2_2220_111300 0.988200
R14010 n1_M2_2220_111300 n1_M2_3300_111300 0.988200
R14011 n1_M2_3300_111300 n1_M2_4380_111300 0.988200
R14012 n1_M2_4380_111300 n1_M2_5460_111300 0.988200
R14013 n1_M2_5460_111300 n1_M2_6540_111300 0.988200
R14014 n1_M2_6540_111300 n1_M2_7620_111300 0.988200
R14015 n1_M2_7620_111300 n1_M2_8700_111300 0.988200
R14016 n1_M2_8700_111300 n1_M2_9780_111300 0.988200
R14017 n1_M2_9780_111300 n1_M2_10860_111300 0.988200
R14018 n1_M2_10860_111300 n1_M2_11940_111300 0.988200
R14019 n1_M2_11940_111300 n1_M2_13020_111300 0.988200
R14020 n1_M2_13020_111300 n1_M2_14100_111300 0.988200
R14021 n1_M2_14100_111300 n1_M2_15180_111300 0.988200
R14022 n1_M2_15180_111300 n1_M2_16260_111300 0.988200
R14023 n1_M2_16260_111300 n1_M2_17340_111300 0.988200
R14024 n1_M2_17340_111300 n1_M2_18420_111300 0.988200
R14025 n1_M2_18420_111300 n1_M2_19500_111300 0.988200
R14026 n1_M2_19500_111300 n1_M2_20580_111300 0.988200
R14027 n1_M2_20580_111300 n1_M2_21660_111300 0.988200
R14028 n1_M2_21660_111300 n1_M2_22740_111300 0.988200
R14029 n1_M2_22740_111300 n1_M2_23820_111300 0.988200
R14030 n1_M2_23820_111300 n1_M2_24900_111300 0.988200
R14031 n1_M2_24900_111300 n1_M2_25980_111300 0.988200
R14032 n1_M2_25980_111300 n1_M2_27060_111300 0.988200
R14033 n1_M2_27060_111300 n1_M2_28140_111300 0.988200
R14034 n1_M2_28140_111300 n1_M2_29220_111300 0.988200
R14035 n1_M2_29220_111300 n1_M2_30300_111300 0.988200
R14036 n1_M2_30300_111300 n1_M2_31380_111300 0.988200
R14037 n1_M2_31380_111300 n1_M2_32460_111300 0.988200
R14038 n1_M2_32460_111300 n1_M2_33540_111300 0.988200
R14039 n1_M2_33540_111300 n1_M2_34620_111300 0.988200
R14040 n1_M2_34620_111300 n1_M2_35700_111300 0.988200
R14041 n1_M2_35700_111300 n1_M2_36780_111300 0.988200
R14042 n1_M2_36780_111300 n1_M2_37860_111300 0.988200
R14043 n1_M2_37860_111300 n1_M2_38940_111300 0.988200
R14044 n1_M2_38940_111300 n1_M2_40020_111300 0.988200
R14045 n1_M2_40020_111300 n1_M2_41100_111300 0.988200
R14046 n1_M2_41100_111300 n1_M2_42180_111300 0.988200
R14047 n1_M2_42180_111300 n1_M2_43260_111300 0.988200
R14048 n1_M2_43260_111300 n1_M2_44340_111300 0.988200
R14049 n1_M2_44340_111300 n1_M2_45420_111300 0.988200
R14050 n1_M2_45420_111300 n1_M2_46500_111300 0.988200
R14051 n1_M2_46500_111300 n1_M2_47580_111300 0.988200
R14052 n1_M2_47580_111300 n1_M2_48660_111300 0.988200
R14053 n1_M2_48660_111300 n1_M2_49740_111300 0.988200
R14054 n1_M2_49740_111300 n1_M2_50820_111300 0.988200
R14055 n1_M2_50820_111300 n1_M2_51900_111300 0.988200
R14056 n1_M2_51900_111300 n1_M2_52980_111300 0.988200
R14057 n1_M2_52980_111300 n1_M2_54060_111300 0.988200
R14058 n1_M2_54060_111300 n1_M2_55140_111300 0.988200
R14059 n1_M2_55140_111300 n1_M2_56220_111300 0.988200
R14060 n1_M2_56220_111300 n1_M2_57300_111300 0.988200
R14061 n1_M2_57300_111300 n1_M2_58380_111300 0.988200
R14062 n1_M2_58380_111300 n1_M2_59460_111300 0.988200
R14063 n1_M2_59460_111300 n1_M2_60540_111300 0.988200
R14064 n1_M2_60540_111300 n1_M2_61620_111300 0.988200
R14065 n1_M2_61620_111300 n1_M2_62700_111300 0.988200
R14066 n1_M2_62700_111300 n1_M2_63780_111300 0.988200
R14067 n1_M2_63780_111300 n1_M2_64860_111300 0.988200
R14068 n1_M2_64860_111300 n1_M2_65940_111300 0.988200
R14069 n1_M2_65940_111300 n1_M2_67020_111300 0.988200
R14070 n1_M2_67020_111300 n1_M2_68100_111300 0.988200
R14071 n1_M2_68100_111300 n1_M2_69180_111300 0.988200
R14072 n1_M2_69180_111300 n1_M2_70260_111300 0.988200
R14073 n1_M2_70260_111300 n1_M2_71340_111300 0.988200
R14074 n1_M2_71340_111300 n1_M2_72420_111300 0.988200
R14075 n1_M2_72420_111300 n1_M2_73500_111300 0.988200
R14076 n1_M2_73500_111300 n1_M2_74580_111300 0.988200
R14077 n1_M2_74580_111300 n1_M2_75660_111300 0.988200
R14078 n1_M2_75660_111300 n1_M2_76740_111300 0.988200
R14079 n1_M2_76740_111300 n1_M2_77820_111300 0.988200
R14080 n1_M2_77820_111300 n1_M2_78900_111300 0.988200
R14081 n1_M2_78900_111300 n1_M2_79980_111300 0.988200
R14082 n1_M2_79980_111300 n1_M2_81060_111300 0.988200
R14083 n1_M2_81060_111300 n1_M2_82140_111300 0.988200
R14084 n1_M2_82140_111300 n1_M2_83220_111300 0.988200
R14085 n1_M2_83220_111300 n1_M2_84300_111300 0.988200
R14086 n1_M2_84300_111300 n1_M2_85380_111300 0.988200
R14087 n1_M2_85380_111300 n1_M2_86460_111300 0.988200
R14088 n1_M2_86460_111300 n1_M2_87540_111300 0.988200
R14089 n1_M2_87540_111300 n1_M2_88620_111300 0.988200
R14090 n1_M2_88620_111300 n1_M2_89700_111300 0.988200
R14091 n1_M2_89700_111300 n1_M2_90780_111300 0.988200
R14092 n1_M2_90780_111300 n1_M2_91860_111300 0.988200
R14093 n1_M2_91860_111300 n1_M2_92940_111300 0.988200
R14094 n1_M2_92940_111300 n1_M2_94020_111300 0.988200
R14095 n1_M2_94020_111300 n1_M2_95100_111300 0.988200
R14096 n1_M2_95100_111300 n1_M2_96180_111300 0.988200
R14097 n1_M2_96180_111300 n1_M2_97260_111300 0.988200
R14098 n1_M2_97260_111300 n1_M2_98340_111300 0.988200
R14099 n1_M2_98340_111300 n1_M2_99420_111300 0.988200
R14100 n1_M2_99420_111300 n1_M2_100500_111300 0.988200
R14101 n1_M2_100500_111300 n1_M2_101580_111300 0.988200
R14102 n1_M2_101580_111300 n1_M2_102660_111300 0.988200
R14103 n1_M2_102660_111300 n1_M2_103740_111300 0.988200
R14104 n1_M2_103740_111300 n1_M2_104820_111300 0.988200
R14105 n1_M2_104820_111300 n1_M2_105900_111300 0.988200
R14106 n1_M2_105900_111300 n1_M2_106980_111300 0.988200
R14107 n1_M2_106980_111300 n1_M2_108060_111300 0.988200
R14108 n1_M2_108060_111300 n1_M2_109140_111300 0.988200
R14109 n1_M2_109140_111300 n1_M2_110220_111300 0.988200
R14110 n1_M2_110220_111300 n1_M2_111300_111300 0.988200
R14111 n1_M2_111300_111300 n1_M2_112380_111300 0.988200
R14112 n1_M2_112380_111300 n1_M2_113460_111300 0.988200
R14113 n1_M2_113460_111300 n1_M2_114540_111300 0.988200
R14114 n1_M2_114540_111300 n1_M2_115620_111300 0.988200
R14115 n1_M2_115620_111300 n1_M2_116700_111300 0.988200
R14116 n1_M2_116700_111300 n1_M2_117780_111300 0.988200
R14117 n1_M2_117780_111300 n1_M2_118860_111300 0.988200
R14118 n1_M2_118860_111300 n1_M2_119940_111300 0.988200
R14119 n1_M2_119940_111300 n1_M2_121020_111300 0.988200
R14120 n1_M2_121020_111300 n1_M2_122100_111300 0.988200
R14121 n1_M2_122100_111300 n1_M2_123180_111300 0.988200
R14122 n1_M2_123180_111300 n1_M2_124260_111300 0.988200
R14123 n1_M2_124260_111300 n1_M2_125340_111300 0.988200
R14124 n1_M2_125340_111300 n1_M2_126420_111300 0.988200
R14125 n1_M2_126420_111300 n1_M2_127500_111300 0.988200
R14126 n1_M2_127500_111300 n1_M2_128580_111300 0.988200
R14127 n1_M2_128580_111300 n1_M2_129660_111300 0.988200
R14128 n1_M2_129660_111300 n1_M2_130740_111300 0.988200
R14129 n1_M2_130740_111300 n1_M2_131820_111300 0.988200
R14130 n1_M2_131820_111300 n1_M2_132900_111300 0.988200
R14131 n1_M2_132900_111300 n1_M2_133980_111300 0.988200
R14132 n1_M2_133980_111300 n1_M2_135060_111300 0.988200
R14133 n1_M2_135060_111300 n1_M2_136140_111300 0.988200
R14134 n1_M2_136140_111300 n1_M2_137220_111300 0.988200
R14135 n1_M2_137220_111300 n1_M2_138300_111300 0.988200
R14136 n1_M2_138300_111300 n1_M2_139380_111300 0.988200
R14137 n1_M2_139380_111300 n1_M2_140460_111300 0.988200
R14138 n1_M2_140460_111300 n1_M2_141540_111300 0.988200
R14139 n1_M2_141540_111300 n1_M2_142620_111300 0.988200
R14140 n1_M2_142620_111300 n1_M2_143700_111300 0.988200
R14141 n1_M2_143700_111300 n1_M2_144780_111300 0.988200
R14142 n1_M2_144780_111300 n1_M2_145860_111300 0.988200
R14143 n1_M2_145860_111300 n1_M2_146940_111300 0.988200
R14144 n1_M2_60_112380 n1_M2_1140_112380 0.988200
R14145 n1_M2_1140_112380 n1_M2_2220_112380 0.988200
R14146 n1_M2_2220_112380 n1_M2_3300_112380 0.988200
R14147 n1_M2_3300_112380 n1_M2_4380_112380 0.988200
R14148 n1_M2_4380_112380 n1_M2_5460_112380 0.988200
R14149 n1_M2_5460_112380 n1_M2_6540_112380 0.988200
R14150 n1_M2_6540_112380 n1_M2_7620_112380 0.988200
R14151 n1_M2_7620_112380 n1_M2_8700_112380 0.988200
R14152 n1_M2_8700_112380 n1_M2_9780_112380 0.988200
R14153 n1_M2_9780_112380 n1_M2_10860_112380 0.988200
R14154 n1_M2_10860_112380 n1_M2_11940_112380 0.988200
R14155 n1_M2_11940_112380 n1_M2_13020_112380 0.988200
R14156 n1_M2_13020_112380 n1_M2_14100_112380 0.988200
R14157 n1_M2_14100_112380 n1_M2_15180_112380 0.988200
R14158 n1_M2_15180_112380 n1_M2_16260_112380 0.988200
R14159 n1_M2_16260_112380 n1_M2_17340_112380 0.988200
R14160 n1_M2_17340_112380 n1_M2_18420_112380 0.988200
R14161 n1_M2_18420_112380 n1_M2_19500_112380 0.988200
R14162 n1_M2_19500_112380 n1_M2_20580_112380 0.988200
R14163 n1_M2_20580_112380 n1_M2_21660_112380 0.988200
R14164 n1_M2_21660_112380 n1_M2_22740_112380 0.988200
R14165 n1_M2_22740_112380 n1_M2_23820_112380 0.988200
R14166 n1_M2_23820_112380 n1_M2_24900_112380 0.988200
R14167 n1_M2_24900_112380 n1_M2_25980_112380 0.988200
R14168 n1_M2_25980_112380 n1_M2_27060_112380 0.988200
R14169 n1_M2_27060_112380 n1_M2_28140_112380 0.988200
R14170 n1_M2_28140_112380 n1_M2_29220_112380 0.988200
R14171 n1_M2_29220_112380 n1_M2_30300_112380 0.988200
R14172 n1_M2_30300_112380 n1_M2_31380_112380 0.988200
R14173 n1_M2_31380_112380 n1_M2_32460_112380 0.988200
R14174 n1_M2_32460_112380 n1_M2_33540_112380 0.988200
R14175 n1_M2_33540_112380 n1_M2_34620_112380 0.988200
R14176 n1_M2_34620_112380 n1_M2_35700_112380 0.988200
R14177 n1_M2_35700_112380 n1_M2_36780_112380 0.988200
R14178 n1_M2_36780_112380 n1_M2_37860_112380 0.988200
R14179 n1_M2_37860_112380 n1_M2_38940_112380 0.988200
R14180 n1_M2_38940_112380 n1_M2_40020_112380 0.988200
R14181 n1_M2_40020_112380 n1_M2_41100_112380 0.988200
R14182 n1_M2_41100_112380 n1_M2_42180_112380 0.988200
R14183 n1_M2_42180_112380 n1_M2_43260_112380 0.988200
R14184 n1_M2_43260_112380 n1_M2_44340_112380 0.988200
R14185 n1_M2_44340_112380 n1_M2_45420_112380 0.988200
R14186 n1_M2_45420_112380 n1_M2_46500_112380 0.988200
R14187 n1_M2_46500_112380 n1_M2_47580_112380 0.988200
R14188 n1_M2_47580_112380 n1_M2_48660_112380 0.988200
R14189 n1_M2_48660_112380 n1_M2_49740_112380 0.988200
R14190 n1_M2_49740_112380 n1_M2_50820_112380 0.988200
R14191 n1_M2_50820_112380 n1_M2_51900_112380 0.988200
R14192 n1_M2_51900_112380 n1_M2_52980_112380 0.988200
R14193 n1_M2_52980_112380 n1_M2_54060_112380 0.988200
R14194 n1_M2_54060_112380 n1_M2_55140_112380 0.988200
R14195 n1_M2_55140_112380 n1_M2_56220_112380 0.988200
R14196 n1_M2_56220_112380 n1_M2_57300_112380 0.988200
R14197 n1_M2_57300_112380 n1_M2_58380_112380 0.988200
R14198 n1_M2_58380_112380 n1_M2_59460_112380 0.988200
R14199 n1_M2_59460_112380 n1_M2_60540_112380 0.988200
R14200 n1_M2_60540_112380 n1_M2_61620_112380 0.988200
R14201 n1_M2_61620_112380 n1_M2_62700_112380 0.988200
R14202 n1_M2_62700_112380 n1_M2_63780_112380 0.988200
R14203 n1_M2_63780_112380 n1_M2_64860_112380 0.988200
R14204 n1_M2_64860_112380 n1_M2_65940_112380 0.988200
R14205 n1_M2_65940_112380 n1_M2_67020_112380 0.988200
R14206 n1_M2_67020_112380 n1_M2_68100_112380 0.988200
R14207 n1_M2_68100_112380 n1_M2_69180_112380 0.988200
R14208 n1_M2_69180_112380 n1_M2_70260_112380 0.988200
R14209 n1_M2_70260_112380 n1_M2_71340_112380 0.988200
R14210 n1_M2_71340_112380 n1_M2_72420_112380 0.988200
R14211 n1_M2_72420_112380 n1_M2_73500_112380 0.988200
R14212 n1_M2_73500_112380 n1_M2_74580_112380 0.988200
R14213 n1_M2_74580_112380 n1_M2_75660_112380 0.988200
R14214 n1_M2_75660_112380 n1_M2_76740_112380 0.988200
R14215 n1_M2_76740_112380 n1_M2_77820_112380 0.988200
R14216 n1_M2_77820_112380 n1_M2_78900_112380 0.988200
R14217 n1_M2_78900_112380 n1_M2_79980_112380 0.988200
R14218 n1_M2_79980_112380 n1_M2_81060_112380 0.988200
R14219 n1_M2_81060_112380 n1_M2_82140_112380 0.988200
R14220 n1_M2_82140_112380 n1_M2_83220_112380 0.988200
R14221 n1_M2_83220_112380 n1_M2_84300_112380 0.988200
R14222 n1_M2_84300_112380 n1_M2_85380_112380 0.988200
R14223 n1_M2_85380_112380 n1_M2_86460_112380 0.988200
R14224 n1_M2_86460_112380 n1_M2_87540_112380 0.988200
R14225 n1_M2_87540_112380 n1_M2_88620_112380 0.988200
R14226 n1_M2_88620_112380 n1_M2_89700_112380 0.988200
R14227 n1_M2_89700_112380 n1_M2_90780_112380 0.988200
R14228 n1_M2_90780_112380 n1_M2_91860_112380 0.988200
R14229 n1_M2_91860_112380 n1_M2_92940_112380 0.988200
R14230 n1_M2_92940_112380 n1_M2_94020_112380 0.988200
R14231 n1_M2_94020_112380 n1_M2_95100_112380 0.988200
R14232 n1_M2_95100_112380 n1_M2_96180_112380 0.988200
R14233 n1_M2_96180_112380 n1_M2_97260_112380 0.988200
R14234 n1_M2_97260_112380 n1_M2_98340_112380 0.988200
R14235 n1_M2_98340_112380 n1_M2_99420_112380 0.988200
R14236 n1_M2_99420_112380 n1_M2_100500_112380 0.988200
R14237 n1_M2_100500_112380 n1_M2_101580_112380 0.988200
R14238 n1_M2_101580_112380 n1_M2_102660_112380 0.988200
R14239 n1_M2_102660_112380 n1_M2_103740_112380 0.988200
R14240 n1_M2_103740_112380 n1_M2_104820_112380 0.988200
R14241 n1_M2_104820_112380 n1_M2_105900_112380 0.988200
R14242 n1_M2_105900_112380 n1_M2_106980_112380 0.988200
R14243 n1_M2_106980_112380 n1_M2_108060_112380 0.988200
R14244 n1_M2_108060_112380 n1_M2_109140_112380 0.988200
R14245 n1_M2_109140_112380 n1_M2_110220_112380 0.988200
R14246 n1_M2_110220_112380 n1_M2_111300_112380 0.988200
R14247 n1_M2_111300_112380 n1_M2_112380_112380 0.988200
R14248 n1_M2_112380_112380 n1_M2_113460_112380 0.988200
R14249 n1_M2_113460_112380 n1_M2_114540_112380 0.988200
R14250 n1_M2_114540_112380 n1_M2_115620_112380 0.988200
R14251 n1_M2_115620_112380 n1_M2_116700_112380 0.988200
R14252 n1_M2_116700_112380 n1_M2_117780_112380 0.988200
R14253 n1_M2_117780_112380 n1_M2_118860_112380 0.988200
R14254 n1_M2_118860_112380 n1_M2_119940_112380 0.988200
R14255 n1_M2_119940_112380 n1_M2_121020_112380 0.988200
R14256 n1_M2_121020_112380 n1_M2_122100_112380 0.988200
R14257 n1_M2_122100_112380 n1_M2_123180_112380 0.988200
R14258 n1_M2_123180_112380 n1_M2_124260_112380 0.988200
R14259 n1_M2_124260_112380 n1_M2_125340_112380 0.988200
R14260 n1_M2_125340_112380 n1_M2_126420_112380 0.988200
R14261 n1_M2_126420_112380 n1_M2_127500_112380 0.988200
R14262 n1_M2_127500_112380 n1_M2_128580_112380 0.988200
R14263 n1_M2_128580_112380 n1_M2_129660_112380 0.988200
R14264 n1_M2_129660_112380 n1_M2_130740_112380 0.988200
R14265 n1_M2_130740_112380 n1_M2_131820_112380 0.988200
R14266 n1_M2_131820_112380 n1_M2_132900_112380 0.988200
R14267 n1_M2_132900_112380 n1_M2_133980_112380 0.988200
R14268 n1_M2_133980_112380 n1_M2_135060_112380 0.988200
R14269 n1_M2_135060_112380 n1_M2_136140_112380 0.988200
R14270 n1_M2_136140_112380 n1_M2_137220_112380 0.988200
R14271 n1_M2_137220_112380 n1_M2_138300_112380 0.988200
R14272 n1_M2_138300_112380 n1_M2_139380_112380 0.988200
R14273 n1_M2_139380_112380 n1_M2_140460_112380 0.988200
R14274 n1_M2_140460_112380 n1_M2_141540_112380 0.988200
R14275 n1_M2_141540_112380 n1_M2_142620_112380 0.988200
R14276 n1_M2_142620_112380 n1_M2_143700_112380 0.988200
R14277 n1_M2_143700_112380 n1_M2_144780_112380 0.988200
R14278 n1_M2_144780_112380 n1_M2_145860_112380 0.988200
R14279 n1_M2_145860_112380 n1_M2_146940_112380 0.988200
R14280 n1_M2_60_113460 n1_M2_1140_113460 0.988200
R14281 n1_M2_1140_113460 n1_M2_2220_113460 0.988200
R14282 n1_M2_2220_113460 n1_M2_3300_113460 0.988200
R14283 n1_M2_3300_113460 n1_M2_4380_113460 0.988200
R14284 n1_M2_4380_113460 n1_M2_5460_113460 0.988200
R14285 n1_M2_5460_113460 n1_M2_6540_113460 0.988200
R14286 n1_M2_6540_113460 n1_M2_7620_113460 0.988200
R14287 n1_M2_7620_113460 n1_M2_8700_113460 0.988200
R14288 n1_M2_8700_113460 n1_M2_9780_113460 0.988200
R14289 n1_M2_9780_113460 n1_M2_10860_113460 0.988200
R14290 n1_M2_10860_113460 n1_M2_11940_113460 0.988200
R14291 n1_M2_11940_113460 n1_M2_13020_113460 0.988200
R14292 n1_M2_13020_113460 n1_M2_14100_113460 0.988200
R14293 n1_M2_14100_113460 n1_M2_15180_113460 0.988200
R14294 n1_M2_15180_113460 n1_M2_16260_113460 0.988200
R14295 n1_M2_16260_113460 n1_M2_17340_113460 0.988200
R14296 n1_M2_17340_113460 n1_M2_18420_113460 0.988200
R14297 n1_M2_18420_113460 n1_M2_19500_113460 0.988200
R14298 n1_M2_19500_113460 n1_M2_20580_113460 0.988200
R14299 n1_M2_20580_113460 n1_M2_21660_113460 0.988200
R14300 n1_M2_21660_113460 n1_M2_22740_113460 0.988200
R14301 n1_M2_22740_113460 n1_M2_23820_113460 0.988200
R14302 n1_M2_23820_113460 n1_M2_24900_113460 0.988200
R14303 n1_M2_24900_113460 n1_M2_25980_113460 0.988200
R14304 n1_M2_25980_113460 n1_M2_27060_113460 0.988200
R14305 n1_M2_27060_113460 n1_M2_28140_113460 0.988200
R14306 n1_M2_28140_113460 n1_M2_29220_113460 0.988200
R14307 n1_M2_29220_113460 n1_M2_30300_113460 0.988200
R14308 n1_M2_30300_113460 n1_M2_31380_113460 0.988200
R14309 n1_M2_31380_113460 n1_M2_32460_113460 0.988200
R14310 n1_M2_32460_113460 n1_M2_33540_113460 0.988200
R14311 n1_M2_33540_113460 n1_M2_34620_113460 0.988200
R14312 n1_M2_34620_113460 n1_M2_35700_113460 0.988200
R14313 n1_M2_35700_113460 n1_M2_36780_113460 0.988200
R14314 n1_M2_36780_113460 n1_M2_37860_113460 0.988200
R14315 n1_M2_37860_113460 n1_M2_38940_113460 0.988200
R14316 n1_M2_38940_113460 n1_M2_40020_113460 0.988200
R14317 n1_M2_40020_113460 n1_M2_41100_113460 0.988200
R14318 n1_M2_41100_113460 n1_M2_42180_113460 0.988200
R14319 n1_M2_42180_113460 n1_M2_43260_113460 0.988200
R14320 n1_M2_43260_113460 n1_M2_44340_113460 0.988200
R14321 n1_M2_44340_113460 n1_M2_45420_113460 0.988200
R14322 n1_M2_45420_113460 n1_M2_46500_113460 0.988200
R14323 n1_M2_46500_113460 n1_M2_47580_113460 0.988200
R14324 n1_M2_47580_113460 n1_M2_48660_113460 0.988200
R14325 n1_M2_48660_113460 n1_M2_49740_113460 0.988200
R14326 n1_M2_49740_113460 n1_M2_50820_113460 0.988200
R14327 n1_M2_50820_113460 n1_M2_51900_113460 0.988200
R14328 n1_M2_51900_113460 n1_M2_52980_113460 0.988200
R14329 n1_M2_52980_113460 n1_M2_54060_113460 0.988200
R14330 n1_M2_54060_113460 n1_M2_55140_113460 0.988200
R14331 n1_M2_55140_113460 n1_M2_56220_113460 0.988200
R14332 n1_M2_56220_113460 n1_M2_57300_113460 0.988200
R14333 n1_M2_57300_113460 n1_M2_58380_113460 0.988200
R14334 n1_M2_58380_113460 n1_M2_59460_113460 0.988200
R14335 n1_M2_59460_113460 n1_M2_60540_113460 0.988200
R14336 n1_M2_60540_113460 n1_M2_61620_113460 0.988200
R14337 n1_M2_61620_113460 n1_M2_62700_113460 0.988200
R14338 n1_M2_62700_113460 n1_M2_63780_113460 0.988200
R14339 n1_M2_63780_113460 n1_M2_64860_113460 0.988200
R14340 n1_M2_64860_113460 n1_M2_65940_113460 0.988200
R14341 n1_M2_65940_113460 n1_M2_67020_113460 0.988200
R14342 n1_M2_67020_113460 n1_M2_68100_113460 0.988200
R14343 n1_M2_68100_113460 n1_M2_69180_113460 0.988200
R14344 n1_M2_69180_113460 n1_M2_70260_113460 0.988200
R14345 n1_M2_70260_113460 n1_M2_71340_113460 0.988200
R14346 n1_M2_71340_113460 n1_M2_72420_113460 0.988200
R14347 n1_M2_72420_113460 n1_M2_73500_113460 0.988200
R14348 n1_M2_73500_113460 n1_M2_74580_113460 0.988200
R14349 n1_M2_74580_113460 n1_M2_75660_113460 0.988200
R14350 n1_M2_75660_113460 n1_M2_76740_113460 0.988200
R14351 n1_M2_76740_113460 n1_M2_77820_113460 0.988200
R14352 n1_M2_77820_113460 n1_M2_78900_113460 0.988200
R14353 n1_M2_78900_113460 n1_M2_79980_113460 0.988200
R14354 n1_M2_79980_113460 n1_M2_81060_113460 0.988200
R14355 n1_M2_81060_113460 n1_M2_82140_113460 0.988200
R14356 n1_M2_82140_113460 n1_M2_83220_113460 0.988200
R14357 n1_M2_83220_113460 n1_M2_84300_113460 0.988200
R14358 n1_M2_84300_113460 n1_M2_85380_113460 0.988200
R14359 n1_M2_85380_113460 n1_M2_86460_113460 0.988200
R14360 n1_M2_86460_113460 n1_M2_87540_113460 0.988200
R14361 n1_M2_87540_113460 n1_M2_88620_113460 0.988200
R14362 n1_M2_88620_113460 n1_M2_89700_113460 0.988200
R14363 n1_M2_89700_113460 n1_M2_90780_113460 0.988200
R14364 n1_M2_90780_113460 n1_M2_91860_113460 0.988200
R14365 n1_M2_91860_113460 n1_M2_92940_113460 0.988200
R14366 n1_M2_92940_113460 n1_M2_94020_113460 0.988200
R14367 n1_M2_94020_113460 n1_M2_95100_113460 0.988200
R14368 n1_M2_95100_113460 n1_M2_96180_113460 0.988200
R14369 n1_M2_96180_113460 n1_M2_97260_113460 0.988200
R14370 n1_M2_97260_113460 n1_M2_98340_113460 0.988200
R14371 n1_M2_98340_113460 n1_M2_99420_113460 0.988200
R14372 n1_M2_99420_113460 n1_M2_100500_113460 0.988200
R14373 n1_M2_100500_113460 n1_M2_101580_113460 0.988200
R14374 n1_M2_101580_113460 n1_M2_102660_113460 0.988200
R14375 n1_M2_102660_113460 n1_M2_103740_113460 0.988200
R14376 n1_M2_103740_113460 n1_M2_104820_113460 0.988200
R14377 n1_M2_104820_113460 n1_M2_105900_113460 0.988200
R14378 n1_M2_105900_113460 n1_M2_106980_113460 0.988200
R14379 n1_M2_106980_113460 n1_M2_108060_113460 0.988200
R14380 n1_M2_108060_113460 n1_M2_109140_113460 0.988200
R14381 n1_M2_109140_113460 n1_M2_110220_113460 0.988200
R14382 n1_M2_110220_113460 n1_M2_111300_113460 0.988200
R14383 n1_M2_111300_113460 n1_M2_112380_113460 0.988200
R14384 n1_M2_112380_113460 n1_M2_113460_113460 0.988200
R14385 n1_M2_113460_113460 n1_M2_114540_113460 0.988200
R14386 n1_M2_114540_113460 n1_M2_115620_113460 0.988200
R14387 n1_M2_115620_113460 n1_M2_116700_113460 0.988200
R14388 n1_M2_116700_113460 n1_M2_117780_113460 0.988200
R14389 n1_M2_117780_113460 n1_M2_118860_113460 0.988200
R14390 n1_M2_118860_113460 n1_M2_119940_113460 0.988200
R14391 n1_M2_119940_113460 n1_M2_121020_113460 0.988200
R14392 n1_M2_121020_113460 n1_M2_122100_113460 0.988200
R14393 n1_M2_122100_113460 n1_M2_123180_113460 0.988200
R14394 n1_M2_123180_113460 n1_M2_124260_113460 0.988200
R14395 n1_M2_124260_113460 n1_M2_125340_113460 0.988200
R14396 n1_M2_125340_113460 n1_M2_126420_113460 0.988200
R14397 n1_M2_126420_113460 n1_M2_127500_113460 0.988200
R14398 n1_M2_127500_113460 n1_M2_128580_113460 0.988200
R14399 n1_M2_128580_113460 n1_M2_129660_113460 0.988200
R14400 n1_M2_129660_113460 n1_M2_130740_113460 0.988200
R14401 n1_M2_130740_113460 n1_M2_131820_113460 0.988200
R14402 n1_M2_131820_113460 n1_M2_132900_113460 0.988200
R14403 n1_M2_132900_113460 n1_M2_133980_113460 0.988200
R14404 n1_M2_133980_113460 n1_M2_135060_113460 0.988200
R14405 n1_M2_135060_113460 n1_M2_136140_113460 0.988200
R14406 n1_M2_136140_113460 n1_M2_137220_113460 0.988200
R14407 n1_M2_137220_113460 n1_M2_138300_113460 0.988200
R14408 n1_M2_138300_113460 n1_M2_139380_113460 0.988200
R14409 n1_M2_139380_113460 n1_M2_140460_113460 0.988200
R14410 n1_M2_140460_113460 n1_M2_141540_113460 0.988200
R14411 n1_M2_141540_113460 n1_M2_142620_113460 0.988200
R14412 n1_M2_142620_113460 n1_M2_143700_113460 0.988200
R14413 n1_M2_143700_113460 n1_M2_144780_113460 0.988200
R14414 n1_M2_144780_113460 n1_M2_145860_113460 0.988200
R14415 n1_M2_145860_113460 n1_M2_146940_113460 0.988200
R14416 n1_M2_60_114540 n1_M2_1140_114540 0.988200
R14417 n1_M2_1140_114540 n1_M2_2220_114540 0.988200
R14418 n1_M2_2220_114540 n1_M2_3300_114540 0.988200
R14419 n1_M2_3300_114540 n1_M2_4380_114540 0.988200
R14420 n1_M2_4380_114540 n1_M2_5460_114540 0.988200
R14421 n1_M2_5460_114540 n1_M2_6540_114540 0.988200
R14422 n1_M2_6540_114540 n1_M2_7620_114540 0.988200
R14423 n1_M2_7620_114540 n1_M2_8700_114540 0.988200
R14424 n1_M2_8700_114540 n1_M2_9780_114540 0.988200
R14425 n1_M2_9780_114540 n1_M2_10860_114540 0.988200
R14426 n1_M2_10860_114540 n1_M2_11940_114540 0.988200
R14427 n1_M2_11940_114540 n1_M2_13020_114540 0.988200
R14428 n1_M2_13020_114540 n1_M2_14100_114540 0.988200
R14429 n1_M2_14100_114540 n1_M2_15180_114540 0.988200
R14430 n1_M2_15180_114540 n1_M2_16260_114540 0.988200
R14431 n1_M2_16260_114540 n1_M2_17340_114540 0.988200
R14432 n1_M2_17340_114540 n1_M2_18420_114540 0.988200
R14433 n1_M2_18420_114540 n1_M2_19500_114540 0.988200
R14434 n1_M2_19500_114540 n1_M2_20580_114540 0.988200
R14435 n1_M2_20580_114540 n1_M2_21660_114540 0.988200
R14436 n1_M2_21660_114540 n1_M2_22740_114540 0.988200
R14437 n1_M2_22740_114540 n1_M2_23820_114540 0.988200
R14438 n1_M2_23820_114540 n1_M2_24900_114540 0.988200
R14439 n1_M2_24900_114540 n1_M2_25980_114540 0.988200
R14440 n1_M2_25980_114540 n1_M2_27060_114540 0.988200
R14441 n1_M2_27060_114540 n1_M2_28140_114540 0.988200
R14442 n1_M2_28140_114540 n1_M2_29220_114540 0.988200
R14443 n1_M2_29220_114540 n1_M2_30300_114540 0.988200
R14444 n1_M2_30300_114540 n1_M2_31380_114540 0.988200
R14445 n1_M2_31380_114540 n1_M2_32460_114540 0.988200
R14446 n1_M2_32460_114540 n1_M2_33540_114540 0.988200
R14447 n1_M2_33540_114540 n1_M2_34620_114540 0.988200
R14448 n1_M2_34620_114540 n1_M2_35700_114540 0.988200
R14449 n1_M2_35700_114540 n1_M2_36780_114540 0.988200
R14450 n1_M2_36780_114540 n1_M2_37860_114540 0.988200
R14451 n1_M2_37860_114540 n1_M2_38940_114540 0.988200
R14452 n1_M2_38940_114540 n1_M2_40020_114540 0.988200
R14453 n1_M2_40020_114540 n1_M2_41100_114540 0.988200
R14454 n1_M2_41100_114540 n1_M2_42180_114540 0.988200
R14455 n1_M2_42180_114540 n1_M2_43260_114540 0.988200
R14456 n1_M2_43260_114540 n1_M2_44340_114540 0.988200
R14457 n1_M2_44340_114540 n1_M2_45420_114540 0.988200
R14458 n1_M2_45420_114540 n1_M2_46500_114540 0.988200
R14459 n1_M2_46500_114540 n1_M2_47580_114540 0.988200
R14460 n1_M2_47580_114540 n1_M2_48660_114540 0.988200
R14461 n1_M2_48660_114540 n1_M2_49740_114540 0.988200
R14462 n1_M2_49740_114540 n1_M2_50820_114540 0.988200
R14463 n1_M2_50820_114540 n1_M2_51900_114540 0.988200
R14464 n1_M2_51900_114540 n1_M2_52980_114540 0.988200
R14465 n1_M2_52980_114540 n1_M2_54060_114540 0.988200
R14466 n1_M2_54060_114540 n1_M2_55140_114540 0.988200
R14467 n1_M2_55140_114540 n1_M2_56220_114540 0.988200
R14468 n1_M2_56220_114540 n1_M2_57300_114540 0.988200
R14469 n1_M2_57300_114540 n1_M2_58380_114540 0.988200
R14470 n1_M2_58380_114540 n1_M2_59460_114540 0.988200
R14471 n1_M2_59460_114540 n1_M2_60540_114540 0.988200
R14472 n1_M2_60540_114540 n1_M2_61620_114540 0.988200
R14473 n1_M2_61620_114540 n1_M2_62700_114540 0.988200
R14474 n1_M2_62700_114540 n1_M2_63780_114540 0.988200
R14475 n1_M2_63780_114540 n1_M2_64860_114540 0.988200
R14476 n1_M2_64860_114540 n1_M2_65940_114540 0.988200
R14477 n1_M2_65940_114540 n1_M2_67020_114540 0.988200
R14478 n1_M2_67020_114540 n1_M2_68100_114540 0.988200
R14479 n1_M2_68100_114540 n1_M2_69180_114540 0.988200
R14480 n1_M2_69180_114540 n1_M2_70260_114540 0.988200
R14481 n1_M2_70260_114540 n1_M2_71340_114540 0.988200
R14482 n1_M2_71340_114540 n1_M2_72420_114540 0.988200
R14483 n1_M2_72420_114540 n1_M2_73500_114540 0.988200
R14484 n1_M2_73500_114540 n1_M2_74580_114540 0.988200
R14485 n1_M2_74580_114540 n1_M2_75660_114540 0.988200
R14486 n1_M2_75660_114540 n1_M2_76740_114540 0.988200
R14487 n1_M2_76740_114540 n1_M2_77820_114540 0.988200
R14488 n1_M2_77820_114540 n1_M2_78900_114540 0.988200
R14489 n1_M2_78900_114540 n1_M2_79980_114540 0.988200
R14490 n1_M2_79980_114540 n1_M2_81060_114540 0.988200
R14491 n1_M2_81060_114540 n1_M2_82140_114540 0.988200
R14492 n1_M2_82140_114540 n1_M2_83220_114540 0.988200
R14493 n1_M2_83220_114540 n1_M2_84300_114540 0.988200
R14494 n1_M2_84300_114540 n1_M2_85380_114540 0.988200
R14495 n1_M2_85380_114540 n1_M2_86460_114540 0.988200
R14496 n1_M2_86460_114540 n1_M2_87540_114540 0.988200
R14497 n1_M2_87540_114540 n1_M2_88620_114540 0.988200
R14498 n1_M2_88620_114540 n1_M2_89700_114540 0.988200
R14499 n1_M2_89700_114540 n1_M2_90780_114540 0.988200
R14500 n1_M2_90780_114540 n1_M2_91860_114540 0.988200
R14501 n1_M2_91860_114540 n1_M2_92940_114540 0.988200
R14502 n1_M2_92940_114540 n1_M2_94020_114540 0.988200
R14503 n1_M2_94020_114540 n1_M2_95100_114540 0.988200
R14504 n1_M2_95100_114540 n1_M2_96180_114540 0.988200
R14505 n1_M2_96180_114540 n1_M2_97260_114540 0.988200
R14506 n1_M2_97260_114540 n1_M2_98340_114540 0.988200
R14507 n1_M2_98340_114540 n1_M2_99420_114540 0.988200
R14508 n1_M2_99420_114540 n1_M2_100500_114540 0.988200
R14509 n1_M2_100500_114540 n1_M2_101580_114540 0.988200
R14510 n1_M2_101580_114540 n1_M2_102660_114540 0.988200
R14511 n1_M2_102660_114540 n1_M2_103740_114540 0.988200
R14512 n1_M2_103740_114540 n1_M2_104820_114540 0.988200
R14513 n1_M2_104820_114540 n1_M2_105900_114540 0.988200
R14514 n1_M2_105900_114540 n1_M2_106980_114540 0.988200
R14515 n1_M2_106980_114540 n1_M2_108060_114540 0.988200
R14516 n1_M2_108060_114540 n1_M2_109140_114540 0.988200
R14517 n1_M2_109140_114540 n1_M2_110220_114540 0.988200
R14518 n1_M2_110220_114540 n1_M2_111300_114540 0.988200
R14519 n1_M2_111300_114540 n1_M2_112380_114540 0.988200
R14520 n1_M2_112380_114540 n1_M2_113460_114540 0.988200
R14521 n1_M2_113460_114540 n1_M2_114540_114540 0.988200
R14522 n1_M2_114540_114540 n1_M2_115620_114540 0.988200
R14523 n1_M2_115620_114540 n1_M2_116700_114540 0.988200
R14524 n1_M2_116700_114540 n1_M2_117780_114540 0.988200
R14525 n1_M2_117780_114540 n1_M2_118860_114540 0.988200
R14526 n1_M2_118860_114540 n1_M2_119940_114540 0.988200
R14527 n1_M2_119940_114540 n1_M2_121020_114540 0.988200
R14528 n1_M2_121020_114540 n1_M2_122100_114540 0.988200
R14529 n1_M2_122100_114540 n1_M2_123180_114540 0.988200
R14530 n1_M2_123180_114540 n1_M2_124260_114540 0.988200
R14531 n1_M2_124260_114540 n1_M2_125340_114540 0.988200
R14532 n1_M2_125340_114540 n1_M2_126420_114540 0.988200
R14533 n1_M2_126420_114540 n1_M2_127500_114540 0.988200
R14534 n1_M2_127500_114540 n1_M2_128580_114540 0.988200
R14535 n1_M2_128580_114540 n1_M2_129660_114540 0.988200
R14536 n1_M2_129660_114540 n1_M2_130740_114540 0.988200
R14537 n1_M2_130740_114540 n1_M2_131820_114540 0.988200
R14538 n1_M2_131820_114540 n1_M2_132900_114540 0.988200
R14539 n1_M2_132900_114540 n1_M2_133980_114540 0.988200
R14540 n1_M2_133980_114540 n1_M2_135060_114540 0.988200
R14541 n1_M2_135060_114540 n1_M2_136140_114540 0.988200
R14542 n1_M2_136140_114540 n1_M2_137220_114540 0.988200
R14543 n1_M2_137220_114540 n1_M2_138300_114540 0.988200
R14544 n1_M2_138300_114540 n1_M2_139380_114540 0.988200
R14545 n1_M2_139380_114540 n1_M2_140460_114540 0.988200
R14546 n1_M2_140460_114540 n1_M2_141540_114540 0.988200
R14547 n1_M2_141540_114540 n1_M2_142620_114540 0.988200
R14548 n1_M2_142620_114540 n1_M2_143700_114540 0.988200
R14549 n1_M2_143700_114540 n1_M2_144780_114540 0.988200
R14550 n1_M2_144780_114540 n1_M2_145860_114540 0.988200
R14551 n1_M2_145860_114540 n1_M2_146940_114540 0.988200
R14552 n1_M2_60_115620 n1_M2_1140_115620 0.988200
R14553 n1_M2_1140_115620 n1_M2_2220_115620 0.988200
R14554 n1_M2_2220_115620 n1_M2_3300_115620 0.988200
R14555 n1_M2_3300_115620 n1_M2_4380_115620 0.988200
R14556 n1_M2_4380_115620 n1_M2_5460_115620 0.988200
R14557 n1_M2_5460_115620 n1_M2_6540_115620 0.988200
R14558 n1_M2_6540_115620 n1_M2_7620_115620 0.988200
R14559 n1_M2_7620_115620 n1_M2_8700_115620 0.988200
R14560 n1_M2_8700_115620 n1_M2_9780_115620 0.988200
R14561 n1_M2_9780_115620 n1_M2_10860_115620 0.988200
R14562 n1_M2_10860_115620 n1_M2_11940_115620 0.988200
R14563 n1_M2_11940_115620 n1_M2_13020_115620 0.988200
R14564 n1_M2_13020_115620 n1_M2_14100_115620 0.988200
R14565 n1_M2_14100_115620 n1_M2_15180_115620 0.988200
R14566 n1_M2_15180_115620 n1_M2_16260_115620 0.988200
R14567 n1_M2_16260_115620 n1_M2_17340_115620 0.988200
R14568 n1_M2_17340_115620 n1_M2_18420_115620 0.988200
R14569 n1_M2_18420_115620 n1_M2_19500_115620 0.988200
R14570 n1_M2_19500_115620 n1_M2_20580_115620 0.988200
R14571 n1_M2_20580_115620 n1_M2_21660_115620 0.988200
R14572 n1_M2_21660_115620 n1_M2_22740_115620 0.988200
R14573 n1_M2_22740_115620 n1_M2_23820_115620 0.988200
R14574 n1_M2_23820_115620 n1_M2_24900_115620 0.988200
R14575 n1_M2_24900_115620 n1_M2_25980_115620 0.988200
R14576 n1_M2_25980_115620 n1_M2_27060_115620 0.988200
R14577 n1_M2_27060_115620 n1_M2_28140_115620 0.988200
R14578 n1_M2_28140_115620 n1_M2_29220_115620 0.988200
R14579 n1_M2_29220_115620 n1_M2_30300_115620 0.988200
R14580 n1_M2_30300_115620 n1_M2_31380_115620 0.988200
R14581 n1_M2_31380_115620 n1_M2_32460_115620 0.988200
R14582 n1_M2_32460_115620 n1_M2_33540_115620 0.988200
R14583 n1_M2_33540_115620 n1_M2_34620_115620 0.988200
R14584 n1_M2_34620_115620 n1_M2_35700_115620 0.988200
R14585 n1_M2_35700_115620 n1_M2_36780_115620 0.988200
R14586 n1_M2_36780_115620 n1_M2_37860_115620 0.988200
R14587 n1_M2_37860_115620 n1_M2_38940_115620 0.988200
R14588 n1_M2_38940_115620 n1_M2_40020_115620 0.988200
R14589 n1_M2_40020_115620 n1_M2_41100_115620 0.988200
R14590 n1_M2_41100_115620 n1_M2_42180_115620 0.988200
R14591 n1_M2_42180_115620 n1_M2_43260_115620 0.988200
R14592 n1_M2_43260_115620 n1_M2_44340_115620 0.988200
R14593 n1_M2_44340_115620 n1_M2_45420_115620 0.988200
R14594 n1_M2_45420_115620 n1_M2_46500_115620 0.988200
R14595 n1_M2_46500_115620 n1_M2_47580_115620 0.988200
R14596 n1_M2_47580_115620 n1_M2_48660_115620 0.988200
R14597 n1_M2_48660_115620 n1_M2_49740_115620 0.988200
R14598 n1_M2_49740_115620 n1_M2_50820_115620 0.988200
R14599 n1_M2_50820_115620 n1_M2_51900_115620 0.988200
R14600 n1_M2_51900_115620 n1_M2_52980_115620 0.988200
R14601 n1_M2_52980_115620 n1_M2_54060_115620 0.988200
R14602 n1_M2_54060_115620 n1_M2_55140_115620 0.988200
R14603 n1_M2_55140_115620 n1_M2_56220_115620 0.988200
R14604 n1_M2_56220_115620 n1_M2_57300_115620 0.988200
R14605 n1_M2_57300_115620 n1_M2_58380_115620 0.988200
R14606 n1_M2_58380_115620 n1_M2_59460_115620 0.988200
R14607 n1_M2_59460_115620 n1_M2_60540_115620 0.988200
R14608 n1_M2_60540_115620 n1_M2_61620_115620 0.988200
R14609 n1_M2_61620_115620 n1_M2_62700_115620 0.988200
R14610 n1_M2_62700_115620 n1_M2_63780_115620 0.988200
R14611 n1_M2_63780_115620 n1_M2_64860_115620 0.988200
R14612 n1_M2_64860_115620 n1_M2_65940_115620 0.988200
R14613 n1_M2_65940_115620 n1_M2_67020_115620 0.988200
R14614 n1_M2_67020_115620 n1_M2_68100_115620 0.988200
R14615 n1_M2_68100_115620 n1_M2_69180_115620 0.988200
R14616 n1_M2_69180_115620 n1_M2_70260_115620 0.988200
R14617 n1_M2_70260_115620 n1_M2_71340_115620 0.988200
R14618 n1_M2_71340_115620 n1_M2_72420_115620 0.988200
R14619 n1_M2_72420_115620 n1_M2_73500_115620 0.988200
R14620 n1_M2_73500_115620 n1_M2_74580_115620 0.988200
R14621 n1_M2_74580_115620 n1_M2_75660_115620 0.988200
R14622 n1_M2_75660_115620 n1_M2_76740_115620 0.988200
R14623 n1_M2_76740_115620 n1_M2_77820_115620 0.988200
R14624 n1_M2_77820_115620 n1_M2_78900_115620 0.988200
R14625 n1_M2_78900_115620 n1_M2_79980_115620 0.988200
R14626 n1_M2_79980_115620 n1_M2_81060_115620 0.988200
R14627 n1_M2_81060_115620 n1_M2_82140_115620 0.988200
R14628 n1_M2_82140_115620 n1_M2_83220_115620 0.988200
R14629 n1_M2_83220_115620 n1_M2_84300_115620 0.988200
R14630 n1_M2_84300_115620 n1_M2_85380_115620 0.988200
R14631 n1_M2_85380_115620 n1_M2_86460_115620 0.988200
R14632 n1_M2_86460_115620 n1_M2_87540_115620 0.988200
R14633 n1_M2_87540_115620 n1_M2_88620_115620 0.988200
R14634 n1_M2_88620_115620 n1_M2_89700_115620 0.988200
R14635 n1_M2_89700_115620 n1_M2_90780_115620 0.988200
R14636 n1_M2_90780_115620 n1_M2_91860_115620 0.988200
R14637 n1_M2_91860_115620 n1_M2_92940_115620 0.988200
R14638 n1_M2_92940_115620 n1_M2_94020_115620 0.988200
R14639 n1_M2_94020_115620 n1_M2_95100_115620 0.988200
R14640 n1_M2_95100_115620 n1_M2_96180_115620 0.988200
R14641 n1_M2_96180_115620 n1_M2_97260_115620 0.988200
R14642 n1_M2_97260_115620 n1_M2_98340_115620 0.988200
R14643 n1_M2_98340_115620 n1_M2_99420_115620 0.988200
R14644 n1_M2_99420_115620 n1_M2_100500_115620 0.988200
R14645 n1_M2_100500_115620 n1_M2_101580_115620 0.988200
R14646 n1_M2_101580_115620 n1_M2_102660_115620 0.988200
R14647 n1_M2_102660_115620 n1_M2_103740_115620 0.988200
R14648 n1_M2_103740_115620 n1_M2_104820_115620 0.988200
R14649 n1_M2_104820_115620 n1_M2_105900_115620 0.988200
R14650 n1_M2_105900_115620 n1_M2_106980_115620 0.988200
R14651 n1_M2_106980_115620 n1_M2_108060_115620 0.988200
R14652 n1_M2_108060_115620 n1_M2_109140_115620 0.988200
R14653 n1_M2_109140_115620 n1_M2_110220_115620 0.988200
R14654 n1_M2_110220_115620 n1_M2_111300_115620 0.988200
R14655 n1_M2_111300_115620 n1_M2_112380_115620 0.988200
R14656 n1_M2_112380_115620 n1_M2_113460_115620 0.988200
R14657 n1_M2_113460_115620 n1_M2_114540_115620 0.988200
R14658 n1_M2_114540_115620 n1_M2_115620_115620 0.988200
R14659 n1_M2_115620_115620 n1_M2_116700_115620 0.988200
R14660 n1_M2_116700_115620 n1_M2_117780_115620 0.988200
R14661 n1_M2_117780_115620 n1_M2_118860_115620 0.988200
R14662 n1_M2_118860_115620 n1_M2_119940_115620 0.988200
R14663 n1_M2_119940_115620 n1_M2_121020_115620 0.988200
R14664 n1_M2_121020_115620 n1_M2_122100_115620 0.988200
R14665 n1_M2_122100_115620 n1_M2_123180_115620 0.988200
R14666 n1_M2_123180_115620 n1_M2_124260_115620 0.988200
R14667 n1_M2_124260_115620 n1_M2_125340_115620 0.988200
R14668 n1_M2_125340_115620 n1_M2_126420_115620 0.988200
R14669 n1_M2_126420_115620 n1_M2_127500_115620 0.988200
R14670 n1_M2_127500_115620 n1_M2_128580_115620 0.988200
R14671 n1_M2_128580_115620 n1_M2_129660_115620 0.988200
R14672 n1_M2_129660_115620 n1_M2_130740_115620 0.988200
R14673 n1_M2_130740_115620 n1_M2_131820_115620 0.988200
R14674 n1_M2_131820_115620 n1_M2_132900_115620 0.988200
R14675 n1_M2_132900_115620 n1_M2_133980_115620 0.988200
R14676 n1_M2_133980_115620 n1_M2_135060_115620 0.988200
R14677 n1_M2_135060_115620 n1_M2_136140_115620 0.988200
R14678 n1_M2_136140_115620 n1_M2_137220_115620 0.988200
R14679 n1_M2_137220_115620 n1_M2_138300_115620 0.988200
R14680 n1_M2_138300_115620 n1_M2_139380_115620 0.988200
R14681 n1_M2_139380_115620 n1_M2_140460_115620 0.988200
R14682 n1_M2_140460_115620 n1_M2_141540_115620 0.988200
R14683 n1_M2_141540_115620 n1_M2_142620_115620 0.988200
R14684 n1_M2_142620_115620 n1_M2_143700_115620 0.988200
R14685 n1_M2_143700_115620 n1_M2_144780_115620 0.988200
R14686 n1_M2_144780_115620 n1_M2_145860_115620 0.988200
R14687 n1_M2_145860_115620 n1_M2_146940_115620 0.988200
R14688 n1_M2_60_116700 n1_M2_1140_116700 0.988200
R14689 n1_M2_1140_116700 n1_M2_2220_116700 0.988200
R14690 n1_M2_2220_116700 n1_M2_3300_116700 0.988200
R14691 n1_M2_3300_116700 n1_M2_4380_116700 0.988200
R14692 n1_M2_4380_116700 n1_M2_5460_116700 0.988200
R14693 n1_M2_5460_116700 n1_M2_6540_116700 0.988200
R14694 n1_M2_6540_116700 n1_M2_7620_116700 0.988200
R14695 n1_M2_7620_116700 n1_M2_8700_116700 0.988200
R14696 n1_M2_8700_116700 n1_M2_9780_116700 0.988200
R14697 n1_M2_9780_116700 n1_M2_10860_116700 0.988200
R14698 n1_M2_10860_116700 n1_M2_11940_116700 0.988200
R14699 n1_M2_11940_116700 n1_M2_13020_116700 0.988200
R14700 n1_M2_13020_116700 n1_M2_14100_116700 0.988200
R14701 n1_M2_14100_116700 n1_M2_15180_116700 0.988200
R14702 n1_M2_15180_116700 n1_M2_16260_116700 0.988200
R14703 n1_M2_16260_116700 n1_M2_17340_116700 0.988200
R14704 n1_M2_17340_116700 n1_M2_18420_116700 0.988200
R14705 n1_M2_18420_116700 n1_M2_19500_116700 0.988200
R14706 n1_M2_19500_116700 n1_M2_20580_116700 0.988200
R14707 n1_M2_20580_116700 n1_M2_21660_116700 0.988200
R14708 n1_M2_21660_116700 n1_M2_22740_116700 0.988200
R14709 n1_M2_22740_116700 n1_M2_23820_116700 0.988200
R14710 n1_M2_23820_116700 n1_M2_24900_116700 0.988200
R14711 n1_M2_24900_116700 n1_M2_25980_116700 0.988200
R14712 n1_M2_25980_116700 n1_M2_27060_116700 0.988200
R14713 n1_M2_27060_116700 n1_M2_28140_116700 0.988200
R14714 n1_M2_28140_116700 n1_M2_29220_116700 0.988200
R14715 n1_M2_29220_116700 n1_M2_30300_116700 0.988200
R14716 n1_M2_30300_116700 n1_M2_31380_116700 0.988200
R14717 n1_M2_31380_116700 n1_M2_32460_116700 0.988200
R14718 n1_M2_32460_116700 n1_M2_33540_116700 0.988200
R14719 n1_M2_33540_116700 n1_M2_34620_116700 0.988200
R14720 n1_M2_34620_116700 n1_M2_35700_116700 0.988200
R14721 n1_M2_35700_116700 n1_M2_36780_116700 0.988200
R14722 n1_M2_36780_116700 n1_M2_37860_116700 0.988200
R14723 n1_M2_37860_116700 n1_M2_38940_116700 0.988200
R14724 n1_M2_38940_116700 n1_M2_40020_116700 0.988200
R14725 n1_M2_40020_116700 n1_M2_41100_116700 0.988200
R14726 n1_M2_41100_116700 n1_M2_42180_116700 0.988200
R14727 n1_M2_42180_116700 n1_M2_43260_116700 0.988200
R14728 n1_M2_43260_116700 n1_M2_44340_116700 0.988200
R14729 n1_M2_44340_116700 n1_M2_45420_116700 0.988200
R14730 n1_M2_45420_116700 n1_M2_46500_116700 0.988200
R14731 n1_M2_46500_116700 n1_M2_47580_116700 0.988200
R14732 n1_M2_47580_116700 n1_M2_48660_116700 0.988200
R14733 n1_M2_48660_116700 n1_M2_49740_116700 0.988200
R14734 n1_M2_49740_116700 n1_M2_50820_116700 0.988200
R14735 n1_M2_50820_116700 n1_M2_51900_116700 0.988200
R14736 n1_M2_51900_116700 n1_M2_52980_116700 0.988200
R14737 n1_M2_52980_116700 n1_M2_54060_116700 0.988200
R14738 n1_M2_54060_116700 n1_M2_55140_116700 0.988200
R14739 n1_M2_55140_116700 n1_M2_56220_116700 0.988200
R14740 n1_M2_56220_116700 n1_M2_57300_116700 0.988200
R14741 n1_M2_57300_116700 n1_M2_58380_116700 0.988200
R14742 n1_M2_58380_116700 n1_M2_59460_116700 0.988200
R14743 n1_M2_59460_116700 n1_M2_60540_116700 0.988200
R14744 n1_M2_60540_116700 n1_M2_61620_116700 0.988200
R14745 n1_M2_61620_116700 n1_M2_62700_116700 0.988200
R14746 n1_M2_62700_116700 n1_M2_63780_116700 0.988200
R14747 n1_M2_63780_116700 n1_M2_64860_116700 0.988200
R14748 n1_M2_64860_116700 n1_M2_65940_116700 0.988200
R14749 n1_M2_65940_116700 n1_M2_67020_116700 0.988200
R14750 n1_M2_67020_116700 n1_M2_68100_116700 0.988200
R14751 n1_M2_68100_116700 n1_M2_69180_116700 0.988200
R14752 n1_M2_69180_116700 n1_M2_70260_116700 0.988200
R14753 n1_M2_70260_116700 n1_M2_71340_116700 0.988200
R14754 n1_M2_71340_116700 n1_M2_72420_116700 0.988200
R14755 n1_M2_72420_116700 n1_M2_73500_116700 0.988200
R14756 n1_M2_73500_116700 n1_M2_74580_116700 0.988200
R14757 n1_M2_74580_116700 n1_M2_75660_116700 0.988200
R14758 n1_M2_75660_116700 n1_M2_76740_116700 0.988200
R14759 n1_M2_76740_116700 n1_M2_77820_116700 0.988200
R14760 n1_M2_77820_116700 n1_M2_78900_116700 0.988200
R14761 n1_M2_78900_116700 n1_M2_79980_116700 0.988200
R14762 n1_M2_79980_116700 n1_M2_81060_116700 0.988200
R14763 n1_M2_81060_116700 n1_M2_82140_116700 0.988200
R14764 n1_M2_82140_116700 n1_M2_83220_116700 0.988200
R14765 n1_M2_83220_116700 n1_M2_84300_116700 0.988200
R14766 n1_M2_84300_116700 n1_M2_85380_116700 0.988200
R14767 n1_M2_85380_116700 n1_M2_86460_116700 0.988200
R14768 n1_M2_86460_116700 n1_M2_87540_116700 0.988200
R14769 n1_M2_87540_116700 n1_M2_88620_116700 0.988200
R14770 n1_M2_88620_116700 n1_M2_89700_116700 0.988200
R14771 n1_M2_89700_116700 n1_M2_90780_116700 0.988200
R14772 n1_M2_90780_116700 n1_M2_91860_116700 0.988200
R14773 n1_M2_91860_116700 n1_M2_92940_116700 0.988200
R14774 n1_M2_92940_116700 n1_M2_94020_116700 0.988200
R14775 n1_M2_94020_116700 n1_M2_95100_116700 0.988200
R14776 n1_M2_95100_116700 n1_M2_96180_116700 0.988200
R14777 n1_M2_96180_116700 n1_M2_97260_116700 0.988200
R14778 n1_M2_97260_116700 n1_M2_98340_116700 0.988200
R14779 n1_M2_98340_116700 n1_M2_99420_116700 0.988200
R14780 n1_M2_99420_116700 n1_M2_100500_116700 0.988200
R14781 n1_M2_100500_116700 n1_M2_101580_116700 0.988200
R14782 n1_M2_101580_116700 n1_M2_102660_116700 0.988200
R14783 n1_M2_102660_116700 n1_M2_103740_116700 0.988200
R14784 n1_M2_103740_116700 n1_M2_104820_116700 0.988200
R14785 n1_M2_104820_116700 n1_M2_105900_116700 0.988200
R14786 n1_M2_105900_116700 n1_M2_106980_116700 0.988200
R14787 n1_M2_106980_116700 n1_M2_108060_116700 0.988200
R14788 n1_M2_108060_116700 n1_M2_109140_116700 0.988200
R14789 n1_M2_109140_116700 n1_M2_110220_116700 0.988200
R14790 n1_M2_110220_116700 n1_M2_111300_116700 0.988200
R14791 n1_M2_111300_116700 n1_M2_112380_116700 0.988200
R14792 n1_M2_112380_116700 n1_M2_113460_116700 0.988200
R14793 n1_M2_113460_116700 n1_M2_114540_116700 0.988200
R14794 n1_M2_114540_116700 n1_M2_115620_116700 0.988200
R14795 n1_M2_115620_116700 n1_M2_116700_116700 0.988200
R14796 n1_M2_116700_116700 n1_M2_117780_116700 0.988200
R14797 n1_M2_117780_116700 n1_M2_118860_116700 0.988200
R14798 n1_M2_118860_116700 n1_M2_119940_116700 0.988200
R14799 n1_M2_119940_116700 n1_M2_121020_116700 0.988200
R14800 n1_M2_121020_116700 n1_M2_122100_116700 0.988200
R14801 n1_M2_122100_116700 n1_M2_123180_116700 0.988200
R14802 n1_M2_123180_116700 n1_M2_124260_116700 0.988200
R14803 n1_M2_124260_116700 n1_M2_125340_116700 0.988200
R14804 n1_M2_125340_116700 n1_M2_126420_116700 0.988200
R14805 n1_M2_126420_116700 n1_M2_127500_116700 0.988200
R14806 n1_M2_127500_116700 n1_M2_128580_116700 0.988200
R14807 n1_M2_128580_116700 n1_M2_129660_116700 0.988200
R14808 n1_M2_129660_116700 n1_M2_130740_116700 0.988200
R14809 n1_M2_130740_116700 n1_M2_131820_116700 0.988200
R14810 n1_M2_131820_116700 n1_M2_132900_116700 0.988200
R14811 n1_M2_132900_116700 n1_M2_133980_116700 0.988200
R14812 n1_M2_133980_116700 n1_M2_135060_116700 0.988200
R14813 n1_M2_135060_116700 n1_M2_136140_116700 0.988200
R14814 n1_M2_136140_116700 n1_M2_137220_116700 0.988200
R14815 n1_M2_137220_116700 n1_M2_138300_116700 0.988200
R14816 n1_M2_138300_116700 n1_M2_139380_116700 0.988200
R14817 n1_M2_139380_116700 n1_M2_140460_116700 0.988200
R14818 n1_M2_140460_116700 n1_M2_141540_116700 0.988200
R14819 n1_M2_141540_116700 n1_M2_142620_116700 0.988200
R14820 n1_M2_142620_116700 n1_M2_143700_116700 0.988200
R14821 n1_M2_143700_116700 n1_M2_144780_116700 0.988200
R14822 n1_M2_144780_116700 n1_M2_145860_116700 0.988200
R14823 n1_M2_145860_116700 n1_M2_146940_116700 0.988200
R14824 n1_M2_60_117780 n1_M2_1140_117780 0.988200
R14825 n1_M2_1140_117780 n1_M2_2220_117780 0.988200
R14826 n1_M2_2220_117780 n1_M2_3300_117780 0.988200
R14827 n1_M2_3300_117780 n1_M2_4380_117780 0.988200
R14828 n1_M2_4380_117780 n1_M2_5460_117780 0.988200
R14829 n1_M2_5460_117780 n1_M2_6540_117780 0.988200
R14830 n1_M2_6540_117780 n1_M2_7620_117780 0.988200
R14831 n1_M2_7620_117780 n1_M2_8700_117780 0.988200
R14832 n1_M2_8700_117780 n1_M2_9780_117780 0.988200
R14833 n1_M2_9780_117780 n1_M2_10860_117780 0.988200
R14834 n1_M2_10860_117780 n1_M2_11940_117780 0.988200
R14835 n1_M2_11940_117780 n1_M2_13020_117780 0.988200
R14836 n1_M2_13020_117780 n1_M2_14100_117780 0.988200
R14837 n1_M2_14100_117780 n1_M2_15180_117780 0.988200
R14838 n1_M2_15180_117780 n1_M2_16260_117780 0.988200
R14839 n1_M2_16260_117780 n1_M2_17340_117780 0.988200
R14840 n1_M2_17340_117780 n1_M2_18420_117780 0.988200
R14841 n1_M2_18420_117780 n1_M2_19500_117780 0.988200
R14842 n1_M2_19500_117780 n1_M2_20580_117780 0.988200
R14843 n1_M2_20580_117780 n1_M2_21660_117780 0.988200
R14844 n1_M2_21660_117780 n1_M2_22740_117780 0.988200
R14845 n1_M2_22740_117780 n1_M2_23820_117780 0.988200
R14846 n1_M2_23820_117780 n1_M2_24900_117780 0.988200
R14847 n1_M2_24900_117780 n1_M2_25980_117780 0.988200
R14848 n1_M2_25980_117780 n1_M2_27060_117780 0.988200
R14849 n1_M2_27060_117780 n1_M2_28140_117780 0.988200
R14850 n1_M2_28140_117780 n1_M2_29220_117780 0.988200
R14851 n1_M2_29220_117780 n1_M2_30300_117780 0.988200
R14852 n1_M2_30300_117780 n1_M2_31380_117780 0.988200
R14853 n1_M2_31380_117780 n1_M2_32460_117780 0.988200
R14854 n1_M2_32460_117780 n1_M2_33540_117780 0.988200
R14855 n1_M2_33540_117780 n1_M2_34620_117780 0.988200
R14856 n1_M2_34620_117780 n1_M2_35700_117780 0.988200
R14857 n1_M2_35700_117780 n1_M2_36780_117780 0.988200
R14858 n1_M2_36780_117780 n1_M2_37860_117780 0.988200
R14859 n1_M2_37860_117780 n1_M2_38940_117780 0.988200
R14860 n1_M2_38940_117780 n1_M2_40020_117780 0.988200
R14861 n1_M2_40020_117780 n1_M2_41100_117780 0.988200
R14862 n1_M2_41100_117780 n1_M2_42180_117780 0.988200
R14863 n1_M2_42180_117780 n1_M2_43260_117780 0.988200
R14864 n1_M2_43260_117780 n1_M2_44340_117780 0.988200
R14865 n1_M2_44340_117780 n1_M2_45420_117780 0.988200
R14866 n1_M2_45420_117780 n1_M2_46500_117780 0.988200
R14867 n1_M2_46500_117780 n1_M2_47580_117780 0.988200
R14868 n1_M2_47580_117780 n1_M2_48660_117780 0.988200
R14869 n1_M2_48660_117780 n1_M2_49740_117780 0.988200
R14870 n1_M2_49740_117780 n1_M2_50820_117780 0.988200
R14871 n1_M2_50820_117780 n1_M2_51900_117780 0.988200
R14872 n1_M2_51900_117780 n1_M2_52980_117780 0.988200
R14873 n1_M2_52980_117780 n1_M2_54060_117780 0.988200
R14874 n1_M2_54060_117780 n1_M2_55140_117780 0.988200
R14875 n1_M2_55140_117780 n1_M2_56220_117780 0.988200
R14876 n1_M2_56220_117780 n1_M2_57300_117780 0.988200
R14877 n1_M2_57300_117780 n1_M2_58380_117780 0.988200
R14878 n1_M2_58380_117780 n1_M2_59460_117780 0.988200
R14879 n1_M2_59460_117780 n1_M2_60540_117780 0.988200
R14880 n1_M2_60540_117780 n1_M2_61620_117780 0.988200
R14881 n1_M2_61620_117780 n1_M2_62700_117780 0.988200
R14882 n1_M2_62700_117780 n1_M2_63780_117780 0.988200
R14883 n1_M2_63780_117780 n1_M2_64860_117780 0.988200
R14884 n1_M2_64860_117780 n1_M2_65940_117780 0.988200
R14885 n1_M2_65940_117780 n1_M2_67020_117780 0.988200
R14886 n1_M2_67020_117780 n1_M2_68100_117780 0.988200
R14887 n1_M2_68100_117780 n1_M2_69180_117780 0.988200
R14888 n1_M2_69180_117780 n1_M2_70260_117780 0.988200
R14889 n1_M2_70260_117780 n1_M2_71340_117780 0.988200
R14890 n1_M2_71340_117780 n1_M2_72420_117780 0.988200
R14891 n1_M2_72420_117780 n1_M2_73500_117780 0.988200
R14892 n1_M2_73500_117780 n1_M2_74580_117780 0.988200
R14893 n1_M2_74580_117780 n1_M2_75660_117780 0.988200
R14894 n1_M2_75660_117780 n1_M2_76740_117780 0.988200
R14895 n1_M2_76740_117780 n1_M2_77820_117780 0.988200
R14896 n1_M2_77820_117780 n1_M2_78900_117780 0.988200
R14897 n1_M2_78900_117780 n1_M2_79980_117780 0.988200
R14898 n1_M2_79980_117780 n1_M2_81060_117780 0.988200
R14899 n1_M2_81060_117780 n1_M2_82140_117780 0.988200
R14900 n1_M2_82140_117780 n1_M2_83220_117780 0.988200
R14901 n1_M2_83220_117780 n1_M2_84300_117780 0.988200
R14902 n1_M2_84300_117780 n1_M2_85380_117780 0.988200
R14903 n1_M2_85380_117780 n1_M2_86460_117780 0.988200
R14904 n1_M2_86460_117780 n1_M2_87540_117780 0.988200
R14905 n1_M2_87540_117780 n1_M2_88620_117780 0.988200
R14906 n1_M2_88620_117780 n1_M2_89700_117780 0.988200
R14907 n1_M2_89700_117780 n1_M2_90780_117780 0.988200
R14908 n1_M2_90780_117780 n1_M2_91860_117780 0.988200
R14909 n1_M2_91860_117780 n1_M2_92940_117780 0.988200
R14910 n1_M2_92940_117780 n1_M2_94020_117780 0.988200
R14911 n1_M2_94020_117780 n1_M2_95100_117780 0.988200
R14912 n1_M2_95100_117780 n1_M2_96180_117780 0.988200
R14913 n1_M2_96180_117780 n1_M2_97260_117780 0.988200
R14914 n1_M2_97260_117780 n1_M2_98340_117780 0.988200
R14915 n1_M2_98340_117780 n1_M2_99420_117780 0.988200
R14916 n1_M2_99420_117780 n1_M2_100500_117780 0.988200
R14917 n1_M2_100500_117780 n1_M2_101580_117780 0.988200
R14918 n1_M2_101580_117780 n1_M2_102660_117780 0.988200
R14919 n1_M2_102660_117780 n1_M2_103740_117780 0.988200
R14920 n1_M2_103740_117780 n1_M2_104820_117780 0.988200
R14921 n1_M2_104820_117780 n1_M2_105900_117780 0.988200
R14922 n1_M2_105900_117780 n1_M2_106980_117780 0.988200
R14923 n1_M2_106980_117780 n1_M2_108060_117780 0.988200
R14924 n1_M2_108060_117780 n1_M2_109140_117780 0.988200
R14925 n1_M2_109140_117780 n1_M2_110220_117780 0.988200
R14926 n1_M2_110220_117780 n1_M2_111300_117780 0.988200
R14927 n1_M2_111300_117780 n1_M2_112380_117780 0.988200
R14928 n1_M2_112380_117780 n1_M2_113460_117780 0.988200
R14929 n1_M2_113460_117780 n1_M2_114540_117780 0.988200
R14930 n1_M2_114540_117780 n1_M2_115620_117780 0.988200
R14931 n1_M2_115620_117780 n1_M2_116700_117780 0.988200
R14932 n1_M2_116700_117780 n1_M2_117780_117780 0.988200
R14933 n1_M2_117780_117780 n1_M2_118860_117780 0.988200
R14934 n1_M2_118860_117780 n1_M2_119940_117780 0.988200
R14935 n1_M2_119940_117780 n1_M2_121020_117780 0.988200
R14936 n1_M2_121020_117780 n1_M2_122100_117780 0.988200
R14937 n1_M2_122100_117780 n1_M2_123180_117780 0.988200
R14938 n1_M2_123180_117780 n1_M2_124260_117780 0.988200
R14939 n1_M2_124260_117780 n1_M2_125340_117780 0.988200
R14940 n1_M2_125340_117780 n1_M2_126420_117780 0.988200
R14941 n1_M2_126420_117780 n1_M2_127500_117780 0.988200
R14942 n1_M2_127500_117780 n1_M2_128580_117780 0.988200
R14943 n1_M2_128580_117780 n1_M2_129660_117780 0.988200
R14944 n1_M2_129660_117780 n1_M2_130740_117780 0.988200
R14945 n1_M2_130740_117780 n1_M2_131820_117780 0.988200
R14946 n1_M2_131820_117780 n1_M2_132900_117780 0.988200
R14947 n1_M2_132900_117780 n1_M2_133980_117780 0.988200
R14948 n1_M2_133980_117780 n1_M2_135060_117780 0.988200
R14949 n1_M2_135060_117780 n1_M2_136140_117780 0.988200
R14950 n1_M2_136140_117780 n1_M2_137220_117780 0.988200
R14951 n1_M2_137220_117780 n1_M2_138300_117780 0.988200
R14952 n1_M2_138300_117780 n1_M2_139380_117780 0.988200
R14953 n1_M2_139380_117780 n1_M2_140460_117780 0.988200
R14954 n1_M2_140460_117780 n1_M2_141540_117780 0.988200
R14955 n1_M2_141540_117780 n1_M2_142620_117780 0.988200
R14956 n1_M2_142620_117780 n1_M2_143700_117780 0.988200
R14957 n1_M2_143700_117780 n1_M2_144780_117780 0.988200
R14958 n1_M2_144780_117780 n1_M2_145860_117780 0.988200
R14959 n1_M2_145860_117780 n1_M2_146940_117780 0.988200
R14960 n1_M2_60_118860 n1_M2_1140_118860 0.988200
R14961 n1_M2_1140_118860 n1_M2_2220_118860 0.988200
R14962 n1_M2_2220_118860 n1_M2_3300_118860 0.988200
R14963 n1_M2_3300_118860 n1_M2_4380_118860 0.988200
R14964 n1_M2_4380_118860 n1_M2_5460_118860 0.988200
R14965 n1_M2_5460_118860 n1_M2_6540_118860 0.988200
R14966 n1_M2_6540_118860 n1_M2_7620_118860 0.988200
R14967 n1_M2_7620_118860 n1_M2_8700_118860 0.988200
R14968 n1_M2_8700_118860 n1_M2_9780_118860 0.988200
R14969 n1_M2_9780_118860 n1_M2_10860_118860 0.988200
R14970 n1_M2_10860_118860 n1_M2_11940_118860 0.988200
R14971 n1_M2_11940_118860 n1_M2_13020_118860 0.988200
R14972 n1_M2_13020_118860 n1_M2_14100_118860 0.988200
R14973 n1_M2_14100_118860 n1_M2_15180_118860 0.988200
R14974 n1_M2_15180_118860 n1_M2_16260_118860 0.988200
R14975 n1_M2_16260_118860 n1_M2_17340_118860 0.988200
R14976 n1_M2_17340_118860 n1_M2_18420_118860 0.988200
R14977 n1_M2_18420_118860 n1_M2_19500_118860 0.988200
R14978 n1_M2_19500_118860 n1_M2_20580_118860 0.988200
R14979 n1_M2_20580_118860 n1_M2_21660_118860 0.988200
R14980 n1_M2_21660_118860 n1_M2_22740_118860 0.988200
R14981 n1_M2_22740_118860 n1_M2_23820_118860 0.988200
R14982 n1_M2_23820_118860 n1_M2_24900_118860 0.988200
R14983 n1_M2_24900_118860 n1_M2_25980_118860 0.988200
R14984 n1_M2_25980_118860 n1_M2_27060_118860 0.988200
R14985 n1_M2_27060_118860 n1_M2_28140_118860 0.988200
R14986 n1_M2_28140_118860 n1_M2_29220_118860 0.988200
R14987 n1_M2_29220_118860 n1_M2_30300_118860 0.988200
R14988 n1_M2_30300_118860 n1_M2_31380_118860 0.988200
R14989 n1_M2_31380_118860 n1_M2_32460_118860 0.988200
R14990 n1_M2_32460_118860 n1_M2_33540_118860 0.988200
R14991 n1_M2_33540_118860 n1_M2_34620_118860 0.988200
R14992 n1_M2_34620_118860 n1_M2_35700_118860 0.988200
R14993 n1_M2_35700_118860 n1_M2_36780_118860 0.988200
R14994 n1_M2_36780_118860 n1_M2_37860_118860 0.988200
R14995 n1_M2_37860_118860 n1_M2_38940_118860 0.988200
R14996 n1_M2_38940_118860 n1_M2_40020_118860 0.988200
R14997 n1_M2_40020_118860 n1_M2_41100_118860 0.988200
R14998 n1_M2_41100_118860 n1_M2_42180_118860 0.988200
R14999 n1_M2_42180_118860 n1_M2_43260_118860 0.988200
R15000 n1_M2_43260_118860 n1_M2_44340_118860 0.988200
R15001 n1_M2_44340_118860 n1_M2_45420_118860 0.988200
R15002 n1_M2_45420_118860 n1_M2_46500_118860 0.988200
R15003 n1_M2_46500_118860 n1_M2_47580_118860 0.988200
R15004 n1_M2_47580_118860 n1_M2_48660_118860 0.988200
R15005 n1_M2_48660_118860 n1_M2_49740_118860 0.988200
R15006 n1_M2_49740_118860 n1_M2_50820_118860 0.988200
R15007 n1_M2_50820_118860 n1_M2_51900_118860 0.988200
R15008 n1_M2_51900_118860 n1_M2_52980_118860 0.988200
R15009 n1_M2_52980_118860 n1_M2_54060_118860 0.988200
R15010 n1_M2_54060_118860 n1_M2_55140_118860 0.988200
R15011 n1_M2_55140_118860 n1_M2_56220_118860 0.988200
R15012 n1_M2_56220_118860 n1_M2_57300_118860 0.988200
R15013 n1_M2_57300_118860 n1_M2_58380_118860 0.988200
R15014 n1_M2_58380_118860 n1_M2_59460_118860 0.988200
R15015 n1_M2_59460_118860 n1_M2_60540_118860 0.988200
R15016 n1_M2_60540_118860 n1_M2_61620_118860 0.988200
R15017 n1_M2_61620_118860 n1_M2_62700_118860 0.988200
R15018 n1_M2_62700_118860 n1_M2_63780_118860 0.988200
R15019 n1_M2_63780_118860 n1_M2_64860_118860 0.988200
R15020 n1_M2_64860_118860 n1_M2_65940_118860 0.988200
R15021 n1_M2_65940_118860 n1_M2_67020_118860 0.988200
R15022 n1_M2_67020_118860 n1_M2_68100_118860 0.988200
R15023 n1_M2_68100_118860 n1_M2_69180_118860 0.988200
R15024 n1_M2_69180_118860 n1_M2_70260_118860 0.988200
R15025 n1_M2_70260_118860 n1_M2_71340_118860 0.988200
R15026 n1_M2_71340_118860 n1_M2_72420_118860 0.988200
R15027 n1_M2_72420_118860 n1_M2_73500_118860 0.988200
R15028 n1_M2_73500_118860 n1_M2_74580_118860 0.988200
R15029 n1_M2_74580_118860 n1_M2_75660_118860 0.988200
R15030 n1_M2_75660_118860 n1_M2_76740_118860 0.988200
R15031 n1_M2_76740_118860 n1_M2_77820_118860 0.988200
R15032 n1_M2_77820_118860 n1_M2_78900_118860 0.988200
R15033 n1_M2_78900_118860 n1_M2_79980_118860 0.988200
R15034 n1_M2_79980_118860 n1_M2_81060_118860 0.988200
R15035 n1_M2_81060_118860 n1_M2_82140_118860 0.988200
R15036 n1_M2_82140_118860 n1_M2_83220_118860 0.988200
R15037 n1_M2_83220_118860 n1_M2_84300_118860 0.988200
R15038 n1_M2_84300_118860 n1_M2_85380_118860 0.988200
R15039 n1_M2_85380_118860 n1_M2_86460_118860 0.988200
R15040 n1_M2_86460_118860 n1_M2_87540_118860 0.988200
R15041 n1_M2_87540_118860 n1_M2_88620_118860 0.988200
R15042 n1_M2_88620_118860 n1_M2_89700_118860 0.988200
R15043 n1_M2_89700_118860 n1_M2_90780_118860 0.988200
R15044 n1_M2_90780_118860 n1_M2_91860_118860 0.988200
R15045 n1_M2_91860_118860 n1_M2_92940_118860 0.988200
R15046 n1_M2_92940_118860 n1_M2_94020_118860 0.988200
R15047 n1_M2_94020_118860 n1_M2_95100_118860 0.988200
R15048 n1_M2_95100_118860 n1_M2_96180_118860 0.988200
R15049 n1_M2_96180_118860 n1_M2_97260_118860 0.988200
R15050 n1_M2_97260_118860 n1_M2_98340_118860 0.988200
R15051 n1_M2_98340_118860 n1_M2_99420_118860 0.988200
R15052 n1_M2_99420_118860 n1_M2_100500_118860 0.988200
R15053 n1_M2_100500_118860 n1_M2_101580_118860 0.988200
R15054 n1_M2_101580_118860 n1_M2_102660_118860 0.988200
R15055 n1_M2_102660_118860 n1_M2_103740_118860 0.988200
R15056 n1_M2_103740_118860 n1_M2_104820_118860 0.988200
R15057 n1_M2_104820_118860 n1_M2_105900_118860 0.988200
R15058 n1_M2_105900_118860 n1_M2_106980_118860 0.988200
R15059 n1_M2_106980_118860 n1_M2_108060_118860 0.988200
R15060 n1_M2_108060_118860 n1_M2_109140_118860 0.988200
R15061 n1_M2_109140_118860 n1_M2_110220_118860 0.988200
R15062 n1_M2_110220_118860 n1_M2_111300_118860 0.988200
R15063 n1_M2_111300_118860 n1_M2_112380_118860 0.988200
R15064 n1_M2_112380_118860 n1_M2_113460_118860 0.988200
R15065 n1_M2_113460_118860 n1_M2_114540_118860 0.988200
R15066 n1_M2_114540_118860 n1_M2_115620_118860 0.988200
R15067 n1_M2_115620_118860 n1_M2_116700_118860 0.988200
R15068 n1_M2_116700_118860 n1_M2_117780_118860 0.988200
R15069 n1_M2_117780_118860 n1_M2_118860_118860 0.988200
R15070 n1_M2_118860_118860 n1_M2_119940_118860 0.988200
R15071 n1_M2_119940_118860 n1_M2_121020_118860 0.988200
R15072 n1_M2_121020_118860 n1_M2_122100_118860 0.988200
R15073 n1_M2_122100_118860 n1_M2_123180_118860 0.988200
R15074 n1_M2_123180_118860 n1_M2_124260_118860 0.988200
R15075 n1_M2_124260_118860 n1_M2_125340_118860 0.988200
R15076 n1_M2_125340_118860 n1_M2_126420_118860 0.988200
R15077 n1_M2_126420_118860 n1_M2_127500_118860 0.988200
R15078 n1_M2_127500_118860 n1_M2_128580_118860 0.988200
R15079 n1_M2_128580_118860 n1_M2_129660_118860 0.988200
R15080 n1_M2_129660_118860 n1_M2_130740_118860 0.988200
R15081 n1_M2_130740_118860 n1_M2_131820_118860 0.988200
R15082 n1_M2_131820_118860 n1_M2_132900_118860 0.988200
R15083 n1_M2_132900_118860 n1_M2_133980_118860 0.988200
R15084 n1_M2_133980_118860 n1_M2_135060_118860 0.988200
R15085 n1_M2_135060_118860 n1_M2_136140_118860 0.988200
R15086 n1_M2_136140_118860 n1_M2_137220_118860 0.988200
R15087 n1_M2_137220_118860 n1_M2_138300_118860 0.988200
R15088 n1_M2_138300_118860 n1_M2_139380_118860 0.988200
R15089 n1_M2_139380_118860 n1_M2_140460_118860 0.988200
R15090 n1_M2_140460_118860 n1_M2_141540_118860 0.988200
R15091 n1_M2_141540_118860 n1_M2_142620_118860 0.988200
R15092 n1_M2_142620_118860 n1_M2_143700_118860 0.988200
R15093 n1_M2_143700_118860 n1_M2_144780_118860 0.988200
R15094 n1_M2_144780_118860 n1_M2_145860_118860 0.988200
R15095 n1_M2_145860_118860 n1_M2_146940_118860 0.988200
R15096 n1_M2_60_119940 n1_M2_1140_119940 0.988200
R15097 n1_M2_1140_119940 n1_M2_2220_119940 0.988200
R15098 n1_M2_2220_119940 n1_M2_3300_119940 0.988200
R15099 n1_M2_3300_119940 n1_M2_4380_119940 0.988200
R15100 n1_M2_4380_119940 n1_M2_5460_119940 0.988200
R15101 n1_M2_5460_119940 n1_M2_6540_119940 0.988200
R15102 n1_M2_6540_119940 n1_M2_7620_119940 0.988200
R15103 n1_M2_7620_119940 n1_M2_8700_119940 0.988200
R15104 n1_M2_8700_119940 n1_M2_9780_119940 0.988200
R15105 n1_M2_9780_119940 n1_M2_10860_119940 0.988200
R15106 n1_M2_10860_119940 n1_M2_11940_119940 0.988200
R15107 n1_M2_11940_119940 n1_M2_13020_119940 0.988200
R15108 n1_M2_13020_119940 n1_M2_14100_119940 0.988200
R15109 n1_M2_14100_119940 n1_M2_15180_119940 0.988200
R15110 n1_M2_15180_119940 n1_M2_16260_119940 0.988200
R15111 n1_M2_16260_119940 n1_M2_17340_119940 0.988200
R15112 n1_M2_17340_119940 n1_M2_18420_119940 0.988200
R15113 n1_M2_18420_119940 n1_M2_19500_119940 0.988200
R15114 n1_M2_19500_119940 n1_M2_20580_119940 0.988200
R15115 n1_M2_20580_119940 n1_M2_21660_119940 0.988200
R15116 n1_M2_21660_119940 n1_M2_22740_119940 0.988200
R15117 n1_M2_22740_119940 n1_M2_23820_119940 0.988200
R15118 n1_M2_23820_119940 n1_M2_24900_119940 0.988200
R15119 n1_M2_24900_119940 n1_M2_25980_119940 0.988200
R15120 n1_M2_25980_119940 n1_M2_27060_119940 0.988200
R15121 n1_M2_27060_119940 n1_M2_28140_119940 0.988200
R15122 n1_M2_28140_119940 n1_M2_29220_119940 0.988200
R15123 n1_M2_29220_119940 n1_M2_30300_119940 0.988200
R15124 n1_M2_30300_119940 n1_M2_31380_119940 0.988200
R15125 n1_M2_31380_119940 n1_M2_32460_119940 0.988200
R15126 n1_M2_32460_119940 n1_M2_33540_119940 0.988200
R15127 n1_M2_33540_119940 n1_M2_34620_119940 0.988200
R15128 n1_M2_34620_119940 n1_M2_35700_119940 0.988200
R15129 n1_M2_35700_119940 n1_M2_36780_119940 0.988200
R15130 n1_M2_36780_119940 n1_M2_37860_119940 0.988200
R15131 n1_M2_37860_119940 n1_M2_38940_119940 0.988200
R15132 n1_M2_38940_119940 n1_M2_40020_119940 0.988200
R15133 n1_M2_40020_119940 n1_M2_41100_119940 0.988200
R15134 n1_M2_41100_119940 n1_M2_42180_119940 0.988200
R15135 n1_M2_42180_119940 n1_M2_43260_119940 0.988200
R15136 n1_M2_43260_119940 n1_M2_44340_119940 0.988200
R15137 n1_M2_44340_119940 n1_M2_45420_119940 0.988200
R15138 n1_M2_45420_119940 n1_M2_46500_119940 0.988200
R15139 n1_M2_46500_119940 n1_M2_47580_119940 0.988200
R15140 n1_M2_47580_119940 n1_M2_48660_119940 0.988200
R15141 n1_M2_48660_119940 n1_M2_49740_119940 0.988200
R15142 n1_M2_49740_119940 n1_M2_50820_119940 0.988200
R15143 n1_M2_50820_119940 n1_M2_51900_119940 0.988200
R15144 n1_M2_51900_119940 n1_M2_52980_119940 0.988200
R15145 n1_M2_52980_119940 n1_M2_54060_119940 0.988200
R15146 n1_M2_54060_119940 n1_M2_55140_119940 0.988200
R15147 n1_M2_55140_119940 n1_M2_56220_119940 0.988200
R15148 n1_M2_56220_119940 n1_M2_57300_119940 0.988200
R15149 n1_M2_57300_119940 n1_M2_58380_119940 0.988200
R15150 n1_M2_58380_119940 n1_M2_59460_119940 0.988200
R15151 n1_M2_59460_119940 n1_M2_60540_119940 0.988200
R15152 n1_M2_60540_119940 n1_M2_61620_119940 0.988200
R15153 n1_M2_61620_119940 n1_M2_62700_119940 0.988200
R15154 n1_M2_62700_119940 n1_M2_63780_119940 0.988200
R15155 n1_M2_63780_119940 n1_M2_64860_119940 0.988200
R15156 n1_M2_64860_119940 n1_M2_65940_119940 0.988200
R15157 n1_M2_65940_119940 n1_M2_67020_119940 0.988200
R15158 n1_M2_67020_119940 n1_M2_68100_119940 0.988200
R15159 n1_M2_68100_119940 n1_M2_69180_119940 0.988200
R15160 n1_M2_69180_119940 n1_M2_70260_119940 0.988200
R15161 n1_M2_70260_119940 n1_M2_71340_119940 0.988200
R15162 n1_M2_71340_119940 n1_M2_72420_119940 0.988200
R15163 n1_M2_72420_119940 n1_M2_73500_119940 0.988200
R15164 n1_M2_73500_119940 n1_M2_74580_119940 0.988200
R15165 n1_M2_74580_119940 n1_M2_75660_119940 0.988200
R15166 n1_M2_75660_119940 n1_M2_76740_119940 0.988200
R15167 n1_M2_76740_119940 n1_M2_77820_119940 0.988200
R15168 n1_M2_77820_119940 n1_M2_78900_119940 0.988200
R15169 n1_M2_78900_119940 n1_M2_79980_119940 0.988200
R15170 n1_M2_79980_119940 n1_M2_81060_119940 0.988200
R15171 n1_M2_81060_119940 n1_M2_82140_119940 0.988200
R15172 n1_M2_82140_119940 n1_M2_83220_119940 0.988200
R15173 n1_M2_83220_119940 n1_M2_84300_119940 0.988200
R15174 n1_M2_84300_119940 n1_M2_85380_119940 0.988200
R15175 n1_M2_85380_119940 n1_M2_86460_119940 0.988200
R15176 n1_M2_86460_119940 n1_M2_87540_119940 0.988200
R15177 n1_M2_87540_119940 n1_M2_88620_119940 0.988200
R15178 n1_M2_88620_119940 n1_M2_89700_119940 0.988200
R15179 n1_M2_89700_119940 n1_M2_90780_119940 0.988200
R15180 n1_M2_90780_119940 n1_M2_91860_119940 0.988200
R15181 n1_M2_91860_119940 n1_M2_92940_119940 0.988200
R15182 n1_M2_92940_119940 n1_M2_94020_119940 0.988200
R15183 n1_M2_94020_119940 n1_M2_95100_119940 0.988200
R15184 n1_M2_95100_119940 n1_M2_96180_119940 0.988200
R15185 n1_M2_96180_119940 n1_M2_97260_119940 0.988200
R15186 n1_M2_97260_119940 n1_M2_98340_119940 0.988200
R15187 n1_M2_98340_119940 n1_M2_99420_119940 0.988200
R15188 n1_M2_99420_119940 n1_M2_100500_119940 0.988200
R15189 n1_M2_100500_119940 n1_M2_101580_119940 0.988200
R15190 n1_M2_101580_119940 n1_M2_102660_119940 0.988200
R15191 n1_M2_102660_119940 n1_M2_103740_119940 0.988200
R15192 n1_M2_103740_119940 n1_M2_104820_119940 0.988200
R15193 n1_M2_104820_119940 n1_M2_105900_119940 0.988200
R15194 n1_M2_105900_119940 n1_M2_106980_119940 0.988200
R15195 n1_M2_106980_119940 n1_M2_108060_119940 0.988200
R15196 n1_M2_108060_119940 n1_M2_109140_119940 0.988200
R15197 n1_M2_109140_119940 n1_M2_110220_119940 0.988200
R15198 n1_M2_110220_119940 n1_M2_111300_119940 0.988200
R15199 n1_M2_111300_119940 n1_M2_112380_119940 0.988200
R15200 n1_M2_112380_119940 n1_M2_113460_119940 0.988200
R15201 n1_M2_113460_119940 n1_M2_114540_119940 0.988200
R15202 n1_M2_114540_119940 n1_M2_115620_119940 0.988200
R15203 n1_M2_115620_119940 n1_M2_116700_119940 0.988200
R15204 n1_M2_116700_119940 n1_M2_117780_119940 0.988200
R15205 n1_M2_117780_119940 n1_M2_118860_119940 0.988200
R15206 n1_M2_118860_119940 n1_M2_119940_119940 0.988200
R15207 n1_M2_119940_119940 n1_M2_121020_119940 0.988200
R15208 n1_M2_121020_119940 n1_M2_122100_119940 0.988200
R15209 n1_M2_122100_119940 n1_M2_123180_119940 0.988200
R15210 n1_M2_123180_119940 n1_M2_124260_119940 0.988200
R15211 n1_M2_124260_119940 n1_M2_125340_119940 0.988200
R15212 n1_M2_125340_119940 n1_M2_126420_119940 0.988200
R15213 n1_M2_126420_119940 n1_M2_127500_119940 0.988200
R15214 n1_M2_127500_119940 n1_M2_128580_119940 0.988200
R15215 n1_M2_128580_119940 n1_M2_129660_119940 0.988200
R15216 n1_M2_129660_119940 n1_M2_130740_119940 0.988200
R15217 n1_M2_130740_119940 n1_M2_131820_119940 0.988200
R15218 n1_M2_131820_119940 n1_M2_132900_119940 0.988200
R15219 n1_M2_132900_119940 n1_M2_133980_119940 0.988200
R15220 n1_M2_133980_119940 n1_M2_135060_119940 0.988200
R15221 n1_M2_135060_119940 n1_M2_136140_119940 0.988200
R15222 n1_M2_136140_119940 n1_M2_137220_119940 0.988200
R15223 n1_M2_137220_119940 n1_M2_138300_119940 0.988200
R15224 n1_M2_138300_119940 n1_M2_139380_119940 0.988200
R15225 n1_M2_139380_119940 n1_M2_140460_119940 0.988200
R15226 n1_M2_140460_119940 n1_M2_141540_119940 0.988200
R15227 n1_M2_141540_119940 n1_M2_142620_119940 0.988200
R15228 n1_M2_142620_119940 n1_M2_143700_119940 0.988200
R15229 n1_M2_143700_119940 n1_M2_144780_119940 0.988200
R15230 n1_M2_144780_119940 n1_M2_145860_119940 0.988200
R15231 n1_M2_145860_119940 n1_M2_146940_119940 0.988200
R15232 n1_M2_60_121020 n1_M2_1140_121020 0.988200
R15233 n1_M2_1140_121020 n1_M2_2220_121020 0.988200
R15234 n1_M2_2220_121020 n1_M2_3300_121020 0.988200
R15235 n1_M2_3300_121020 n1_M2_4380_121020 0.988200
R15236 n1_M2_4380_121020 n1_M2_5460_121020 0.988200
R15237 n1_M2_5460_121020 n1_M2_6540_121020 0.988200
R15238 n1_M2_6540_121020 n1_M2_7620_121020 0.988200
R15239 n1_M2_7620_121020 n1_M2_8700_121020 0.988200
R15240 n1_M2_8700_121020 n1_M2_9780_121020 0.988200
R15241 n1_M2_9780_121020 n1_M2_10860_121020 0.988200
R15242 n1_M2_10860_121020 n1_M2_11940_121020 0.988200
R15243 n1_M2_11940_121020 n1_M2_13020_121020 0.988200
R15244 n1_M2_13020_121020 n1_M2_14100_121020 0.988200
R15245 n1_M2_14100_121020 n1_M2_15180_121020 0.988200
R15246 n1_M2_15180_121020 n1_M2_16260_121020 0.988200
R15247 n1_M2_16260_121020 n1_M2_17340_121020 0.988200
R15248 n1_M2_17340_121020 n1_M2_18420_121020 0.988200
R15249 n1_M2_18420_121020 n1_M2_19500_121020 0.988200
R15250 n1_M2_19500_121020 n1_M2_20580_121020 0.988200
R15251 n1_M2_20580_121020 n1_M2_21660_121020 0.988200
R15252 n1_M2_21660_121020 n1_M2_22740_121020 0.988200
R15253 n1_M2_22740_121020 n1_M2_23820_121020 0.988200
R15254 n1_M2_23820_121020 n1_M2_24900_121020 0.988200
R15255 n1_M2_24900_121020 n1_M2_25980_121020 0.988200
R15256 n1_M2_25980_121020 n1_M2_27060_121020 0.988200
R15257 n1_M2_27060_121020 n1_M2_28140_121020 0.988200
R15258 n1_M2_28140_121020 n1_M2_29220_121020 0.988200
R15259 n1_M2_29220_121020 n1_M2_30300_121020 0.988200
R15260 n1_M2_30300_121020 n1_M2_31380_121020 0.988200
R15261 n1_M2_31380_121020 n1_M2_32460_121020 0.988200
R15262 n1_M2_32460_121020 n1_M2_33540_121020 0.988200
R15263 n1_M2_33540_121020 n1_M2_34620_121020 0.988200
R15264 n1_M2_34620_121020 n1_M2_35700_121020 0.988200
R15265 n1_M2_35700_121020 n1_M2_36780_121020 0.988200
R15266 n1_M2_36780_121020 n1_M2_37860_121020 0.988200
R15267 n1_M2_37860_121020 n1_M2_38940_121020 0.988200
R15268 n1_M2_38940_121020 n1_M2_40020_121020 0.988200
R15269 n1_M2_40020_121020 n1_M2_41100_121020 0.988200
R15270 n1_M2_41100_121020 n1_M2_42180_121020 0.988200
R15271 n1_M2_42180_121020 n1_M2_43260_121020 0.988200
R15272 n1_M2_43260_121020 n1_M2_44340_121020 0.988200
R15273 n1_M2_44340_121020 n1_M2_45420_121020 0.988200
R15274 n1_M2_45420_121020 n1_M2_46500_121020 0.988200
R15275 n1_M2_46500_121020 n1_M2_47580_121020 0.988200
R15276 n1_M2_47580_121020 n1_M2_48660_121020 0.988200
R15277 n1_M2_48660_121020 n1_M2_49740_121020 0.988200
R15278 n1_M2_49740_121020 n1_M2_50820_121020 0.988200
R15279 n1_M2_50820_121020 n1_M2_51900_121020 0.988200
R15280 n1_M2_51900_121020 n1_M2_52980_121020 0.988200
R15281 n1_M2_52980_121020 n1_M2_54060_121020 0.988200
R15282 n1_M2_54060_121020 n1_M2_55140_121020 0.988200
R15283 n1_M2_55140_121020 n1_M2_56220_121020 0.988200
R15284 n1_M2_56220_121020 n1_M2_57300_121020 0.988200
R15285 n1_M2_57300_121020 n1_M2_58380_121020 0.988200
R15286 n1_M2_58380_121020 n1_M2_59460_121020 0.988200
R15287 n1_M2_59460_121020 n1_M2_60540_121020 0.988200
R15288 n1_M2_60540_121020 n1_M2_61620_121020 0.988200
R15289 n1_M2_61620_121020 n1_M2_62700_121020 0.988200
R15290 n1_M2_62700_121020 n1_M2_63780_121020 0.988200
R15291 n1_M2_63780_121020 n1_M2_64860_121020 0.988200
R15292 n1_M2_64860_121020 n1_M2_65940_121020 0.988200
R15293 n1_M2_65940_121020 n1_M2_67020_121020 0.988200
R15294 n1_M2_67020_121020 n1_M2_68100_121020 0.988200
R15295 n1_M2_68100_121020 n1_M2_69180_121020 0.988200
R15296 n1_M2_69180_121020 n1_M2_70260_121020 0.988200
R15297 n1_M2_70260_121020 n1_M2_71340_121020 0.988200
R15298 n1_M2_71340_121020 n1_M2_72420_121020 0.988200
R15299 n1_M2_72420_121020 n1_M2_73500_121020 0.988200
R15300 n1_M2_73500_121020 n1_M2_74580_121020 0.988200
R15301 n1_M2_74580_121020 n1_M2_75660_121020 0.988200
R15302 n1_M2_75660_121020 n1_M2_76740_121020 0.988200
R15303 n1_M2_76740_121020 n1_M2_77820_121020 0.988200
R15304 n1_M2_77820_121020 n1_M2_78900_121020 0.988200
R15305 n1_M2_78900_121020 n1_M2_79980_121020 0.988200
R15306 n1_M2_79980_121020 n1_M2_81060_121020 0.988200
R15307 n1_M2_81060_121020 n1_M2_82140_121020 0.988200
R15308 n1_M2_82140_121020 n1_M2_83220_121020 0.988200
R15309 n1_M2_83220_121020 n1_M2_84300_121020 0.988200
R15310 n1_M2_84300_121020 n1_M2_85380_121020 0.988200
R15311 n1_M2_85380_121020 n1_M2_86460_121020 0.988200
R15312 n1_M2_86460_121020 n1_M2_87540_121020 0.988200
R15313 n1_M2_87540_121020 n1_M2_88620_121020 0.988200
R15314 n1_M2_88620_121020 n1_M2_89700_121020 0.988200
R15315 n1_M2_89700_121020 n1_M2_90780_121020 0.988200
R15316 n1_M2_90780_121020 n1_M2_91860_121020 0.988200
R15317 n1_M2_91860_121020 n1_M2_92940_121020 0.988200
R15318 n1_M2_92940_121020 n1_M2_94020_121020 0.988200
R15319 n1_M2_94020_121020 n1_M2_95100_121020 0.988200
R15320 n1_M2_95100_121020 n1_M2_96180_121020 0.988200
R15321 n1_M2_96180_121020 n1_M2_97260_121020 0.988200
R15322 n1_M2_97260_121020 n1_M2_98340_121020 0.988200
R15323 n1_M2_98340_121020 n1_M2_99420_121020 0.988200
R15324 n1_M2_99420_121020 n1_M2_100500_121020 0.988200
R15325 n1_M2_100500_121020 n1_M2_101580_121020 0.988200
R15326 n1_M2_101580_121020 n1_M2_102660_121020 0.988200
R15327 n1_M2_102660_121020 n1_M2_103740_121020 0.988200
R15328 n1_M2_103740_121020 n1_M2_104820_121020 0.988200
R15329 n1_M2_104820_121020 n1_M2_105900_121020 0.988200
R15330 n1_M2_105900_121020 n1_M2_106980_121020 0.988200
R15331 n1_M2_106980_121020 n1_M2_108060_121020 0.988200
R15332 n1_M2_108060_121020 n1_M2_109140_121020 0.988200
R15333 n1_M2_109140_121020 n1_M2_110220_121020 0.988200
R15334 n1_M2_110220_121020 n1_M2_111300_121020 0.988200
R15335 n1_M2_111300_121020 n1_M2_112380_121020 0.988200
R15336 n1_M2_112380_121020 n1_M2_113460_121020 0.988200
R15337 n1_M2_113460_121020 n1_M2_114540_121020 0.988200
R15338 n1_M2_114540_121020 n1_M2_115620_121020 0.988200
R15339 n1_M2_115620_121020 n1_M2_116700_121020 0.988200
R15340 n1_M2_116700_121020 n1_M2_117780_121020 0.988200
R15341 n1_M2_117780_121020 n1_M2_118860_121020 0.988200
R15342 n1_M2_118860_121020 n1_M2_119940_121020 0.988200
R15343 n1_M2_119940_121020 n1_M2_121020_121020 0.988200
R15344 n1_M2_121020_121020 n1_M2_122100_121020 0.988200
R15345 n1_M2_122100_121020 n1_M2_123180_121020 0.988200
R15346 n1_M2_123180_121020 n1_M2_124260_121020 0.988200
R15347 n1_M2_124260_121020 n1_M2_125340_121020 0.988200
R15348 n1_M2_125340_121020 n1_M2_126420_121020 0.988200
R15349 n1_M2_126420_121020 n1_M2_127500_121020 0.988200
R15350 n1_M2_127500_121020 n1_M2_128580_121020 0.988200
R15351 n1_M2_128580_121020 n1_M2_129660_121020 0.988200
R15352 n1_M2_129660_121020 n1_M2_130740_121020 0.988200
R15353 n1_M2_130740_121020 n1_M2_131820_121020 0.988200
R15354 n1_M2_131820_121020 n1_M2_132900_121020 0.988200
R15355 n1_M2_132900_121020 n1_M2_133980_121020 0.988200
R15356 n1_M2_133980_121020 n1_M2_135060_121020 0.988200
R15357 n1_M2_135060_121020 n1_M2_136140_121020 0.988200
R15358 n1_M2_136140_121020 n1_M2_137220_121020 0.988200
R15359 n1_M2_137220_121020 n1_M2_138300_121020 0.988200
R15360 n1_M2_138300_121020 n1_M2_139380_121020 0.988200
R15361 n1_M2_139380_121020 n1_M2_140460_121020 0.988200
R15362 n1_M2_140460_121020 n1_M2_141540_121020 0.988200
R15363 n1_M2_141540_121020 n1_M2_142620_121020 0.988200
R15364 n1_M2_142620_121020 n1_M2_143700_121020 0.988200
R15365 n1_M2_143700_121020 n1_M2_144780_121020 0.988200
R15366 n1_M2_144780_121020 n1_M2_145860_121020 0.988200
R15367 n1_M2_145860_121020 n1_M2_146940_121020 0.988200
R15368 n1_M2_60_122100 n1_M2_1140_122100 0.988200
R15369 n1_M2_1140_122100 n1_M2_2220_122100 0.988200
R15370 n1_M2_2220_122100 n1_M2_3300_122100 0.988200
R15371 n1_M2_3300_122100 n1_M2_4380_122100 0.988200
R15372 n1_M2_4380_122100 n1_M2_5460_122100 0.988200
R15373 n1_M2_5460_122100 n1_M2_6540_122100 0.988200
R15374 n1_M2_6540_122100 n1_M2_7620_122100 0.988200
R15375 n1_M2_7620_122100 n1_M2_8700_122100 0.988200
R15376 n1_M2_8700_122100 n1_M2_9780_122100 0.988200
R15377 n1_M2_9780_122100 n1_M2_10860_122100 0.988200
R15378 n1_M2_10860_122100 n1_M2_11940_122100 0.988200
R15379 n1_M2_11940_122100 n1_M2_13020_122100 0.988200
R15380 n1_M2_13020_122100 n1_M2_14100_122100 0.988200
R15381 n1_M2_14100_122100 n1_M2_15180_122100 0.988200
R15382 n1_M2_15180_122100 n1_M2_16260_122100 0.988200
R15383 n1_M2_16260_122100 n1_M2_17340_122100 0.988200
R15384 n1_M2_17340_122100 n1_M2_18420_122100 0.988200
R15385 n1_M2_18420_122100 n1_M2_19500_122100 0.988200
R15386 n1_M2_19500_122100 n1_M2_20580_122100 0.988200
R15387 n1_M2_20580_122100 n1_M2_21660_122100 0.988200
R15388 n1_M2_21660_122100 n1_M2_22740_122100 0.988200
R15389 n1_M2_22740_122100 n1_M2_23820_122100 0.988200
R15390 n1_M2_23820_122100 n1_M2_24900_122100 0.988200
R15391 n1_M2_24900_122100 n1_M2_25980_122100 0.988200
R15392 n1_M2_25980_122100 n1_M2_27060_122100 0.988200
R15393 n1_M2_27060_122100 n1_M2_28140_122100 0.988200
R15394 n1_M2_28140_122100 n1_M2_29220_122100 0.988200
R15395 n1_M2_29220_122100 n1_M2_30300_122100 0.988200
R15396 n1_M2_30300_122100 n1_M2_31380_122100 0.988200
R15397 n1_M2_31380_122100 n1_M2_32460_122100 0.988200
R15398 n1_M2_32460_122100 n1_M2_33540_122100 0.988200
R15399 n1_M2_33540_122100 n1_M2_34620_122100 0.988200
R15400 n1_M2_34620_122100 n1_M2_35700_122100 0.988200
R15401 n1_M2_35700_122100 n1_M2_36780_122100 0.988200
R15402 n1_M2_36780_122100 n1_M2_37860_122100 0.988200
R15403 n1_M2_37860_122100 n1_M2_38940_122100 0.988200
R15404 n1_M2_38940_122100 n1_M2_40020_122100 0.988200
R15405 n1_M2_40020_122100 n1_M2_41100_122100 0.988200
R15406 n1_M2_41100_122100 n1_M2_42180_122100 0.988200
R15407 n1_M2_42180_122100 n1_M2_43260_122100 0.988200
R15408 n1_M2_43260_122100 n1_M2_44340_122100 0.988200
R15409 n1_M2_44340_122100 n1_M2_45420_122100 0.988200
R15410 n1_M2_45420_122100 n1_M2_46500_122100 0.988200
R15411 n1_M2_46500_122100 n1_M2_47580_122100 0.988200
R15412 n1_M2_47580_122100 n1_M2_48660_122100 0.988200
R15413 n1_M2_48660_122100 n1_M2_49740_122100 0.988200
R15414 n1_M2_49740_122100 n1_M2_50820_122100 0.988200
R15415 n1_M2_50820_122100 n1_M2_51900_122100 0.988200
R15416 n1_M2_51900_122100 n1_M2_52980_122100 0.988200
R15417 n1_M2_52980_122100 n1_M2_54060_122100 0.988200
R15418 n1_M2_54060_122100 n1_M2_55140_122100 0.988200
R15419 n1_M2_55140_122100 n1_M2_56220_122100 0.988200
R15420 n1_M2_56220_122100 n1_M2_57300_122100 0.988200
R15421 n1_M2_57300_122100 n1_M2_58380_122100 0.988200
R15422 n1_M2_58380_122100 n1_M2_59460_122100 0.988200
R15423 n1_M2_59460_122100 n1_M2_60540_122100 0.988200
R15424 n1_M2_60540_122100 n1_M2_61620_122100 0.988200
R15425 n1_M2_61620_122100 n1_M2_62700_122100 0.988200
R15426 n1_M2_62700_122100 n1_M2_63780_122100 0.988200
R15427 n1_M2_63780_122100 n1_M2_64860_122100 0.988200
R15428 n1_M2_64860_122100 n1_M2_65940_122100 0.988200
R15429 n1_M2_65940_122100 n1_M2_67020_122100 0.988200
R15430 n1_M2_67020_122100 n1_M2_68100_122100 0.988200
R15431 n1_M2_68100_122100 n1_M2_69180_122100 0.988200
R15432 n1_M2_69180_122100 n1_M2_70260_122100 0.988200
R15433 n1_M2_70260_122100 n1_M2_71340_122100 0.988200
R15434 n1_M2_71340_122100 n1_M2_72420_122100 0.988200
R15435 n1_M2_72420_122100 n1_M2_73500_122100 0.988200
R15436 n1_M2_73500_122100 n1_M2_74580_122100 0.988200
R15437 n1_M2_74580_122100 n1_M2_75660_122100 0.988200
R15438 n1_M2_75660_122100 n1_M2_76740_122100 0.988200
R15439 n1_M2_76740_122100 n1_M2_77820_122100 0.988200
R15440 n1_M2_77820_122100 n1_M2_78900_122100 0.988200
R15441 n1_M2_78900_122100 n1_M2_79980_122100 0.988200
R15442 n1_M2_79980_122100 n1_M2_81060_122100 0.988200
R15443 n1_M2_81060_122100 n1_M2_82140_122100 0.988200
R15444 n1_M2_82140_122100 n1_M2_83220_122100 0.988200
R15445 n1_M2_83220_122100 n1_M2_84300_122100 0.988200
R15446 n1_M2_84300_122100 n1_M2_85380_122100 0.988200
R15447 n1_M2_85380_122100 n1_M2_86460_122100 0.988200
R15448 n1_M2_86460_122100 n1_M2_87540_122100 0.988200
R15449 n1_M2_87540_122100 n1_M2_88620_122100 0.988200
R15450 n1_M2_88620_122100 n1_M2_89700_122100 0.988200
R15451 n1_M2_89700_122100 n1_M2_90780_122100 0.988200
R15452 n1_M2_90780_122100 n1_M2_91860_122100 0.988200
R15453 n1_M2_91860_122100 n1_M2_92940_122100 0.988200
R15454 n1_M2_92940_122100 n1_M2_94020_122100 0.988200
R15455 n1_M2_94020_122100 n1_M2_95100_122100 0.988200
R15456 n1_M2_95100_122100 n1_M2_96180_122100 0.988200
R15457 n1_M2_96180_122100 n1_M2_97260_122100 0.988200
R15458 n1_M2_97260_122100 n1_M2_98340_122100 0.988200
R15459 n1_M2_98340_122100 n1_M2_99420_122100 0.988200
R15460 n1_M2_99420_122100 n1_M2_100500_122100 0.988200
R15461 n1_M2_100500_122100 n1_M2_101580_122100 0.988200
R15462 n1_M2_101580_122100 n1_M2_102660_122100 0.988200
R15463 n1_M2_102660_122100 n1_M2_103740_122100 0.988200
R15464 n1_M2_103740_122100 n1_M2_104820_122100 0.988200
R15465 n1_M2_104820_122100 n1_M2_105900_122100 0.988200
R15466 n1_M2_105900_122100 n1_M2_106980_122100 0.988200
R15467 n1_M2_106980_122100 n1_M2_108060_122100 0.988200
R15468 n1_M2_108060_122100 n1_M2_109140_122100 0.988200
R15469 n1_M2_109140_122100 n1_M2_110220_122100 0.988200
R15470 n1_M2_110220_122100 n1_M2_111300_122100 0.988200
R15471 n1_M2_111300_122100 n1_M2_112380_122100 0.988200
R15472 n1_M2_112380_122100 n1_M2_113460_122100 0.988200
R15473 n1_M2_113460_122100 n1_M2_114540_122100 0.988200
R15474 n1_M2_114540_122100 n1_M2_115620_122100 0.988200
R15475 n1_M2_115620_122100 n1_M2_116700_122100 0.988200
R15476 n1_M2_116700_122100 n1_M2_117780_122100 0.988200
R15477 n1_M2_117780_122100 n1_M2_118860_122100 0.988200
R15478 n1_M2_118860_122100 n1_M2_119940_122100 0.988200
R15479 n1_M2_119940_122100 n1_M2_121020_122100 0.988200
R15480 n1_M2_121020_122100 n1_M2_122100_122100 0.988200
R15481 n1_M2_122100_122100 n1_M2_123180_122100 0.988200
R15482 n1_M2_123180_122100 n1_M2_124260_122100 0.988200
R15483 n1_M2_124260_122100 n1_M2_125340_122100 0.988200
R15484 n1_M2_125340_122100 n1_M2_126420_122100 0.988200
R15485 n1_M2_126420_122100 n1_M2_127500_122100 0.988200
R15486 n1_M2_127500_122100 n1_M2_128580_122100 0.988200
R15487 n1_M2_128580_122100 n1_M2_129660_122100 0.988200
R15488 n1_M2_129660_122100 n1_M2_130740_122100 0.988200
R15489 n1_M2_130740_122100 n1_M2_131820_122100 0.988200
R15490 n1_M2_131820_122100 n1_M2_132900_122100 0.988200
R15491 n1_M2_132900_122100 n1_M2_133980_122100 0.988200
R15492 n1_M2_133980_122100 n1_M2_135060_122100 0.988200
R15493 n1_M2_135060_122100 n1_M2_136140_122100 0.988200
R15494 n1_M2_136140_122100 n1_M2_137220_122100 0.988200
R15495 n1_M2_137220_122100 n1_M2_138300_122100 0.988200
R15496 n1_M2_138300_122100 n1_M2_139380_122100 0.988200
R15497 n1_M2_139380_122100 n1_M2_140460_122100 0.988200
R15498 n1_M2_140460_122100 n1_M2_141540_122100 0.988200
R15499 n1_M2_141540_122100 n1_M2_142620_122100 0.988200
R15500 n1_M2_142620_122100 n1_M2_143700_122100 0.988200
R15501 n1_M2_143700_122100 n1_M2_144780_122100 0.988200
R15502 n1_M2_144780_122100 n1_M2_145860_122100 0.988200
R15503 n1_M2_145860_122100 n1_M2_146940_122100 0.988200
R15504 n1_M2_60_123180 n1_M2_1140_123180 0.988200
R15505 n1_M2_1140_123180 n1_M2_2220_123180 0.988200
R15506 n1_M2_2220_123180 n1_M2_3300_123180 0.988200
R15507 n1_M2_3300_123180 n1_M2_4380_123180 0.988200
R15508 n1_M2_4380_123180 n1_M2_5460_123180 0.988200
R15509 n1_M2_5460_123180 n1_M2_6540_123180 0.988200
R15510 n1_M2_6540_123180 n1_M2_7620_123180 0.988200
R15511 n1_M2_7620_123180 n1_M2_8700_123180 0.988200
R15512 n1_M2_8700_123180 n1_M2_9780_123180 0.988200
R15513 n1_M2_9780_123180 n1_M2_10860_123180 0.988200
R15514 n1_M2_10860_123180 n1_M2_11940_123180 0.988200
R15515 n1_M2_11940_123180 n1_M2_13020_123180 0.988200
R15516 n1_M2_13020_123180 n1_M2_14100_123180 0.988200
R15517 n1_M2_14100_123180 n1_M2_15180_123180 0.988200
R15518 n1_M2_15180_123180 n1_M2_16260_123180 0.988200
R15519 n1_M2_16260_123180 n1_M2_17340_123180 0.988200
R15520 n1_M2_17340_123180 n1_M2_18420_123180 0.988200
R15521 n1_M2_18420_123180 n1_M2_19500_123180 0.988200
R15522 n1_M2_19500_123180 n1_M2_20580_123180 0.988200
R15523 n1_M2_20580_123180 n1_M2_21660_123180 0.988200
R15524 n1_M2_21660_123180 n1_M2_22740_123180 0.988200
R15525 n1_M2_22740_123180 n1_M2_23820_123180 0.988200
R15526 n1_M2_23820_123180 n1_M2_24900_123180 0.988200
R15527 n1_M2_24900_123180 n1_M2_25980_123180 0.988200
R15528 n1_M2_25980_123180 n1_M2_27060_123180 0.988200
R15529 n1_M2_27060_123180 n1_M2_28140_123180 0.988200
R15530 n1_M2_28140_123180 n1_M2_29220_123180 0.988200
R15531 n1_M2_29220_123180 n1_M2_30300_123180 0.988200
R15532 n1_M2_30300_123180 n1_M2_31380_123180 0.988200
R15533 n1_M2_31380_123180 n1_M2_32460_123180 0.988200
R15534 n1_M2_32460_123180 n1_M2_33540_123180 0.988200
R15535 n1_M2_33540_123180 n1_M2_34620_123180 0.988200
R15536 n1_M2_34620_123180 n1_M2_35700_123180 0.988200
R15537 n1_M2_35700_123180 n1_M2_36780_123180 0.988200
R15538 n1_M2_36780_123180 n1_M2_37860_123180 0.988200
R15539 n1_M2_37860_123180 n1_M2_38940_123180 0.988200
R15540 n1_M2_38940_123180 n1_M2_40020_123180 0.988200
R15541 n1_M2_40020_123180 n1_M2_41100_123180 0.988200
R15542 n1_M2_41100_123180 n1_M2_42180_123180 0.988200
R15543 n1_M2_42180_123180 n1_M2_43260_123180 0.988200
R15544 n1_M2_43260_123180 n1_M2_44340_123180 0.988200
R15545 n1_M2_44340_123180 n1_M2_45420_123180 0.988200
R15546 n1_M2_45420_123180 n1_M2_46500_123180 0.988200
R15547 n1_M2_46500_123180 n1_M2_47580_123180 0.988200
R15548 n1_M2_47580_123180 n1_M2_48660_123180 0.988200
R15549 n1_M2_48660_123180 n1_M2_49740_123180 0.988200
R15550 n1_M2_49740_123180 n1_M2_50820_123180 0.988200
R15551 n1_M2_50820_123180 n1_M2_51900_123180 0.988200
R15552 n1_M2_51900_123180 n1_M2_52980_123180 0.988200
R15553 n1_M2_52980_123180 n1_M2_54060_123180 0.988200
R15554 n1_M2_54060_123180 n1_M2_55140_123180 0.988200
R15555 n1_M2_55140_123180 n1_M2_56220_123180 0.988200
R15556 n1_M2_56220_123180 n1_M2_57300_123180 0.988200
R15557 n1_M2_57300_123180 n1_M2_58380_123180 0.988200
R15558 n1_M2_58380_123180 n1_M2_59460_123180 0.988200
R15559 n1_M2_59460_123180 n1_M2_60540_123180 0.988200
R15560 n1_M2_60540_123180 n1_M2_61620_123180 0.988200
R15561 n1_M2_61620_123180 n1_M2_62700_123180 0.988200
R15562 n1_M2_62700_123180 n1_M2_63780_123180 0.988200
R15563 n1_M2_63780_123180 n1_M2_64860_123180 0.988200
R15564 n1_M2_64860_123180 n1_M2_65940_123180 0.988200
R15565 n1_M2_65940_123180 n1_M2_67020_123180 0.988200
R15566 n1_M2_67020_123180 n1_M2_68100_123180 0.988200
R15567 n1_M2_68100_123180 n1_M2_69180_123180 0.988200
R15568 n1_M2_69180_123180 n1_M2_70260_123180 0.988200
R15569 n1_M2_70260_123180 n1_M2_71340_123180 0.988200
R15570 n1_M2_71340_123180 n1_M2_72420_123180 0.988200
R15571 n1_M2_72420_123180 n1_M2_73500_123180 0.988200
R15572 n1_M2_73500_123180 n1_M2_74580_123180 0.988200
R15573 n1_M2_74580_123180 n1_M2_75660_123180 0.988200
R15574 n1_M2_75660_123180 n1_M2_76740_123180 0.988200
R15575 n1_M2_76740_123180 n1_M2_77820_123180 0.988200
R15576 n1_M2_77820_123180 n1_M2_78900_123180 0.988200
R15577 n1_M2_78900_123180 n1_M2_79980_123180 0.988200
R15578 n1_M2_79980_123180 n1_M2_81060_123180 0.988200
R15579 n1_M2_81060_123180 n1_M2_82140_123180 0.988200
R15580 n1_M2_82140_123180 n1_M2_83220_123180 0.988200
R15581 n1_M2_83220_123180 n1_M2_84300_123180 0.988200
R15582 n1_M2_84300_123180 n1_M2_85380_123180 0.988200
R15583 n1_M2_85380_123180 n1_M2_86460_123180 0.988200
R15584 n1_M2_86460_123180 n1_M2_87540_123180 0.988200
R15585 n1_M2_87540_123180 n1_M2_88620_123180 0.988200
R15586 n1_M2_88620_123180 n1_M2_89700_123180 0.988200
R15587 n1_M2_89700_123180 n1_M2_90780_123180 0.988200
R15588 n1_M2_90780_123180 n1_M2_91860_123180 0.988200
R15589 n1_M2_91860_123180 n1_M2_92940_123180 0.988200
R15590 n1_M2_92940_123180 n1_M2_94020_123180 0.988200
R15591 n1_M2_94020_123180 n1_M2_95100_123180 0.988200
R15592 n1_M2_95100_123180 n1_M2_96180_123180 0.988200
R15593 n1_M2_96180_123180 n1_M2_97260_123180 0.988200
R15594 n1_M2_97260_123180 n1_M2_98340_123180 0.988200
R15595 n1_M2_98340_123180 n1_M2_99420_123180 0.988200
R15596 n1_M2_99420_123180 n1_M2_100500_123180 0.988200
R15597 n1_M2_100500_123180 n1_M2_101580_123180 0.988200
R15598 n1_M2_101580_123180 n1_M2_102660_123180 0.988200
R15599 n1_M2_102660_123180 n1_M2_103740_123180 0.988200
R15600 n1_M2_103740_123180 n1_M2_104820_123180 0.988200
R15601 n1_M2_104820_123180 n1_M2_105900_123180 0.988200
R15602 n1_M2_105900_123180 n1_M2_106980_123180 0.988200
R15603 n1_M2_106980_123180 n1_M2_108060_123180 0.988200
R15604 n1_M2_108060_123180 n1_M2_109140_123180 0.988200
R15605 n1_M2_109140_123180 n1_M2_110220_123180 0.988200
R15606 n1_M2_110220_123180 n1_M2_111300_123180 0.988200
R15607 n1_M2_111300_123180 n1_M2_112380_123180 0.988200
R15608 n1_M2_112380_123180 n1_M2_113460_123180 0.988200
R15609 n1_M2_113460_123180 n1_M2_114540_123180 0.988200
R15610 n1_M2_114540_123180 n1_M2_115620_123180 0.988200
R15611 n1_M2_115620_123180 n1_M2_116700_123180 0.988200
R15612 n1_M2_116700_123180 n1_M2_117780_123180 0.988200
R15613 n1_M2_117780_123180 n1_M2_118860_123180 0.988200
R15614 n1_M2_118860_123180 n1_M2_119940_123180 0.988200
R15615 n1_M2_119940_123180 n1_M2_121020_123180 0.988200
R15616 n1_M2_121020_123180 n1_M2_122100_123180 0.988200
R15617 n1_M2_122100_123180 n1_M2_123180_123180 0.988200
R15618 n1_M2_123180_123180 n1_M2_124260_123180 0.988200
R15619 n1_M2_124260_123180 n1_M2_125340_123180 0.988200
R15620 n1_M2_125340_123180 n1_M2_126420_123180 0.988200
R15621 n1_M2_126420_123180 n1_M2_127500_123180 0.988200
R15622 n1_M2_127500_123180 n1_M2_128580_123180 0.988200
R15623 n1_M2_128580_123180 n1_M2_129660_123180 0.988200
R15624 n1_M2_129660_123180 n1_M2_130740_123180 0.988200
R15625 n1_M2_130740_123180 n1_M2_131820_123180 0.988200
R15626 n1_M2_131820_123180 n1_M2_132900_123180 0.988200
R15627 n1_M2_132900_123180 n1_M2_133980_123180 0.988200
R15628 n1_M2_133980_123180 n1_M2_135060_123180 0.988200
R15629 n1_M2_135060_123180 n1_M2_136140_123180 0.988200
R15630 n1_M2_136140_123180 n1_M2_137220_123180 0.988200
R15631 n1_M2_137220_123180 n1_M2_138300_123180 0.988200
R15632 n1_M2_138300_123180 n1_M2_139380_123180 0.988200
R15633 n1_M2_139380_123180 n1_M2_140460_123180 0.988200
R15634 n1_M2_140460_123180 n1_M2_141540_123180 0.988200
R15635 n1_M2_141540_123180 n1_M2_142620_123180 0.988200
R15636 n1_M2_142620_123180 n1_M2_143700_123180 0.988200
R15637 n1_M2_143700_123180 n1_M2_144780_123180 0.988200
R15638 n1_M2_144780_123180 n1_M2_145860_123180 0.988200
R15639 n1_M2_145860_123180 n1_M2_146940_123180 0.988200
R15640 n1_M2_60_124260 n1_M2_1140_124260 0.988200
R15641 n1_M2_1140_124260 n1_M2_2220_124260 0.988200
R15642 n1_M2_2220_124260 n1_M2_3300_124260 0.988200
R15643 n1_M2_3300_124260 n1_M2_4380_124260 0.988200
R15644 n1_M2_4380_124260 n1_M2_5460_124260 0.988200
R15645 n1_M2_5460_124260 n1_M2_6540_124260 0.988200
R15646 n1_M2_6540_124260 n1_M2_7620_124260 0.988200
R15647 n1_M2_7620_124260 n1_M2_8700_124260 0.988200
R15648 n1_M2_8700_124260 n1_M2_9780_124260 0.988200
R15649 n1_M2_9780_124260 n1_M2_10860_124260 0.988200
R15650 n1_M2_10860_124260 n1_M2_11940_124260 0.988200
R15651 n1_M2_11940_124260 n1_M2_13020_124260 0.988200
R15652 n1_M2_13020_124260 n1_M2_14100_124260 0.988200
R15653 n1_M2_14100_124260 n1_M2_15180_124260 0.988200
R15654 n1_M2_15180_124260 n1_M2_16260_124260 0.988200
R15655 n1_M2_16260_124260 n1_M2_17340_124260 0.988200
R15656 n1_M2_17340_124260 n1_M2_18420_124260 0.988200
R15657 n1_M2_18420_124260 n1_M2_19500_124260 0.988200
R15658 n1_M2_19500_124260 n1_M2_20580_124260 0.988200
R15659 n1_M2_20580_124260 n1_M2_21660_124260 0.988200
R15660 n1_M2_21660_124260 n1_M2_22740_124260 0.988200
R15661 n1_M2_22740_124260 n1_M2_23820_124260 0.988200
R15662 n1_M2_23820_124260 n1_M2_24900_124260 0.988200
R15663 n1_M2_24900_124260 n1_M2_25980_124260 0.988200
R15664 n1_M2_25980_124260 n1_M2_27060_124260 0.988200
R15665 n1_M2_27060_124260 n1_M2_28140_124260 0.988200
R15666 n1_M2_28140_124260 n1_M2_29220_124260 0.988200
R15667 n1_M2_29220_124260 n1_M2_30300_124260 0.988200
R15668 n1_M2_30300_124260 n1_M2_31380_124260 0.988200
R15669 n1_M2_31380_124260 n1_M2_32460_124260 0.988200
R15670 n1_M2_32460_124260 n1_M2_33540_124260 0.988200
R15671 n1_M2_33540_124260 n1_M2_34620_124260 0.988200
R15672 n1_M2_34620_124260 n1_M2_35700_124260 0.988200
R15673 n1_M2_35700_124260 n1_M2_36780_124260 0.988200
R15674 n1_M2_36780_124260 n1_M2_37860_124260 0.988200
R15675 n1_M2_37860_124260 n1_M2_38940_124260 0.988200
R15676 n1_M2_38940_124260 n1_M2_40020_124260 0.988200
R15677 n1_M2_40020_124260 n1_M2_41100_124260 0.988200
R15678 n1_M2_41100_124260 n1_M2_42180_124260 0.988200
R15679 n1_M2_42180_124260 n1_M2_43260_124260 0.988200
R15680 n1_M2_43260_124260 n1_M2_44340_124260 0.988200
R15681 n1_M2_44340_124260 n1_M2_45420_124260 0.988200
R15682 n1_M2_45420_124260 n1_M2_46500_124260 0.988200
R15683 n1_M2_46500_124260 n1_M2_47580_124260 0.988200
R15684 n1_M2_47580_124260 n1_M2_48660_124260 0.988200
R15685 n1_M2_48660_124260 n1_M2_49740_124260 0.988200
R15686 n1_M2_49740_124260 n1_M2_50820_124260 0.988200
R15687 n1_M2_50820_124260 n1_M2_51900_124260 0.988200
R15688 n1_M2_51900_124260 n1_M2_52980_124260 0.988200
R15689 n1_M2_52980_124260 n1_M2_54060_124260 0.988200
R15690 n1_M2_54060_124260 n1_M2_55140_124260 0.988200
R15691 n1_M2_55140_124260 n1_M2_56220_124260 0.988200
R15692 n1_M2_56220_124260 n1_M2_57300_124260 0.988200
R15693 n1_M2_57300_124260 n1_M2_58380_124260 0.988200
R15694 n1_M2_58380_124260 n1_M2_59460_124260 0.988200
R15695 n1_M2_59460_124260 n1_M2_60540_124260 0.988200
R15696 n1_M2_60540_124260 n1_M2_61620_124260 0.988200
R15697 n1_M2_61620_124260 n1_M2_62700_124260 0.988200
R15698 n1_M2_62700_124260 n1_M2_63780_124260 0.988200
R15699 n1_M2_63780_124260 n1_M2_64860_124260 0.988200
R15700 n1_M2_64860_124260 n1_M2_65940_124260 0.988200
R15701 n1_M2_65940_124260 n1_M2_67020_124260 0.988200
R15702 n1_M2_67020_124260 n1_M2_68100_124260 0.988200
R15703 n1_M2_68100_124260 n1_M2_69180_124260 0.988200
R15704 n1_M2_69180_124260 n1_M2_70260_124260 0.988200
R15705 n1_M2_70260_124260 n1_M2_71340_124260 0.988200
R15706 n1_M2_71340_124260 n1_M2_72420_124260 0.988200
R15707 n1_M2_72420_124260 n1_M2_73500_124260 0.988200
R15708 n1_M2_73500_124260 n1_M2_74580_124260 0.988200
R15709 n1_M2_74580_124260 n1_M2_75660_124260 0.988200
R15710 n1_M2_75660_124260 n1_M2_76740_124260 0.988200
R15711 n1_M2_76740_124260 n1_M2_77820_124260 0.988200
R15712 n1_M2_77820_124260 n1_M2_78900_124260 0.988200
R15713 n1_M2_78900_124260 n1_M2_79980_124260 0.988200
R15714 n1_M2_79980_124260 n1_M2_81060_124260 0.988200
R15715 n1_M2_81060_124260 n1_M2_82140_124260 0.988200
R15716 n1_M2_82140_124260 n1_M2_83220_124260 0.988200
R15717 n1_M2_83220_124260 n1_M2_84300_124260 0.988200
R15718 n1_M2_84300_124260 n1_M2_85380_124260 0.988200
R15719 n1_M2_85380_124260 n1_M2_86460_124260 0.988200
R15720 n1_M2_86460_124260 n1_M2_87540_124260 0.988200
R15721 n1_M2_87540_124260 n1_M2_88620_124260 0.988200
R15722 n1_M2_88620_124260 n1_M2_89700_124260 0.988200
R15723 n1_M2_89700_124260 n1_M2_90780_124260 0.988200
R15724 n1_M2_90780_124260 n1_M2_91860_124260 0.988200
R15725 n1_M2_91860_124260 n1_M2_92940_124260 0.988200
R15726 n1_M2_92940_124260 n1_M2_94020_124260 0.988200
R15727 n1_M2_94020_124260 n1_M2_95100_124260 0.988200
R15728 n1_M2_95100_124260 n1_M2_96180_124260 0.988200
R15729 n1_M2_96180_124260 n1_M2_97260_124260 0.988200
R15730 n1_M2_97260_124260 n1_M2_98340_124260 0.988200
R15731 n1_M2_98340_124260 n1_M2_99420_124260 0.988200
R15732 n1_M2_99420_124260 n1_M2_100500_124260 0.988200
R15733 n1_M2_100500_124260 n1_M2_101580_124260 0.988200
R15734 n1_M2_101580_124260 n1_M2_102660_124260 0.988200
R15735 n1_M2_102660_124260 n1_M2_103740_124260 0.988200
R15736 n1_M2_103740_124260 n1_M2_104820_124260 0.988200
R15737 n1_M2_104820_124260 n1_M2_105900_124260 0.988200
R15738 n1_M2_105900_124260 n1_M2_106980_124260 0.988200
R15739 n1_M2_106980_124260 n1_M2_108060_124260 0.988200
R15740 n1_M2_108060_124260 n1_M2_109140_124260 0.988200
R15741 n1_M2_109140_124260 n1_M2_110220_124260 0.988200
R15742 n1_M2_110220_124260 n1_M2_111300_124260 0.988200
R15743 n1_M2_111300_124260 n1_M2_112380_124260 0.988200
R15744 n1_M2_112380_124260 n1_M2_113460_124260 0.988200
R15745 n1_M2_113460_124260 n1_M2_114540_124260 0.988200
R15746 n1_M2_114540_124260 n1_M2_115620_124260 0.988200
R15747 n1_M2_115620_124260 n1_M2_116700_124260 0.988200
R15748 n1_M2_116700_124260 n1_M2_117780_124260 0.988200
R15749 n1_M2_117780_124260 n1_M2_118860_124260 0.988200
R15750 n1_M2_118860_124260 n1_M2_119940_124260 0.988200
R15751 n1_M2_119940_124260 n1_M2_121020_124260 0.988200
R15752 n1_M2_121020_124260 n1_M2_122100_124260 0.988200
R15753 n1_M2_122100_124260 n1_M2_123180_124260 0.988200
R15754 n1_M2_123180_124260 n1_M2_124260_124260 0.988200
R15755 n1_M2_124260_124260 n1_M2_125340_124260 0.988200
R15756 n1_M2_125340_124260 n1_M2_126420_124260 0.988200
R15757 n1_M2_126420_124260 n1_M2_127500_124260 0.988200
R15758 n1_M2_127500_124260 n1_M2_128580_124260 0.988200
R15759 n1_M2_128580_124260 n1_M2_129660_124260 0.988200
R15760 n1_M2_129660_124260 n1_M2_130740_124260 0.988200
R15761 n1_M2_130740_124260 n1_M2_131820_124260 0.988200
R15762 n1_M2_131820_124260 n1_M2_132900_124260 0.988200
R15763 n1_M2_132900_124260 n1_M2_133980_124260 0.988200
R15764 n1_M2_133980_124260 n1_M2_135060_124260 0.988200
R15765 n1_M2_135060_124260 n1_M2_136140_124260 0.988200
R15766 n1_M2_136140_124260 n1_M2_137220_124260 0.988200
R15767 n1_M2_137220_124260 n1_M2_138300_124260 0.988200
R15768 n1_M2_138300_124260 n1_M2_139380_124260 0.988200
R15769 n1_M2_139380_124260 n1_M2_140460_124260 0.988200
R15770 n1_M2_140460_124260 n1_M2_141540_124260 0.988200
R15771 n1_M2_141540_124260 n1_M2_142620_124260 0.988200
R15772 n1_M2_142620_124260 n1_M2_143700_124260 0.988200
R15773 n1_M2_143700_124260 n1_M2_144780_124260 0.988200
R15774 n1_M2_144780_124260 n1_M2_145860_124260 0.988200
R15775 n1_M2_145860_124260 n1_M2_146940_124260 0.988200
R15776 n1_M2_60_125340 n1_M2_1140_125340 0.988200
R15777 n1_M2_1140_125340 n1_M2_2220_125340 0.988200
R15778 n1_M2_2220_125340 n1_M2_3300_125340 0.988200
R15779 n1_M2_3300_125340 n1_M2_4380_125340 0.988200
R15780 n1_M2_4380_125340 n1_M2_5460_125340 0.988200
R15781 n1_M2_5460_125340 n1_M2_6540_125340 0.988200
R15782 n1_M2_6540_125340 n1_M2_7620_125340 0.988200
R15783 n1_M2_7620_125340 n1_M2_8700_125340 0.988200
R15784 n1_M2_8700_125340 n1_M2_9780_125340 0.988200
R15785 n1_M2_9780_125340 n1_M2_10860_125340 0.988200
R15786 n1_M2_10860_125340 n1_M2_11940_125340 0.988200
R15787 n1_M2_11940_125340 n1_M2_13020_125340 0.988200
R15788 n1_M2_13020_125340 n1_M2_14100_125340 0.988200
R15789 n1_M2_14100_125340 n1_M2_15180_125340 0.988200
R15790 n1_M2_15180_125340 n1_M2_16260_125340 0.988200
R15791 n1_M2_16260_125340 n1_M2_17340_125340 0.988200
R15792 n1_M2_17340_125340 n1_M2_18420_125340 0.988200
R15793 n1_M2_18420_125340 n1_M2_19500_125340 0.988200
R15794 n1_M2_19500_125340 n1_M2_20580_125340 0.988200
R15795 n1_M2_20580_125340 n1_M2_21660_125340 0.988200
R15796 n1_M2_21660_125340 n1_M2_22740_125340 0.988200
R15797 n1_M2_22740_125340 n1_M2_23820_125340 0.988200
R15798 n1_M2_23820_125340 n1_M2_24900_125340 0.988200
R15799 n1_M2_24900_125340 n1_M2_25980_125340 0.988200
R15800 n1_M2_25980_125340 n1_M2_27060_125340 0.988200
R15801 n1_M2_27060_125340 n1_M2_28140_125340 0.988200
R15802 n1_M2_28140_125340 n1_M2_29220_125340 0.988200
R15803 n1_M2_29220_125340 n1_M2_30300_125340 0.988200
R15804 n1_M2_30300_125340 n1_M2_31380_125340 0.988200
R15805 n1_M2_31380_125340 n1_M2_32460_125340 0.988200
R15806 n1_M2_32460_125340 n1_M2_33540_125340 0.988200
R15807 n1_M2_33540_125340 n1_M2_34620_125340 0.988200
R15808 n1_M2_34620_125340 n1_M2_35700_125340 0.988200
R15809 n1_M2_35700_125340 n1_M2_36780_125340 0.988200
R15810 n1_M2_36780_125340 n1_M2_37860_125340 0.988200
R15811 n1_M2_37860_125340 n1_M2_38940_125340 0.988200
R15812 n1_M2_38940_125340 n1_M2_40020_125340 0.988200
R15813 n1_M2_40020_125340 n1_M2_41100_125340 0.988200
R15814 n1_M2_41100_125340 n1_M2_42180_125340 0.988200
R15815 n1_M2_42180_125340 n1_M2_43260_125340 0.988200
R15816 n1_M2_43260_125340 n1_M2_44340_125340 0.988200
R15817 n1_M2_44340_125340 n1_M2_45420_125340 0.988200
R15818 n1_M2_45420_125340 n1_M2_46500_125340 0.988200
R15819 n1_M2_46500_125340 n1_M2_47580_125340 0.988200
R15820 n1_M2_47580_125340 n1_M2_48660_125340 0.988200
R15821 n1_M2_48660_125340 n1_M2_49740_125340 0.988200
R15822 n1_M2_49740_125340 n1_M2_50820_125340 0.988200
R15823 n1_M2_50820_125340 n1_M2_51900_125340 0.988200
R15824 n1_M2_51900_125340 n1_M2_52980_125340 0.988200
R15825 n1_M2_52980_125340 n1_M2_54060_125340 0.988200
R15826 n1_M2_54060_125340 n1_M2_55140_125340 0.988200
R15827 n1_M2_55140_125340 n1_M2_56220_125340 0.988200
R15828 n1_M2_56220_125340 n1_M2_57300_125340 0.988200
R15829 n1_M2_57300_125340 n1_M2_58380_125340 0.988200
R15830 n1_M2_58380_125340 n1_M2_59460_125340 0.988200
R15831 n1_M2_59460_125340 n1_M2_60540_125340 0.988200
R15832 n1_M2_60540_125340 n1_M2_61620_125340 0.988200
R15833 n1_M2_61620_125340 n1_M2_62700_125340 0.988200
R15834 n1_M2_62700_125340 n1_M2_63780_125340 0.988200
R15835 n1_M2_63780_125340 n1_M2_64860_125340 0.988200
R15836 n1_M2_64860_125340 n1_M2_65940_125340 0.988200
R15837 n1_M2_65940_125340 n1_M2_67020_125340 0.988200
R15838 n1_M2_67020_125340 n1_M2_68100_125340 0.988200
R15839 n1_M2_68100_125340 n1_M2_69180_125340 0.988200
R15840 n1_M2_69180_125340 n1_M2_70260_125340 0.988200
R15841 n1_M2_70260_125340 n1_M2_71340_125340 0.988200
R15842 n1_M2_71340_125340 n1_M2_72420_125340 0.988200
R15843 n1_M2_72420_125340 n1_M2_73500_125340 0.988200
R15844 n1_M2_73500_125340 n1_M2_74580_125340 0.988200
R15845 n1_M2_74580_125340 n1_M2_75660_125340 0.988200
R15846 n1_M2_75660_125340 n1_M2_76740_125340 0.988200
R15847 n1_M2_76740_125340 n1_M2_77820_125340 0.988200
R15848 n1_M2_77820_125340 n1_M2_78900_125340 0.988200
R15849 n1_M2_78900_125340 n1_M2_79980_125340 0.988200
R15850 n1_M2_79980_125340 n1_M2_81060_125340 0.988200
R15851 n1_M2_81060_125340 n1_M2_82140_125340 0.988200
R15852 n1_M2_82140_125340 n1_M2_83220_125340 0.988200
R15853 n1_M2_83220_125340 n1_M2_84300_125340 0.988200
R15854 n1_M2_84300_125340 n1_M2_85380_125340 0.988200
R15855 n1_M2_85380_125340 n1_M2_86460_125340 0.988200
R15856 n1_M2_86460_125340 n1_M2_87540_125340 0.988200
R15857 n1_M2_87540_125340 n1_M2_88620_125340 0.988200
R15858 n1_M2_88620_125340 n1_M2_89700_125340 0.988200
R15859 n1_M2_89700_125340 n1_M2_90780_125340 0.988200
R15860 n1_M2_90780_125340 n1_M2_91860_125340 0.988200
R15861 n1_M2_91860_125340 n1_M2_92940_125340 0.988200
R15862 n1_M2_92940_125340 n1_M2_94020_125340 0.988200
R15863 n1_M2_94020_125340 n1_M2_95100_125340 0.988200
R15864 n1_M2_95100_125340 n1_M2_96180_125340 0.988200
R15865 n1_M2_96180_125340 n1_M2_97260_125340 0.988200
R15866 n1_M2_97260_125340 n1_M2_98340_125340 0.988200
R15867 n1_M2_98340_125340 n1_M2_99420_125340 0.988200
R15868 n1_M2_99420_125340 n1_M2_100500_125340 0.988200
R15869 n1_M2_100500_125340 n1_M2_101580_125340 0.988200
R15870 n1_M2_101580_125340 n1_M2_102660_125340 0.988200
R15871 n1_M2_102660_125340 n1_M2_103740_125340 0.988200
R15872 n1_M2_103740_125340 n1_M2_104820_125340 0.988200
R15873 n1_M2_104820_125340 n1_M2_105900_125340 0.988200
R15874 n1_M2_105900_125340 n1_M2_106980_125340 0.988200
R15875 n1_M2_106980_125340 n1_M2_108060_125340 0.988200
R15876 n1_M2_108060_125340 n1_M2_109140_125340 0.988200
R15877 n1_M2_109140_125340 n1_M2_110220_125340 0.988200
R15878 n1_M2_110220_125340 n1_M2_111300_125340 0.988200
R15879 n1_M2_111300_125340 n1_M2_112380_125340 0.988200
R15880 n1_M2_112380_125340 n1_M2_113460_125340 0.988200
R15881 n1_M2_113460_125340 n1_M2_114540_125340 0.988200
R15882 n1_M2_114540_125340 n1_M2_115620_125340 0.988200
R15883 n1_M2_115620_125340 n1_M2_116700_125340 0.988200
R15884 n1_M2_116700_125340 n1_M2_117780_125340 0.988200
R15885 n1_M2_117780_125340 n1_M2_118860_125340 0.988200
R15886 n1_M2_118860_125340 n1_M2_119940_125340 0.988200
R15887 n1_M2_119940_125340 n1_M2_121020_125340 0.988200
R15888 n1_M2_121020_125340 n1_M2_122100_125340 0.988200
R15889 n1_M2_122100_125340 n1_M2_123180_125340 0.988200
R15890 n1_M2_123180_125340 n1_M2_124260_125340 0.988200
R15891 n1_M2_124260_125340 n1_M2_125340_125340 0.988200
R15892 n1_M2_125340_125340 n1_M2_126420_125340 0.988200
R15893 n1_M2_126420_125340 n1_M2_127500_125340 0.988200
R15894 n1_M2_127500_125340 n1_M2_128580_125340 0.988200
R15895 n1_M2_128580_125340 n1_M2_129660_125340 0.988200
R15896 n1_M2_129660_125340 n1_M2_130740_125340 0.988200
R15897 n1_M2_130740_125340 n1_M2_131820_125340 0.988200
R15898 n1_M2_131820_125340 n1_M2_132900_125340 0.988200
R15899 n1_M2_132900_125340 n1_M2_133980_125340 0.988200
R15900 n1_M2_133980_125340 n1_M2_135060_125340 0.988200
R15901 n1_M2_135060_125340 n1_M2_136140_125340 0.988200
R15902 n1_M2_136140_125340 n1_M2_137220_125340 0.988200
R15903 n1_M2_137220_125340 n1_M2_138300_125340 0.988200
R15904 n1_M2_138300_125340 n1_M2_139380_125340 0.988200
R15905 n1_M2_139380_125340 n1_M2_140460_125340 0.988200
R15906 n1_M2_140460_125340 n1_M2_141540_125340 0.988200
R15907 n1_M2_141540_125340 n1_M2_142620_125340 0.988200
R15908 n1_M2_142620_125340 n1_M2_143700_125340 0.988200
R15909 n1_M2_143700_125340 n1_M2_144780_125340 0.988200
R15910 n1_M2_144780_125340 n1_M2_145860_125340 0.988200
R15911 n1_M2_145860_125340 n1_M2_146940_125340 0.988200
R15912 n1_M2_60_126420 n1_M2_1140_126420 0.988200
R15913 n1_M2_1140_126420 n1_M2_2220_126420 0.988200
R15914 n1_M2_2220_126420 n1_M2_3300_126420 0.988200
R15915 n1_M2_3300_126420 n1_M2_4380_126420 0.988200
R15916 n1_M2_4380_126420 n1_M2_5460_126420 0.988200
R15917 n1_M2_5460_126420 n1_M2_6540_126420 0.988200
R15918 n1_M2_6540_126420 n1_M2_7620_126420 0.988200
R15919 n1_M2_7620_126420 n1_M2_8700_126420 0.988200
R15920 n1_M2_8700_126420 n1_M2_9780_126420 0.988200
R15921 n1_M2_9780_126420 n1_M2_10860_126420 0.988200
R15922 n1_M2_10860_126420 n1_M2_11940_126420 0.988200
R15923 n1_M2_11940_126420 n1_M2_13020_126420 0.988200
R15924 n1_M2_13020_126420 n1_M2_14100_126420 0.988200
R15925 n1_M2_14100_126420 n1_M2_15180_126420 0.988200
R15926 n1_M2_15180_126420 n1_M2_16260_126420 0.988200
R15927 n1_M2_16260_126420 n1_M2_17340_126420 0.988200
R15928 n1_M2_17340_126420 n1_M2_18420_126420 0.988200
R15929 n1_M2_18420_126420 n1_M2_19500_126420 0.988200
R15930 n1_M2_19500_126420 n1_M2_20580_126420 0.988200
R15931 n1_M2_20580_126420 n1_M2_21660_126420 0.988200
R15932 n1_M2_21660_126420 n1_M2_22740_126420 0.988200
R15933 n1_M2_22740_126420 n1_M2_23820_126420 0.988200
R15934 n1_M2_23820_126420 n1_M2_24900_126420 0.988200
R15935 n1_M2_24900_126420 n1_M2_25980_126420 0.988200
R15936 n1_M2_25980_126420 n1_M2_27060_126420 0.988200
R15937 n1_M2_27060_126420 n1_M2_28140_126420 0.988200
R15938 n1_M2_28140_126420 n1_M2_29220_126420 0.988200
R15939 n1_M2_29220_126420 n1_M2_30300_126420 0.988200
R15940 n1_M2_30300_126420 n1_M2_31380_126420 0.988200
R15941 n1_M2_31380_126420 n1_M2_32460_126420 0.988200
R15942 n1_M2_32460_126420 n1_M2_33540_126420 0.988200
R15943 n1_M2_33540_126420 n1_M2_34620_126420 0.988200
R15944 n1_M2_34620_126420 n1_M2_35700_126420 0.988200
R15945 n1_M2_35700_126420 n1_M2_36780_126420 0.988200
R15946 n1_M2_36780_126420 n1_M2_37860_126420 0.988200
R15947 n1_M2_37860_126420 n1_M2_38940_126420 0.988200
R15948 n1_M2_38940_126420 n1_M2_40020_126420 0.988200
R15949 n1_M2_40020_126420 n1_M2_41100_126420 0.988200
R15950 n1_M2_41100_126420 n1_M2_42180_126420 0.988200
R15951 n1_M2_42180_126420 n1_M2_43260_126420 0.988200
R15952 n1_M2_43260_126420 n1_M2_44340_126420 0.988200
R15953 n1_M2_44340_126420 n1_M2_45420_126420 0.988200
R15954 n1_M2_45420_126420 n1_M2_46500_126420 0.988200
R15955 n1_M2_46500_126420 n1_M2_47580_126420 0.988200
R15956 n1_M2_47580_126420 n1_M2_48660_126420 0.988200
R15957 n1_M2_48660_126420 n1_M2_49740_126420 0.988200
R15958 n1_M2_49740_126420 n1_M2_50820_126420 0.988200
R15959 n1_M2_50820_126420 n1_M2_51900_126420 0.988200
R15960 n1_M2_51900_126420 n1_M2_52980_126420 0.988200
R15961 n1_M2_52980_126420 n1_M2_54060_126420 0.988200
R15962 n1_M2_54060_126420 n1_M2_55140_126420 0.988200
R15963 n1_M2_55140_126420 n1_M2_56220_126420 0.988200
R15964 n1_M2_56220_126420 n1_M2_57300_126420 0.988200
R15965 n1_M2_57300_126420 n1_M2_58380_126420 0.988200
R15966 n1_M2_58380_126420 n1_M2_59460_126420 0.988200
R15967 n1_M2_59460_126420 n1_M2_60540_126420 0.988200
R15968 n1_M2_60540_126420 n1_M2_61620_126420 0.988200
R15969 n1_M2_61620_126420 n1_M2_62700_126420 0.988200
R15970 n1_M2_62700_126420 n1_M2_63780_126420 0.988200
R15971 n1_M2_63780_126420 n1_M2_64860_126420 0.988200
R15972 n1_M2_64860_126420 n1_M2_65940_126420 0.988200
R15973 n1_M2_65940_126420 n1_M2_67020_126420 0.988200
R15974 n1_M2_67020_126420 n1_M2_68100_126420 0.988200
R15975 n1_M2_68100_126420 n1_M2_69180_126420 0.988200
R15976 n1_M2_69180_126420 n1_M2_70260_126420 0.988200
R15977 n1_M2_70260_126420 n1_M2_71340_126420 0.988200
R15978 n1_M2_71340_126420 n1_M2_72420_126420 0.988200
R15979 n1_M2_72420_126420 n1_M2_73500_126420 0.988200
R15980 n1_M2_73500_126420 n1_M2_74580_126420 0.988200
R15981 n1_M2_74580_126420 n1_M2_75660_126420 0.988200
R15982 n1_M2_75660_126420 n1_M2_76740_126420 0.988200
R15983 n1_M2_76740_126420 n1_M2_77820_126420 0.988200
R15984 n1_M2_77820_126420 n1_M2_78900_126420 0.988200
R15985 n1_M2_78900_126420 n1_M2_79980_126420 0.988200
R15986 n1_M2_79980_126420 n1_M2_81060_126420 0.988200
R15987 n1_M2_81060_126420 n1_M2_82140_126420 0.988200
R15988 n1_M2_82140_126420 n1_M2_83220_126420 0.988200
R15989 n1_M2_83220_126420 n1_M2_84300_126420 0.988200
R15990 n1_M2_84300_126420 n1_M2_85380_126420 0.988200
R15991 n1_M2_85380_126420 n1_M2_86460_126420 0.988200
R15992 n1_M2_86460_126420 n1_M2_87540_126420 0.988200
R15993 n1_M2_87540_126420 n1_M2_88620_126420 0.988200
R15994 n1_M2_88620_126420 n1_M2_89700_126420 0.988200
R15995 n1_M2_89700_126420 n1_M2_90780_126420 0.988200
R15996 n1_M2_90780_126420 n1_M2_91860_126420 0.988200
R15997 n1_M2_91860_126420 n1_M2_92940_126420 0.988200
R15998 n1_M2_92940_126420 n1_M2_94020_126420 0.988200
R15999 n1_M2_94020_126420 n1_M2_95100_126420 0.988200
R16000 n1_M2_95100_126420 n1_M2_96180_126420 0.988200
R16001 n1_M2_96180_126420 n1_M2_97260_126420 0.988200
R16002 n1_M2_97260_126420 n1_M2_98340_126420 0.988200
R16003 n1_M2_98340_126420 n1_M2_99420_126420 0.988200
R16004 n1_M2_99420_126420 n1_M2_100500_126420 0.988200
R16005 n1_M2_100500_126420 n1_M2_101580_126420 0.988200
R16006 n1_M2_101580_126420 n1_M2_102660_126420 0.988200
R16007 n1_M2_102660_126420 n1_M2_103740_126420 0.988200
R16008 n1_M2_103740_126420 n1_M2_104820_126420 0.988200
R16009 n1_M2_104820_126420 n1_M2_105900_126420 0.988200
R16010 n1_M2_105900_126420 n1_M2_106980_126420 0.988200
R16011 n1_M2_106980_126420 n1_M2_108060_126420 0.988200
R16012 n1_M2_108060_126420 n1_M2_109140_126420 0.988200
R16013 n1_M2_109140_126420 n1_M2_110220_126420 0.988200
R16014 n1_M2_110220_126420 n1_M2_111300_126420 0.988200
R16015 n1_M2_111300_126420 n1_M2_112380_126420 0.988200
R16016 n1_M2_112380_126420 n1_M2_113460_126420 0.988200
R16017 n1_M2_113460_126420 n1_M2_114540_126420 0.988200
R16018 n1_M2_114540_126420 n1_M2_115620_126420 0.988200
R16019 n1_M2_115620_126420 n1_M2_116700_126420 0.988200
R16020 n1_M2_116700_126420 n1_M2_117780_126420 0.988200
R16021 n1_M2_117780_126420 n1_M2_118860_126420 0.988200
R16022 n1_M2_118860_126420 n1_M2_119940_126420 0.988200
R16023 n1_M2_119940_126420 n1_M2_121020_126420 0.988200
R16024 n1_M2_121020_126420 n1_M2_122100_126420 0.988200
R16025 n1_M2_122100_126420 n1_M2_123180_126420 0.988200
R16026 n1_M2_123180_126420 n1_M2_124260_126420 0.988200
R16027 n1_M2_124260_126420 n1_M2_125340_126420 0.988200
R16028 n1_M2_125340_126420 n1_M2_126420_126420 0.988200
R16029 n1_M2_126420_126420 n1_M2_127500_126420 0.988200
R16030 n1_M2_127500_126420 n1_M2_128580_126420 0.988200
R16031 n1_M2_128580_126420 n1_M2_129660_126420 0.988200
R16032 n1_M2_129660_126420 n1_M2_130740_126420 0.988200
R16033 n1_M2_130740_126420 n1_M2_131820_126420 0.988200
R16034 n1_M2_131820_126420 n1_M2_132900_126420 0.988200
R16035 n1_M2_132900_126420 n1_M2_133980_126420 0.988200
R16036 n1_M2_133980_126420 n1_M2_135060_126420 0.988200
R16037 n1_M2_135060_126420 n1_M2_136140_126420 0.988200
R16038 n1_M2_136140_126420 n1_M2_137220_126420 0.988200
R16039 n1_M2_137220_126420 n1_M2_138300_126420 0.988200
R16040 n1_M2_138300_126420 n1_M2_139380_126420 0.988200
R16041 n1_M2_139380_126420 n1_M2_140460_126420 0.988200
R16042 n1_M2_140460_126420 n1_M2_141540_126420 0.988200
R16043 n1_M2_141540_126420 n1_M2_142620_126420 0.988200
R16044 n1_M2_142620_126420 n1_M2_143700_126420 0.988200
R16045 n1_M2_143700_126420 n1_M2_144780_126420 0.988200
R16046 n1_M2_144780_126420 n1_M2_145860_126420 0.988200
R16047 n1_M2_145860_126420 n1_M2_146940_126420 0.988200
R16048 n1_M2_60_127500 n1_M2_1140_127500 0.988200
R16049 n1_M2_1140_127500 n1_M2_2220_127500 0.988200
R16050 n1_M2_2220_127500 n1_M2_3300_127500 0.988200
R16051 n1_M2_3300_127500 n1_M2_4380_127500 0.988200
R16052 n1_M2_4380_127500 n1_M2_5460_127500 0.988200
R16053 n1_M2_5460_127500 n1_M2_6540_127500 0.988200
R16054 n1_M2_6540_127500 n1_M2_7620_127500 0.988200
R16055 n1_M2_7620_127500 n1_M2_8700_127500 0.988200
R16056 n1_M2_8700_127500 n1_M2_9780_127500 0.988200
R16057 n1_M2_9780_127500 n1_M2_10860_127500 0.988200
R16058 n1_M2_10860_127500 n1_M2_11940_127500 0.988200
R16059 n1_M2_11940_127500 n1_M2_13020_127500 0.988200
R16060 n1_M2_13020_127500 n1_M2_14100_127500 0.988200
R16061 n1_M2_14100_127500 n1_M2_15180_127500 0.988200
R16062 n1_M2_15180_127500 n1_M2_16260_127500 0.988200
R16063 n1_M2_16260_127500 n1_M2_17340_127500 0.988200
R16064 n1_M2_17340_127500 n1_M2_18420_127500 0.988200
R16065 n1_M2_18420_127500 n1_M2_19500_127500 0.988200
R16066 n1_M2_19500_127500 n1_M2_20580_127500 0.988200
R16067 n1_M2_20580_127500 n1_M2_21660_127500 0.988200
R16068 n1_M2_21660_127500 n1_M2_22740_127500 0.988200
R16069 n1_M2_22740_127500 n1_M2_23820_127500 0.988200
R16070 n1_M2_23820_127500 n1_M2_24900_127500 0.988200
R16071 n1_M2_24900_127500 n1_M2_25980_127500 0.988200
R16072 n1_M2_25980_127500 n1_M2_27060_127500 0.988200
R16073 n1_M2_27060_127500 n1_M2_28140_127500 0.988200
R16074 n1_M2_28140_127500 n1_M2_29220_127500 0.988200
R16075 n1_M2_29220_127500 n1_M2_30300_127500 0.988200
R16076 n1_M2_30300_127500 n1_M2_31380_127500 0.988200
R16077 n1_M2_31380_127500 n1_M2_32460_127500 0.988200
R16078 n1_M2_32460_127500 n1_M2_33540_127500 0.988200
R16079 n1_M2_33540_127500 n1_M2_34620_127500 0.988200
R16080 n1_M2_34620_127500 n1_M2_35700_127500 0.988200
R16081 n1_M2_35700_127500 n1_M2_36780_127500 0.988200
R16082 n1_M2_36780_127500 n1_M2_37860_127500 0.988200
R16083 n1_M2_37860_127500 n1_M2_38940_127500 0.988200
R16084 n1_M2_38940_127500 n1_M2_40020_127500 0.988200
R16085 n1_M2_40020_127500 n1_M2_41100_127500 0.988200
R16086 n1_M2_41100_127500 n1_M2_42180_127500 0.988200
R16087 n1_M2_42180_127500 n1_M2_43260_127500 0.988200
R16088 n1_M2_43260_127500 n1_M2_44340_127500 0.988200
R16089 n1_M2_44340_127500 n1_M2_45420_127500 0.988200
R16090 n1_M2_45420_127500 n1_M2_46500_127500 0.988200
R16091 n1_M2_46500_127500 n1_M2_47580_127500 0.988200
R16092 n1_M2_47580_127500 n1_M2_48660_127500 0.988200
R16093 n1_M2_48660_127500 n1_M2_49740_127500 0.988200
R16094 n1_M2_49740_127500 n1_M2_50820_127500 0.988200
R16095 n1_M2_50820_127500 n1_M2_51900_127500 0.988200
R16096 n1_M2_51900_127500 n1_M2_52980_127500 0.988200
R16097 n1_M2_52980_127500 n1_M2_54060_127500 0.988200
R16098 n1_M2_54060_127500 n1_M2_55140_127500 0.988200
R16099 n1_M2_55140_127500 n1_M2_56220_127500 0.988200
R16100 n1_M2_56220_127500 n1_M2_57300_127500 0.988200
R16101 n1_M2_57300_127500 n1_M2_58380_127500 0.988200
R16102 n1_M2_58380_127500 n1_M2_59460_127500 0.988200
R16103 n1_M2_59460_127500 n1_M2_60540_127500 0.988200
R16104 n1_M2_60540_127500 n1_M2_61620_127500 0.988200
R16105 n1_M2_61620_127500 n1_M2_62700_127500 0.988200
R16106 n1_M2_62700_127500 n1_M2_63780_127500 0.988200
R16107 n1_M2_63780_127500 n1_M2_64860_127500 0.988200
R16108 n1_M2_64860_127500 n1_M2_65940_127500 0.988200
R16109 n1_M2_65940_127500 n1_M2_67020_127500 0.988200
R16110 n1_M2_67020_127500 n1_M2_68100_127500 0.988200
R16111 n1_M2_68100_127500 n1_M2_69180_127500 0.988200
R16112 n1_M2_69180_127500 n1_M2_70260_127500 0.988200
R16113 n1_M2_70260_127500 n1_M2_71340_127500 0.988200
R16114 n1_M2_71340_127500 n1_M2_72420_127500 0.988200
R16115 n1_M2_72420_127500 n1_M2_73500_127500 0.988200
R16116 n1_M2_73500_127500 n1_M2_74580_127500 0.988200
R16117 n1_M2_74580_127500 n1_M2_75660_127500 0.988200
R16118 n1_M2_75660_127500 n1_M2_76740_127500 0.988200
R16119 n1_M2_76740_127500 n1_M2_77820_127500 0.988200
R16120 n1_M2_77820_127500 n1_M2_78900_127500 0.988200
R16121 n1_M2_78900_127500 n1_M2_79980_127500 0.988200
R16122 n1_M2_79980_127500 n1_M2_81060_127500 0.988200
R16123 n1_M2_81060_127500 n1_M2_82140_127500 0.988200
R16124 n1_M2_82140_127500 n1_M2_83220_127500 0.988200
R16125 n1_M2_83220_127500 n1_M2_84300_127500 0.988200
R16126 n1_M2_84300_127500 n1_M2_85380_127500 0.988200
R16127 n1_M2_85380_127500 n1_M2_86460_127500 0.988200
R16128 n1_M2_86460_127500 n1_M2_87540_127500 0.988200
R16129 n1_M2_87540_127500 n1_M2_88620_127500 0.988200
R16130 n1_M2_88620_127500 n1_M2_89700_127500 0.988200
R16131 n1_M2_89700_127500 n1_M2_90780_127500 0.988200
R16132 n1_M2_90780_127500 n1_M2_91860_127500 0.988200
R16133 n1_M2_91860_127500 n1_M2_92940_127500 0.988200
R16134 n1_M2_92940_127500 n1_M2_94020_127500 0.988200
R16135 n1_M2_94020_127500 n1_M2_95100_127500 0.988200
R16136 n1_M2_95100_127500 n1_M2_96180_127500 0.988200
R16137 n1_M2_96180_127500 n1_M2_97260_127500 0.988200
R16138 n1_M2_97260_127500 n1_M2_98340_127500 0.988200
R16139 n1_M2_98340_127500 n1_M2_99420_127500 0.988200
R16140 n1_M2_99420_127500 n1_M2_100500_127500 0.988200
R16141 n1_M2_100500_127500 n1_M2_101580_127500 0.988200
R16142 n1_M2_101580_127500 n1_M2_102660_127500 0.988200
R16143 n1_M2_102660_127500 n1_M2_103740_127500 0.988200
R16144 n1_M2_103740_127500 n1_M2_104820_127500 0.988200
R16145 n1_M2_104820_127500 n1_M2_105900_127500 0.988200
R16146 n1_M2_105900_127500 n1_M2_106980_127500 0.988200
R16147 n1_M2_106980_127500 n1_M2_108060_127500 0.988200
R16148 n1_M2_108060_127500 n1_M2_109140_127500 0.988200
R16149 n1_M2_109140_127500 n1_M2_110220_127500 0.988200
R16150 n1_M2_110220_127500 n1_M2_111300_127500 0.988200
R16151 n1_M2_111300_127500 n1_M2_112380_127500 0.988200
R16152 n1_M2_112380_127500 n1_M2_113460_127500 0.988200
R16153 n1_M2_113460_127500 n1_M2_114540_127500 0.988200
R16154 n1_M2_114540_127500 n1_M2_115620_127500 0.988200
R16155 n1_M2_115620_127500 n1_M2_116700_127500 0.988200
R16156 n1_M2_116700_127500 n1_M2_117780_127500 0.988200
R16157 n1_M2_117780_127500 n1_M2_118860_127500 0.988200
R16158 n1_M2_118860_127500 n1_M2_119940_127500 0.988200
R16159 n1_M2_119940_127500 n1_M2_121020_127500 0.988200
R16160 n1_M2_121020_127500 n1_M2_122100_127500 0.988200
R16161 n1_M2_122100_127500 n1_M2_123180_127500 0.988200
R16162 n1_M2_123180_127500 n1_M2_124260_127500 0.988200
R16163 n1_M2_124260_127500 n1_M2_125340_127500 0.988200
R16164 n1_M2_125340_127500 n1_M2_126420_127500 0.988200
R16165 n1_M2_126420_127500 n1_M2_127500_127500 0.988200
R16166 n1_M2_127500_127500 n1_M2_128580_127500 0.988200
R16167 n1_M2_128580_127500 n1_M2_129660_127500 0.988200
R16168 n1_M2_129660_127500 n1_M2_130740_127500 0.988200
R16169 n1_M2_130740_127500 n1_M2_131820_127500 0.988200
R16170 n1_M2_131820_127500 n1_M2_132900_127500 0.988200
R16171 n1_M2_132900_127500 n1_M2_133980_127500 0.988200
R16172 n1_M2_133980_127500 n1_M2_135060_127500 0.988200
R16173 n1_M2_135060_127500 n1_M2_136140_127500 0.988200
R16174 n1_M2_136140_127500 n1_M2_137220_127500 0.988200
R16175 n1_M2_137220_127500 n1_M2_138300_127500 0.988200
R16176 n1_M2_138300_127500 n1_M2_139380_127500 0.988200
R16177 n1_M2_139380_127500 n1_M2_140460_127500 0.988200
R16178 n1_M2_140460_127500 n1_M2_141540_127500 0.988200
R16179 n1_M2_141540_127500 n1_M2_142620_127500 0.988200
R16180 n1_M2_142620_127500 n1_M2_143700_127500 0.988200
R16181 n1_M2_143700_127500 n1_M2_144780_127500 0.988200
R16182 n1_M2_144780_127500 n1_M2_145860_127500 0.988200
R16183 n1_M2_145860_127500 n1_M2_146940_127500 0.988200
R16184 n1_M2_60_128580 n1_M2_1140_128580 0.988200
R16185 n1_M2_1140_128580 n1_M2_2220_128580 0.988200
R16186 n1_M2_2220_128580 n1_M2_3300_128580 0.988200
R16187 n1_M2_3300_128580 n1_M2_4380_128580 0.988200
R16188 n1_M2_4380_128580 n1_M2_5460_128580 0.988200
R16189 n1_M2_5460_128580 n1_M2_6540_128580 0.988200
R16190 n1_M2_6540_128580 n1_M2_7620_128580 0.988200
R16191 n1_M2_7620_128580 n1_M2_8700_128580 0.988200
R16192 n1_M2_8700_128580 n1_M2_9780_128580 0.988200
R16193 n1_M2_9780_128580 n1_M2_10860_128580 0.988200
R16194 n1_M2_10860_128580 n1_M2_11940_128580 0.988200
R16195 n1_M2_11940_128580 n1_M2_13020_128580 0.988200
R16196 n1_M2_13020_128580 n1_M2_14100_128580 0.988200
R16197 n1_M2_14100_128580 n1_M2_15180_128580 0.988200
R16198 n1_M2_15180_128580 n1_M2_16260_128580 0.988200
R16199 n1_M2_16260_128580 n1_M2_17340_128580 0.988200
R16200 n1_M2_17340_128580 n1_M2_18420_128580 0.988200
R16201 n1_M2_18420_128580 n1_M2_19500_128580 0.988200
R16202 n1_M2_19500_128580 n1_M2_20580_128580 0.988200
R16203 n1_M2_20580_128580 n1_M2_21660_128580 0.988200
R16204 n1_M2_21660_128580 n1_M2_22740_128580 0.988200
R16205 n1_M2_22740_128580 n1_M2_23820_128580 0.988200
R16206 n1_M2_23820_128580 n1_M2_24900_128580 0.988200
R16207 n1_M2_24900_128580 n1_M2_25980_128580 0.988200
R16208 n1_M2_25980_128580 n1_M2_27060_128580 0.988200
R16209 n1_M2_27060_128580 n1_M2_28140_128580 0.988200
R16210 n1_M2_28140_128580 n1_M2_29220_128580 0.988200
R16211 n1_M2_29220_128580 n1_M2_30300_128580 0.988200
R16212 n1_M2_30300_128580 n1_M2_31380_128580 0.988200
R16213 n1_M2_31380_128580 n1_M2_32460_128580 0.988200
R16214 n1_M2_32460_128580 n1_M2_33540_128580 0.988200
R16215 n1_M2_33540_128580 n1_M2_34620_128580 0.988200
R16216 n1_M2_34620_128580 n1_M2_35700_128580 0.988200
R16217 n1_M2_35700_128580 n1_M2_36780_128580 0.988200
R16218 n1_M2_36780_128580 n1_M2_37860_128580 0.988200
R16219 n1_M2_37860_128580 n1_M2_38940_128580 0.988200
R16220 n1_M2_38940_128580 n1_M2_40020_128580 0.988200
R16221 n1_M2_40020_128580 n1_M2_41100_128580 0.988200
R16222 n1_M2_41100_128580 n1_M2_42180_128580 0.988200
R16223 n1_M2_42180_128580 n1_M2_43260_128580 0.988200
R16224 n1_M2_43260_128580 n1_M2_44340_128580 0.988200
R16225 n1_M2_44340_128580 n1_M2_45420_128580 0.988200
R16226 n1_M2_45420_128580 n1_M2_46500_128580 0.988200
R16227 n1_M2_46500_128580 n1_M2_47580_128580 0.988200
R16228 n1_M2_47580_128580 n1_M2_48660_128580 0.988200
R16229 n1_M2_48660_128580 n1_M2_49740_128580 0.988200
R16230 n1_M2_49740_128580 n1_M2_50820_128580 0.988200
R16231 n1_M2_50820_128580 n1_M2_51900_128580 0.988200
R16232 n1_M2_51900_128580 n1_M2_52980_128580 0.988200
R16233 n1_M2_52980_128580 n1_M2_54060_128580 0.988200
R16234 n1_M2_54060_128580 n1_M2_55140_128580 0.988200
R16235 n1_M2_55140_128580 n1_M2_56220_128580 0.988200
R16236 n1_M2_56220_128580 n1_M2_57300_128580 0.988200
R16237 n1_M2_57300_128580 n1_M2_58380_128580 0.988200
R16238 n1_M2_58380_128580 n1_M2_59460_128580 0.988200
R16239 n1_M2_59460_128580 n1_M2_60540_128580 0.988200
R16240 n1_M2_60540_128580 n1_M2_61620_128580 0.988200
R16241 n1_M2_61620_128580 n1_M2_62700_128580 0.988200
R16242 n1_M2_62700_128580 n1_M2_63780_128580 0.988200
R16243 n1_M2_63780_128580 n1_M2_64860_128580 0.988200
R16244 n1_M2_64860_128580 n1_M2_65940_128580 0.988200
R16245 n1_M2_65940_128580 n1_M2_67020_128580 0.988200
R16246 n1_M2_67020_128580 n1_M2_68100_128580 0.988200
R16247 n1_M2_68100_128580 n1_M2_69180_128580 0.988200
R16248 n1_M2_69180_128580 n1_M2_70260_128580 0.988200
R16249 n1_M2_70260_128580 n1_M2_71340_128580 0.988200
R16250 n1_M2_71340_128580 n1_M2_72420_128580 0.988200
R16251 n1_M2_72420_128580 n1_M2_73500_128580 0.988200
R16252 n1_M2_73500_128580 n1_M2_74580_128580 0.988200
R16253 n1_M2_74580_128580 n1_M2_75660_128580 0.988200
R16254 n1_M2_75660_128580 n1_M2_76740_128580 0.988200
R16255 n1_M2_76740_128580 n1_M2_77820_128580 0.988200
R16256 n1_M2_77820_128580 n1_M2_78900_128580 0.988200
R16257 n1_M2_78900_128580 n1_M2_79980_128580 0.988200
R16258 n1_M2_79980_128580 n1_M2_81060_128580 0.988200
R16259 n1_M2_81060_128580 n1_M2_82140_128580 0.988200
R16260 n1_M2_82140_128580 n1_M2_83220_128580 0.988200
R16261 n1_M2_83220_128580 n1_M2_84300_128580 0.988200
R16262 n1_M2_84300_128580 n1_M2_85380_128580 0.988200
R16263 n1_M2_85380_128580 n1_M2_86460_128580 0.988200
R16264 n1_M2_86460_128580 n1_M2_87540_128580 0.988200
R16265 n1_M2_87540_128580 n1_M2_88620_128580 0.988200
R16266 n1_M2_88620_128580 n1_M2_89700_128580 0.988200
R16267 n1_M2_89700_128580 n1_M2_90780_128580 0.988200
R16268 n1_M2_90780_128580 n1_M2_91860_128580 0.988200
R16269 n1_M2_91860_128580 n1_M2_92940_128580 0.988200
R16270 n1_M2_92940_128580 n1_M2_94020_128580 0.988200
R16271 n1_M2_94020_128580 n1_M2_95100_128580 0.988200
R16272 n1_M2_95100_128580 n1_M2_96180_128580 0.988200
R16273 n1_M2_96180_128580 n1_M2_97260_128580 0.988200
R16274 n1_M2_97260_128580 n1_M2_98340_128580 0.988200
R16275 n1_M2_98340_128580 n1_M2_99420_128580 0.988200
R16276 n1_M2_99420_128580 n1_M2_100500_128580 0.988200
R16277 n1_M2_100500_128580 n1_M2_101580_128580 0.988200
R16278 n1_M2_101580_128580 n1_M2_102660_128580 0.988200
R16279 n1_M2_102660_128580 n1_M2_103740_128580 0.988200
R16280 n1_M2_103740_128580 n1_M2_104820_128580 0.988200
R16281 n1_M2_104820_128580 n1_M2_105900_128580 0.988200
R16282 n1_M2_105900_128580 n1_M2_106980_128580 0.988200
R16283 n1_M2_106980_128580 n1_M2_108060_128580 0.988200
R16284 n1_M2_108060_128580 n1_M2_109140_128580 0.988200
R16285 n1_M2_109140_128580 n1_M2_110220_128580 0.988200
R16286 n1_M2_110220_128580 n1_M2_111300_128580 0.988200
R16287 n1_M2_111300_128580 n1_M2_112380_128580 0.988200
R16288 n1_M2_112380_128580 n1_M2_113460_128580 0.988200
R16289 n1_M2_113460_128580 n1_M2_114540_128580 0.988200
R16290 n1_M2_114540_128580 n1_M2_115620_128580 0.988200
R16291 n1_M2_115620_128580 n1_M2_116700_128580 0.988200
R16292 n1_M2_116700_128580 n1_M2_117780_128580 0.988200
R16293 n1_M2_117780_128580 n1_M2_118860_128580 0.988200
R16294 n1_M2_118860_128580 n1_M2_119940_128580 0.988200
R16295 n1_M2_119940_128580 n1_M2_121020_128580 0.988200
R16296 n1_M2_121020_128580 n1_M2_122100_128580 0.988200
R16297 n1_M2_122100_128580 n1_M2_123180_128580 0.988200
R16298 n1_M2_123180_128580 n1_M2_124260_128580 0.988200
R16299 n1_M2_124260_128580 n1_M2_125340_128580 0.988200
R16300 n1_M2_125340_128580 n1_M2_126420_128580 0.988200
R16301 n1_M2_126420_128580 n1_M2_127500_128580 0.988200
R16302 n1_M2_127500_128580 n1_M2_128580_128580 0.988200
R16303 n1_M2_128580_128580 n1_M2_129660_128580 0.988200
R16304 n1_M2_129660_128580 n1_M2_130740_128580 0.988200
R16305 n1_M2_130740_128580 n1_M2_131820_128580 0.988200
R16306 n1_M2_131820_128580 n1_M2_132900_128580 0.988200
R16307 n1_M2_132900_128580 n1_M2_133980_128580 0.988200
R16308 n1_M2_133980_128580 n1_M2_135060_128580 0.988200
R16309 n1_M2_135060_128580 n1_M2_136140_128580 0.988200
R16310 n1_M2_136140_128580 n1_M2_137220_128580 0.988200
R16311 n1_M2_137220_128580 n1_M2_138300_128580 0.988200
R16312 n1_M2_138300_128580 n1_M2_139380_128580 0.988200
R16313 n1_M2_139380_128580 n1_M2_140460_128580 0.988200
R16314 n1_M2_140460_128580 n1_M2_141540_128580 0.988200
R16315 n1_M2_141540_128580 n1_M2_142620_128580 0.988200
R16316 n1_M2_142620_128580 n1_M2_143700_128580 0.988200
R16317 n1_M2_143700_128580 n1_M2_144780_128580 0.988200
R16318 n1_M2_144780_128580 n1_M2_145860_128580 0.988200
R16319 n1_M2_145860_128580 n1_M2_146940_128580 0.988200
R16320 n1_M2_60_129660 n1_M2_1140_129660 0.988200
R16321 n1_M2_1140_129660 n1_M2_2220_129660 0.988200
R16322 n1_M2_2220_129660 n1_M2_3300_129660 0.988200
R16323 n1_M2_3300_129660 n1_M2_4380_129660 0.988200
R16324 n1_M2_4380_129660 n1_M2_5460_129660 0.988200
R16325 n1_M2_5460_129660 n1_M2_6540_129660 0.988200
R16326 n1_M2_6540_129660 n1_M2_7620_129660 0.988200
R16327 n1_M2_7620_129660 n1_M2_8700_129660 0.988200
R16328 n1_M2_8700_129660 n1_M2_9780_129660 0.988200
R16329 n1_M2_9780_129660 n1_M2_10860_129660 0.988200
R16330 n1_M2_10860_129660 n1_M2_11940_129660 0.988200
R16331 n1_M2_11940_129660 n1_M2_13020_129660 0.988200
R16332 n1_M2_13020_129660 n1_M2_14100_129660 0.988200
R16333 n1_M2_14100_129660 n1_M2_15180_129660 0.988200
R16334 n1_M2_15180_129660 n1_M2_16260_129660 0.988200
R16335 n1_M2_16260_129660 n1_M2_17340_129660 0.988200
R16336 n1_M2_17340_129660 n1_M2_18420_129660 0.988200
R16337 n1_M2_18420_129660 n1_M2_19500_129660 0.988200
R16338 n1_M2_19500_129660 n1_M2_20580_129660 0.988200
R16339 n1_M2_20580_129660 n1_M2_21660_129660 0.988200
R16340 n1_M2_21660_129660 n1_M2_22740_129660 0.988200
R16341 n1_M2_22740_129660 n1_M2_23820_129660 0.988200
R16342 n1_M2_23820_129660 n1_M2_24900_129660 0.988200
R16343 n1_M2_24900_129660 n1_M2_25980_129660 0.988200
R16344 n1_M2_25980_129660 n1_M2_27060_129660 0.988200
R16345 n1_M2_27060_129660 n1_M2_28140_129660 0.988200
R16346 n1_M2_28140_129660 n1_M2_29220_129660 0.988200
R16347 n1_M2_29220_129660 n1_M2_30300_129660 0.988200
R16348 n1_M2_30300_129660 n1_M2_31380_129660 0.988200
R16349 n1_M2_31380_129660 n1_M2_32460_129660 0.988200
R16350 n1_M2_32460_129660 n1_M2_33540_129660 0.988200
R16351 n1_M2_33540_129660 n1_M2_34620_129660 0.988200
R16352 n1_M2_34620_129660 n1_M2_35700_129660 0.988200
R16353 n1_M2_35700_129660 n1_M2_36780_129660 0.988200
R16354 n1_M2_36780_129660 n1_M2_37860_129660 0.988200
R16355 n1_M2_37860_129660 n1_M2_38940_129660 0.988200
R16356 n1_M2_38940_129660 n1_M2_40020_129660 0.988200
R16357 n1_M2_40020_129660 n1_M2_41100_129660 0.988200
R16358 n1_M2_41100_129660 n1_M2_42180_129660 0.988200
R16359 n1_M2_42180_129660 n1_M2_43260_129660 0.988200
R16360 n1_M2_43260_129660 n1_M2_44340_129660 0.988200
R16361 n1_M2_44340_129660 n1_M2_45420_129660 0.988200
R16362 n1_M2_45420_129660 n1_M2_46500_129660 0.988200
R16363 n1_M2_46500_129660 n1_M2_47580_129660 0.988200
R16364 n1_M2_47580_129660 n1_M2_48660_129660 0.988200
R16365 n1_M2_48660_129660 n1_M2_49740_129660 0.988200
R16366 n1_M2_49740_129660 n1_M2_50820_129660 0.988200
R16367 n1_M2_50820_129660 n1_M2_51900_129660 0.988200
R16368 n1_M2_51900_129660 n1_M2_52980_129660 0.988200
R16369 n1_M2_52980_129660 n1_M2_54060_129660 0.988200
R16370 n1_M2_54060_129660 n1_M2_55140_129660 0.988200
R16371 n1_M2_55140_129660 n1_M2_56220_129660 0.988200
R16372 n1_M2_56220_129660 n1_M2_57300_129660 0.988200
R16373 n1_M2_57300_129660 n1_M2_58380_129660 0.988200
R16374 n1_M2_58380_129660 n1_M2_59460_129660 0.988200
R16375 n1_M2_59460_129660 n1_M2_60540_129660 0.988200
R16376 n1_M2_60540_129660 n1_M2_61620_129660 0.988200
R16377 n1_M2_61620_129660 n1_M2_62700_129660 0.988200
R16378 n1_M2_62700_129660 n1_M2_63780_129660 0.988200
R16379 n1_M2_63780_129660 n1_M2_64860_129660 0.988200
R16380 n1_M2_64860_129660 n1_M2_65940_129660 0.988200
R16381 n1_M2_65940_129660 n1_M2_67020_129660 0.988200
R16382 n1_M2_67020_129660 n1_M2_68100_129660 0.988200
R16383 n1_M2_68100_129660 n1_M2_69180_129660 0.988200
R16384 n1_M2_69180_129660 n1_M2_70260_129660 0.988200
R16385 n1_M2_70260_129660 n1_M2_71340_129660 0.988200
R16386 n1_M2_71340_129660 n1_M2_72420_129660 0.988200
R16387 n1_M2_72420_129660 n1_M2_73500_129660 0.988200
R16388 n1_M2_73500_129660 n1_M2_74580_129660 0.988200
R16389 n1_M2_74580_129660 n1_M2_75660_129660 0.988200
R16390 n1_M2_75660_129660 n1_M2_76740_129660 0.988200
R16391 n1_M2_76740_129660 n1_M2_77820_129660 0.988200
R16392 n1_M2_77820_129660 n1_M2_78900_129660 0.988200
R16393 n1_M2_78900_129660 n1_M2_79980_129660 0.988200
R16394 n1_M2_79980_129660 n1_M2_81060_129660 0.988200
R16395 n1_M2_81060_129660 n1_M2_82140_129660 0.988200
R16396 n1_M2_82140_129660 n1_M2_83220_129660 0.988200
R16397 n1_M2_83220_129660 n1_M2_84300_129660 0.988200
R16398 n1_M2_84300_129660 n1_M2_85380_129660 0.988200
R16399 n1_M2_85380_129660 n1_M2_86460_129660 0.988200
R16400 n1_M2_86460_129660 n1_M2_87540_129660 0.988200
R16401 n1_M2_87540_129660 n1_M2_88620_129660 0.988200
R16402 n1_M2_88620_129660 n1_M2_89700_129660 0.988200
R16403 n1_M2_89700_129660 n1_M2_90780_129660 0.988200
R16404 n1_M2_90780_129660 n1_M2_91860_129660 0.988200
R16405 n1_M2_91860_129660 n1_M2_92940_129660 0.988200
R16406 n1_M2_92940_129660 n1_M2_94020_129660 0.988200
R16407 n1_M2_94020_129660 n1_M2_95100_129660 0.988200
R16408 n1_M2_95100_129660 n1_M2_96180_129660 0.988200
R16409 n1_M2_96180_129660 n1_M2_97260_129660 0.988200
R16410 n1_M2_97260_129660 n1_M2_98340_129660 0.988200
R16411 n1_M2_98340_129660 n1_M2_99420_129660 0.988200
R16412 n1_M2_99420_129660 n1_M2_100500_129660 0.988200
R16413 n1_M2_100500_129660 n1_M2_101580_129660 0.988200
R16414 n1_M2_101580_129660 n1_M2_102660_129660 0.988200
R16415 n1_M2_102660_129660 n1_M2_103740_129660 0.988200
R16416 n1_M2_103740_129660 n1_M2_104820_129660 0.988200
R16417 n1_M2_104820_129660 n1_M2_105900_129660 0.988200
R16418 n1_M2_105900_129660 n1_M2_106980_129660 0.988200
R16419 n1_M2_106980_129660 n1_M2_108060_129660 0.988200
R16420 n1_M2_108060_129660 n1_M2_109140_129660 0.988200
R16421 n1_M2_109140_129660 n1_M2_110220_129660 0.988200
R16422 n1_M2_110220_129660 n1_M2_111300_129660 0.988200
R16423 n1_M2_111300_129660 n1_M2_112380_129660 0.988200
R16424 n1_M2_112380_129660 n1_M2_113460_129660 0.988200
R16425 n1_M2_113460_129660 n1_M2_114540_129660 0.988200
R16426 n1_M2_114540_129660 n1_M2_115620_129660 0.988200
R16427 n1_M2_115620_129660 n1_M2_116700_129660 0.988200
R16428 n1_M2_116700_129660 n1_M2_117780_129660 0.988200
R16429 n1_M2_117780_129660 n1_M2_118860_129660 0.988200
R16430 n1_M2_118860_129660 n1_M2_119940_129660 0.988200
R16431 n1_M2_119940_129660 n1_M2_121020_129660 0.988200
R16432 n1_M2_121020_129660 n1_M2_122100_129660 0.988200
R16433 n1_M2_122100_129660 n1_M2_123180_129660 0.988200
R16434 n1_M2_123180_129660 n1_M2_124260_129660 0.988200
R16435 n1_M2_124260_129660 n1_M2_125340_129660 0.988200
R16436 n1_M2_125340_129660 n1_M2_126420_129660 0.988200
R16437 n1_M2_126420_129660 n1_M2_127500_129660 0.988200
R16438 n1_M2_127500_129660 n1_M2_128580_129660 0.988200
R16439 n1_M2_128580_129660 n1_M2_129660_129660 0.988200
R16440 n1_M2_129660_129660 n1_M2_130740_129660 0.988200
R16441 n1_M2_130740_129660 n1_M2_131820_129660 0.988200
R16442 n1_M2_131820_129660 n1_M2_132900_129660 0.988200
R16443 n1_M2_132900_129660 n1_M2_133980_129660 0.988200
R16444 n1_M2_133980_129660 n1_M2_135060_129660 0.988200
R16445 n1_M2_135060_129660 n1_M2_136140_129660 0.988200
R16446 n1_M2_136140_129660 n1_M2_137220_129660 0.988200
R16447 n1_M2_137220_129660 n1_M2_138300_129660 0.988200
R16448 n1_M2_138300_129660 n1_M2_139380_129660 0.988200
R16449 n1_M2_139380_129660 n1_M2_140460_129660 0.988200
R16450 n1_M2_140460_129660 n1_M2_141540_129660 0.988200
R16451 n1_M2_141540_129660 n1_M2_142620_129660 0.988200
R16452 n1_M2_142620_129660 n1_M2_143700_129660 0.988200
R16453 n1_M2_143700_129660 n1_M2_144780_129660 0.988200
R16454 n1_M2_144780_129660 n1_M2_145860_129660 0.988200
R16455 n1_M2_145860_129660 n1_M2_146940_129660 0.988200
R16456 n1_M2_60_130740 n1_M2_1140_130740 0.988200
R16457 n1_M2_1140_130740 n1_M2_2220_130740 0.988200
R16458 n1_M2_2220_130740 n1_M2_3300_130740 0.988200
R16459 n1_M2_3300_130740 n1_M2_4380_130740 0.988200
R16460 n1_M2_4380_130740 n1_M2_5460_130740 0.988200
R16461 n1_M2_5460_130740 n1_M2_6540_130740 0.988200
R16462 n1_M2_6540_130740 n1_M2_7620_130740 0.988200
R16463 n1_M2_7620_130740 n1_M2_8700_130740 0.988200
R16464 n1_M2_8700_130740 n1_M2_9780_130740 0.988200
R16465 n1_M2_9780_130740 n1_M2_10860_130740 0.988200
R16466 n1_M2_10860_130740 n1_M2_11940_130740 0.988200
R16467 n1_M2_11940_130740 n1_M2_13020_130740 0.988200
R16468 n1_M2_13020_130740 n1_M2_14100_130740 0.988200
R16469 n1_M2_14100_130740 n1_M2_15180_130740 0.988200
R16470 n1_M2_15180_130740 n1_M2_16260_130740 0.988200
R16471 n1_M2_16260_130740 n1_M2_17340_130740 0.988200
R16472 n1_M2_17340_130740 n1_M2_18420_130740 0.988200
R16473 n1_M2_18420_130740 n1_M2_19500_130740 0.988200
R16474 n1_M2_19500_130740 n1_M2_20580_130740 0.988200
R16475 n1_M2_20580_130740 n1_M2_21660_130740 0.988200
R16476 n1_M2_21660_130740 n1_M2_22740_130740 0.988200
R16477 n1_M2_22740_130740 n1_M2_23820_130740 0.988200
R16478 n1_M2_23820_130740 n1_M2_24900_130740 0.988200
R16479 n1_M2_24900_130740 n1_M2_25980_130740 0.988200
R16480 n1_M2_25980_130740 n1_M2_27060_130740 0.988200
R16481 n1_M2_27060_130740 n1_M2_28140_130740 0.988200
R16482 n1_M2_28140_130740 n1_M2_29220_130740 0.988200
R16483 n1_M2_29220_130740 n1_M2_30300_130740 0.988200
R16484 n1_M2_30300_130740 n1_M2_31380_130740 0.988200
R16485 n1_M2_31380_130740 n1_M2_32460_130740 0.988200
R16486 n1_M2_32460_130740 n1_M2_33540_130740 0.988200
R16487 n1_M2_33540_130740 n1_M2_34620_130740 0.988200
R16488 n1_M2_34620_130740 n1_M2_35700_130740 0.988200
R16489 n1_M2_35700_130740 n1_M2_36780_130740 0.988200
R16490 n1_M2_36780_130740 n1_M2_37860_130740 0.988200
R16491 n1_M2_37860_130740 n1_M2_38940_130740 0.988200
R16492 n1_M2_38940_130740 n1_M2_40020_130740 0.988200
R16493 n1_M2_40020_130740 n1_M2_41100_130740 0.988200
R16494 n1_M2_41100_130740 n1_M2_42180_130740 0.988200
R16495 n1_M2_42180_130740 n1_M2_43260_130740 0.988200
R16496 n1_M2_43260_130740 n1_M2_44340_130740 0.988200
R16497 n1_M2_44340_130740 n1_M2_45420_130740 0.988200
R16498 n1_M2_45420_130740 n1_M2_46500_130740 0.988200
R16499 n1_M2_46500_130740 n1_M2_47580_130740 0.988200
R16500 n1_M2_47580_130740 n1_M2_48660_130740 0.988200
R16501 n1_M2_48660_130740 n1_M2_49740_130740 0.988200
R16502 n1_M2_49740_130740 n1_M2_50820_130740 0.988200
R16503 n1_M2_50820_130740 n1_M2_51900_130740 0.988200
R16504 n1_M2_51900_130740 n1_M2_52980_130740 0.988200
R16505 n1_M2_52980_130740 n1_M2_54060_130740 0.988200
R16506 n1_M2_54060_130740 n1_M2_55140_130740 0.988200
R16507 n1_M2_55140_130740 n1_M2_56220_130740 0.988200
R16508 n1_M2_56220_130740 n1_M2_57300_130740 0.988200
R16509 n1_M2_57300_130740 n1_M2_58380_130740 0.988200
R16510 n1_M2_58380_130740 n1_M2_59460_130740 0.988200
R16511 n1_M2_59460_130740 n1_M2_60540_130740 0.988200
R16512 n1_M2_60540_130740 n1_M2_61620_130740 0.988200
R16513 n1_M2_61620_130740 n1_M2_62700_130740 0.988200
R16514 n1_M2_62700_130740 n1_M2_63780_130740 0.988200
R16515 n1_M2_63780_130740 n1_M2_64860_130740 0.988200
R16516 n1_M2_64860_130740 n1_M2_65940_130740 0.988200
R16517 n1_M2_65940_130740 n1_M2_67020_130740 0.988200
R16518 n1_M2_67020_130740 n1_M2_68100_130740 0.988200
R16519 n1_M2_68100_130740 n1_M2_69180_130740 0.988200
R16520 n1_M2_69180_130740 n1_M2_70260_130740 0.988200
R16521 n1_M2_70260_130740 n1_M2_71340_130740 0.988200
R16522 n1_M2_71340_130740 n1_M2_72420_130740 0.988200
R16523 n1_M2_72420_130740 n1_M2_73500_130740 0.988200
R16524 n1_M2_73500_130740 n1_M2_74580_130740 0.988200
R16525 n1_M2_74580_130740 n1_M2_75660_130740 0.988200
R16526 n1_M2_75660_130740 n1_M2_76740_130740 0.988200
R16527 n1_M2_76740_130740 n1_M2_77820_130740 0.988200
R16528 n1_M2_77820_130740 n1_M2_78900_130740 0.988200
R16529 n1_M2_78900_130740 n1_M2_79980_130740 0.988200
R16530 n1_M2_79980_130740 n1_M2_81060_130740 0.988200
R16531 n1_M2_81060_130740 n1_M2_82140_130740 0.988200
R16532 n1_M2_82140_130740 n1_M2_83220_130740 0.988200
R16533 n1_M2_83220_130740 n1_M2_84300_130740 0.988200
R16534 n1_M2_84300_130740 n1_M2_85380_130740 0.988200
R16535 n1_M2_85380_130740 n1_M2_86460_130740 0.988200
R16536 n1_M2_86460_130740 n1_M2_87540_130740 0.988200
R16537 n1_M2_87540_130740 n1_M2_88620_130740 0.988200
R16538 n1_M2_88620_130740 n1_M2_89700_130740 0.988200
R16539 n1_M2_89700_130740 n1_M2_90780_130740 0.988200
R16540 n1_M2_90780_130740 n1_M2_91860_130740 0.988200
R16541 n1_M2_91860_130740 n1_M2_92940_130740 0.988200
R16542 n1_M2_92940_130740 n1_M2_94020_130740 0.988200
R16543 n1_M2_94020_130740 n1_M2_95100_130740 0.988200
R16544 n1_M2_95100_130740 n1_M2_96180_130740 0.988200
R16545 n1_M2_96180_130740 n1_M2_97260_130740 0.988200
R16546 n1_M2_97260_130740 n1_M2_98340_130740 0.988200
R16547 n1_M2_98340_130740 n1_M2_99420_130740 0.988200
R16548 n1_M2_99420_130740 n1_M2_100500_130740 0.988200
R16549 n1_M2_100500_130740 n1_M2_101580_130740 0.988200
R16550 n1_M2_101580_130740 n1_M2_102660_130740 0.988200
R16551 n1_M2_102660_130740 n1_M2_103740_130740 0.988200
R16552 n1_M2_103740_130740 n1_M2_104820_130740 0.988200
R16553 n1_M2_104820_130740 n1_M2_105900_130740 0.988200
R16554 n1_M2_105900_130740 n1_M2_106980_130740 0.988200
R16555 n1_M2_106980_130740 n1_M2_108060_130740 0.988200
R16556 n1_M2_108060_130740 n1_M2_109140_130740 0.988200
R16557 n1_M2_109140_130740 n1_M2_110220_130740 0.988200
R16558 n1_M2_110220_130740 n1_M2_111300_130740 0.988200
R16559 n1_M2_111300_130740 n1_M2_112380_130740 0.988200
R16560 n1_M2_112380_130740 n1_M2_113460_130740 0.988200
R16561 n1_M2_113460_130740 n1_M2_114540_130740 0.988200
R16562 n1_M2_114540_130740 n1_M2_115620_130740 0.988200
R16563 n1_M2_115620_130740 n1_M2_116700_130740 0.988200
R16564 n1_M2_116700_130740 n1_M2_117780_130740 0.988200
R16565 n1_M2_117780_130740 n1_M2_118860_130740 0.988200
R16566 n1_M2_118860_130740 n1_M2_119940_130740 0.988200
R16567 n1_M2_119940_130740 n1_M2_121020_130740 0.988200
R16568 n1_M2_121020_130740 n1_M2_122100_130740 0.988200
R16569 n1_M2_122100_130740 n1_M2_123180_130740 0.988200
R16570 n1_M2_123180_130740 n1_M2_124260_130740 0.988200
R16571 n1_M2_124260_130740 n1_M2_125340_130740 0.988200
R16572 n1_M2_125340_130740 n1_M2_126420_130740 0.988200
R16573 n1_M2_126420_130740 n1_M2_127500_130740 0.988200
R16574 n1_M2_127500_130740 n1_M2_128580_130740 0.988200
R16575 n1_M2_128580_130740 n1_M2_129660_130740 0.988200
R16576 n1_M2_129660_130740 n1_M2_130740_130740 0.988200
R16577 n1_M2_130740_130740 n1_M2_131820_130740 0.988200
R16578 n1_M2_131820_130740 n1_M2_132900_130740 0.988200
R16579 n1_M2_132900_130740 n1_M2_133980_130740 0.988200
R16580 n1_M2_133980_130740 n1_M2_135060_130740 0.988200
R16581 n1_M2_135060_130740 n1_M2_136140_130740 0.988200
R16582 n1_M2_136140_130740 n1_M2_137220_130740 0.988200
R16583 n1_M2_137220_130740 n1_M2_138300_130740 0.988200
R16584 n1_M2_138300_130740 n1_M2_139380_130740 0.988200
R16585 n1_M2_139380_130740 n1_M2_140460_130740 0.988200
R16586 n1_M2_140460_130740 n1_M2_141540_130740 0.988200
R16587 n1_M2_141540_130740 n1_M2_142620_130740 0.988200
R16588 n1_M2_142620_130740 n1_M2_143700_130740 0.988200
R16589 n1_M2_143700_130740 n1_M2_144780_130740 0.988200
R16590 n1_M2_144780_130740 n1_M2_145860_130740 0.988200
R16591 n1_M2_145860_130740 n1_M2_146940_130740 0.988200
R16592 n1_M2_60_131820 n1_M2_1140_131820 0.988200
R16593 n1_M2_1140_131820 n1_M2_2220_131820 0.988200
R16594 n1_M2_2220_131820 n1_M2_3300_131820 0.988200
R16595 n1_M2_3300_131820 n1_M2_4380_131820 0.988200
R16596 n1_M2_4380_131820 n1_M2_5460_131820 0.988200
R16597 n1_M2_5460_131820 n1_M2_6540_131820 0.988200
R16598 n1_M2_6540_131820 n1_M2_7620_131820 0.988200
R16599 n1_M2_7620_131820 n1_M2_8700_131820 0.988200
R16600 n1_M2_8700_131820 n1_M2_9780_131820 0.988200
R16601 n1_M2_9780_131820 n1_M2_10860_131820 0.988200
R16602 n1_M2_10860_131820 n1_M2_11940_131820 0.988200
R16603 n1_M2_11940_131820 n1_M2_13020_131820 0.988200
R16604 n1_M2_13020_131820 n1_M2_14100_131820 0.988200
R16605 n1_M2_14100_131820 n1_M2_15180_131820 0.988200
R16606 n1_M2_15180_131820 n1_M2_16260_131820 0.988200
R16607 n1_M2_16260_131820 n1_M2_17340_131820 0.988200
R16608 n1_M2_17340_131820 n1_M2_18420_131820 0.988200
R16609 n1_M2_18420_131820 n1_M2_19500_131820 0.988200
R16610 n1_M2_19500_131820 n1_M2_20580_131820 0.988200
R16611 n1_M2_20580_131820 n1_M2_21660_131820 0.988200
R16612 n1_M2_21660_131820 n1_M2_22740_131820 0.988200
R16613 n1_M2_22740_131820 n1_M2_23820_131820 0.988200
R16614 n1_M2_23820_131820 n1_M2_24900_131820 0.988200
R16615 n1_M2_24900_131820 n1_M2_25980_131820 0.988200
R16616 n1_M2_25980_131820 n1_M2_27060_131820 0.988200
R16617 n1_M2_27060_131820 n1_M2_28140_131820 0.988200
R16618 n1_M2_28140_131820 n1_M2_29220_131820 0.988200
R16619 n1_M2_29220_131820 n1_M2_30300_131820 0.988200
R16620 n1_M2_30300_131820 n1_M2_31380_131820 0.988200
R16621 n1_M2_31380_131820 n1_M2_32460_131820 0.988200
R16622 n1_M2_32460_131820 n1_M2_33540_131820 0.988200
R16623 n1_M2_33540_131820 n1_M2_34620_131820 0.988200
R16624 n1_M2_34620_131820 n1_M2_35700_131820 0.988200
R16625 n1_M2_35700_131820 n1_M2_36780_131820 0.988200
R16626 n1_M2_36780_131820 n1_M2_37860_131820 0.988200
R16627 n1_M2_37860_131820 n1_M2_38940_131820 0.988200
R16628 n1_M2_38940_131820 n1_M2_40020_131820 0.988200
R16629 n1_M2_40020_131820 n1_M2_41100_131820 0.988200
R16630 n1_M2_41100_131820 n1_M2_42180_131820 0.988200
R16631 n1_M2_42180_131820 n1_M2_43260_131820 0.988200
R16632 n1_M2_43260_131820 n1_M2_44340_131820 0.988200
R16633 n1_M2_44340_131820 n1_M2_45420_131820 0.988200
R16634 n1_M2_45420_131820 n1_M2_46500_131820 0.988200
R16635 n1_M2_46500_131820 n1_M2_47580_131820 0.988200
R16636 n1_M2_47580_131820 n1_M2_48660_131820 0.988200
R16637 n1_M2_48660_131820 n1_M2_49740_131820 0.988200
R16638 n1_M2_49740_131820 n1_M2_50820_131820 0.988200
R16639 n1_M2_50820_131820 n1_M2_51900_131820 0.988200
R16640 n1_M2_51900_131820 n1_M2_52980_131820 0.988200
R16641 n1_M2_52980_131820 n1_M2_54060_131820 0.988200
R16642 n1_M2_54060_131820 n1_M2_55140_131820 0.988200
R16643 n1_M2_55140_131820 n1_M2_56220_131820 0.988200
R16644 n1_M2_56220_131820 n1_M2_57300_131820 0.988200
R16645 n1_M2_57300_131820 n1_M2_58380_131820 0.988200
R16646 n1_M2_58380_131820 n1_M2_59460_131820 0.988200
R16647 n1_M2_59460_131820 n1_M2_60540_131820 0.988200
R16648 n1_M2_60540_131820 n1_M2_61620_131820 0.988200
R16649 n1_M2_61620_131820 n1_M2_62700_131820 0.988200
R16650 n1_M2_62700_131820 n1_M2_63780_131820 0.988200
R16651 n1_M2_63780_131820 n1_M2_64860_131820 0.988200
R16652 n1_M2_64860_131820 n1_M2_65940_131820 0.988200
R16653 n1_M2_65940_131820 n1_M2_67020_131820 0.988200
R16654 n1_M2_67020_131820 n1_M2_68100_131820 0.988200
R16655 n1_M2_68100_131820 n1_M2_69180_131820 0.988200
R16656 n1_M2_69180_131820 n1_M2_70260_131820 0.988200
R16657 n1_M2_70260_131820 n1_M2_71340_131820 0.988200
R16658 n1_M2_71340_131820 n1_M2_72420_131820 0.988200
R16659 n1_M2_72420_131820 n1_M2_73500_131820 0.988200
R16660 n1_M2_73500_131820 n1_M2_74580_131820 0.988200
R16661 n1_M2_74580_131820 n1_M2_75660_131820 0.988200
R16662 n1_M2_75660_131820 n1_M2_76740_131820 0.988200
R16663 n1_M2_76740_131820 n1_M2_77820_131820 0.988200
R16664 n1_M2_77820_131820 n1_M2_78900_131820 0.988200
R16665 n1_M2_78900_131820 n1_M2_79980_131820 0.988200
R16666 n1_M2_79980_131820 n1_M2_81060_131820 0.988200
R16667 n1_M2_81060_131820 n1_M2_82140_131820 0.988200
R16668 n1_M2_82140_131820 n1_M2_83220_131820 0.988200
R16669 n1_M2_83220_131820 n1_M2_84300_131820 0.988200
R16670 n1_M2_84300_131820 n1_M2_85380_131820 0.988200
R16671 n1_M2_85380_131820 n1_M2_86460_131820 0.988200
R16672 n1_M2_86460_131820 n1_M2_87540_131820 0.988200
R16673 n1_M2_87540_131820 n1_M2_88620_131820 0.988200
R16674 n1_M2_88620_131820 n1_M2_89700_131820 0.988200
R16675 n1_M2_89700_131820 n1_M2_90780_131820 0.988200
R16676 n1_M2_90780_131820 n1_M2_91860_131820 0.988200
R16677 n1_M2_91860_131820 n1_M2_92940_131820 0.988200
R16678 n1_M2_92940_131820 n1_M2_94020_131820 0.988200
R16679 n1_M2_94020_131820 n1_M2_95100_131820 0.988200
R16680 n1_M2_95100_131820 n1_M2_96180_131820 0.988200
R16681 n1_M2_96180_131820 n1_M2_97260_131820 0.988200
R16682 n1_M2_97260_131820 n1_M2_98340_131820 0.988200
R16683 n1_M2_98340_131820 n1_M2_99420_131820 0.988200
R16684 n1_M2_99420_131820 n1_M2_100500_131820 0.988200
R16685 n1_M2_100500_131820 n1_M2_101580_131820 0.988200
R16686 n1_M2_101580_131820 n1_M2_102660_131820 0.988200
R16687 n1_M2_102660_131820 n1_M2_103740_131820 0.988200
R16688 n1_M2_103740_131820 n1_M2_104820_131820 0.988200
R16689 n1_M2_104820_131820 n1_M2_105900_131820 0.988200
R16690 n1_M2_105900_131820 n1_M2_106980_131820 0.988200
R16691 n1_M2_106980_131820 n1_M2_108060_131820 0.988200
R16692 n1_M2_108060_131820 n1_M2_109140_131820 0.988200
R16693 n1_M2_109140_131820 n1_M2_110220_131820 0.988200
R16694 n1_M2_110220_131820 n1_M2_111300_131820 0.988200
R16695 n1_M2_111300_131820 n1_M2_112380_131820 0.988200
R16696 n1_M2_112380_131820 n1_M2_113460_131820 0.988200
R16697 n1_M2_113460_131820 n1_M2_114540_131820 0.988200
R16698 n1_M2_114540_131820 n1_M2_115620_131820 0.988200
R16699 n1_M2_115620_131820 n1_M2_116700_131820 0.988200
R16700 n1_M2_116700_131820 n1_M2_117780_131820 0.988200
R16701 n1_M2_117780_131820 n1_M2_118860_131820 0.988200
R16702 n1_M2_118860_131820 n1_M2_119940_131820 0.988200
R16703 n1_M2_119940_131820 n1_M2_121020_131820 0.988200
R16704 n1_M2_121020_131820 n1_M2_122100_131820 0.988200
R16705 n1_M2_122100_131820 n1_M2_123180_131820 0.988200
R16706 n1_M2_123180_131820 n1_M2_124260_131820 0.988200
R16707 n1_M2_124260_131820 n1_M2_125340_131820 0.988200
R16708 n1_M2_125340_131820 n1_M2_126420_131820 0.988200
R16709 n1_M2_126420_131820 n1_M2_127500_131820 0.988200
R16710 n1_M2_127500_131820 n1_M2_128580_131820 0.988200
R16711 n1_M2_128580_131820 n1_M2_129660_131820 0.988200
R16712 n1_M2_129660_131820 n1_M2_130740_131820 0.988200
R16713 n1_M2_130740_131820 n1_M2_131820_131820 0.988200
R16714 n1_M2_131820_131820 n1_M2_132900_131820 0.988200
R16715 n1_M2_132900_131820 n1_M2_133980_131820 0.988200
R16716 n1_M2_133980_131820 n1_M2_135060_131820 0.988200
R16717 n1_M2_135060_131820 n1_M2_136140_131820 0.988200
R16718 n1_M2_136140_131820 n1_M2_137220_131820 0.988200
R16719 n1_M2_137220_131820 n1_M2_138300_131820 0.988200
R16720 n1_M2_138300_131820 n1_M2_139380_131820 0.988200
R16721 n1_M2_139380_131820 n1_M2_140460_131820 0.988200
R16722 n1_M2_140460_131820 n1_M2_141540_131820 0.988200
R16723 n1_M2_141540_131820 n1_M2_142620_131820 0.988200
R16724 n1_M2_142620_131820 n1_M2_143700_131820 0.988200
R16725 n1_M2_143700_131820 n1_M2_144780_131820 0.988200
R16726 n1_M2_144780_131820 n1_M2_145860_131820 0.988200
R16727 n1_M2_145860_131820 n1_M2_146940_131820 0.988200
R16728 n1_M2_60_132900 n1_M2_1140_132900 0.988200
R16729 n1_M2_1140_132900 n1_M2_2220_132900 0.988200
R16730 n1_M2_2220_132900 n1_M2_3300_132900 0.988200
R16731 n1_M2_3300_132900 n1_M2_4380_132900 0.988200
R16732 n1_M2_4380_132900 n1_M2_5460_132900 0.988200
R16733 n1_M2_5460_132900 n1_M2_6540_132900 0.988200
R16734 n1_M2_6540_132900 n1_M2_7620_132900 0.988200
R16735 n1_M2_7620_132900 n1_M2_8700_132900 0.988200
R16736 n1_M2_8700_132900 n1_M2_9780_132900 0.988200
R16737 n1_M2_9780_132900 n1_M2_10860_132900 0.988200
R16738 n1_M2_10860_132900 n1_M2_11940_132900 0.988200
R16739 n1_M2_11940_132900 n1_M2_13020_132900 0.988200
R16740 n1_M2_13020_132900 n1_M2_14100_132900 0.988200
R16741 n1_M2_14100_132900 n1_M2_15180_132900 0.988200
R16742 n1_M2_15180_132900 n1_M2_16260_132900 0.988200
R16743 n1_M2_16260_132900 n1_M2_17340_132900 0.988200
R16744 n1_M2_17340_132900 n1_M2_18420_132900 0.988200
R16745 n1_M2_18420_132900 n1_M2_19500_132900 0.988200
R16746 n1_M2_19500_132900 n1_M2_20580_132900 0.988200
R16747 n1_M2_20580_132900 n1_M2_21660_132900 0.988200
R16748 n1_M2_21660_132900 n1_M2_22740_132900 0.988200
R16749 n1_M2_22740_132900 n1_M2_23820_132900 0.988200
R16750 n1_M2_23820_132900 n1_M2_24900_132900 0.988200
R16751 n1_M2_24900_132900 n1_M2_25980_132900 0.988200
R16752 n1_M2_25980_132900 n1_M2_27060_132900 0.988200
R16753 n1_M2_27060_132900 n1_M2_28140_132900 0.988200
R16754 n1_M2_28140_132900 n1_M2_29220_132900 0.988200
R16755 n1_M2_29220_132900 n1_M2_30300_132900 0.988200
R16756 n1_M2_30300_132900 n1_M2_31380_132900 0.988200
R16757 n1_M2_31380_132900 n1_M2_32460_132900 0.988200
R16758 n1_M2_32460_132900 n1_M2_33540_132900 0.988200
R16759 n1_M2_33540_132900 n1_M2_34620_132900 0.988200
R16760 n1_M2_34620_132900 n1_M2_35700_132900 0.988200
R16761 n1_M2_35700_132900 n1_M2_36780_132900 0.988200
R16762 n1_M2_36780_132900 n1_M2_37860_132900 0.988200
R16763 n1_M2_37860_132900 n1_M2_38940_132900 0.988200
R16764 n1_M2_38940_132900 n1_M2_40020_132900 0.988200
R16765 n1_M2_40020_132900 n1_M2_41100_132900 0.988200
R16766 n1_M2_41100_132900 n1_M2_42180_132900 0.988200
R16767 n1_M2_42180_132900 n1_M2_43260_132900 0.988200
R16768 n1_M2_43260_132900 n1_M2_44340_132900 0.988200
R16769 n1_M2_44340_132900 n1_M2_45420_132900 0.988200
R16770 n1_M2_45420_132900 n1_M2_46500_132900 0.988200
R16771 n1_M2_46500_132900 n1_M2_47580_132900 0.988200
R16772 n1_M2_47580_132900 n1_M2_48660_132900 0.988200
R16773 n1_M2_48660_132900 n1_M2_49740_132900 0.988200
R16774 n1_M2_49740_132900 n1_M2_50820_132900 0.988200
R16775 n1_M2_50820_132900 n1_M2_51900_132900 0.988200
R16776 n1_M2_51900_132900 n1_M2_52980_132900 0.988200
R16777 n1_M2_52980_132900 n1_M2_54060_132900 0.988200
R16778 n1_M2_54060_132900 n1_M2_55140_132900 0.988200
R16779 n1_M2_55140_132900 n1_M2_56220_132900 0.988200
R16780 n1_M2_56220_132900 n1_M2_57300_132900 0.988200
R16781 n1_M2_57300_132900 n1_M2_58380_132900 0.988200
R16782 n1_M2_58380_132900 n1_M2_59460_132900 0.988200
R16783 n1_M2_59460_132900 n1_M2_60540_132900 0.988200
R16784 n1_M2_60540_132900 n1_M2_61620_132900 0.988200
R16785 n1_M2_61620_132900 n1_M2_62700_132900 0.988200
R16786 n1_M2_62700_132900 n1_M2_63780_132900 0.988200
R16787 n1_M2_63780_132900 n1_M2_64860_132900 0.988200
R16788 n1_M2_64860_132900 n1_M2_65940_132900 0.988200
R16789 n1_M2_65940_132900 n1_M2_67020_132900 0.988200
R16790 n1_M2_67020_132900 n1_M2_68100_132900 0.988200
R16791 n1_M2_68100_132900 n1_M2_69180_132900 0.988200
R16792 n1_M2_69180_132900 n1_M2_70260_132900 0.988200
R16793 n1_M2_70260_132900 n1_M2_71340_132900 0.988200
R16794 n1_M2_71340_132900 n1_M2_72420_132900 0.988200
R16795 n1_M2_72420_132900 n1_M2_73500_132900 0.988200
R16796 n1_M2_73500_132900 n1_M2_74580_132900 0.988200
R16797 n1_M2_74580_132900 n1_M2_75660_132900 0.988200
R16798 n1_M2_75660_132900 n1_M2_76740_132900 0.988200
R16799 n1_M2_76740_132900 n1_M2_77820_132900 0.988200
R16800 n1_M2_77820_132900 n1_M2_78900_132900 0.988200
R16801 n1_M2_78900_132900 n1_M2_79980_132900 0.988200
R16802 n1_M2_79980_132900 n1_M2_81060_132900 0.988200
R16803 n1_M2_81060_132900 n1_M2_82140_132900 0.988200
R16804 n1_M2_82140_132900 n1_M2_83220_132900 0.988200
R16805 n1_M2_83220_132900 n1_M2_84300_132900 0.988200
R16806 n1_M2_84300_132900 n1_M2_85380_132900 0.988200
R16807 n1_M2_85380_132900 n1_M2_86460_132900 0.988200
R16808 n1_M2_86460_132900 n1_M2_87540_132900 0.988200
R16809 n1_M2_87540_132900 n1_M2_88620_132900 0.988200
R16810 n1_M2_88620_132900 n1_M2_89700_132900 0.988200
R16811 n1_M2_89700_132900 n1_M2_90780_132900 0.988200
R16812 n1_M2_90780_132900 n1_M2_91860_132900 0.988200
R16813 n1_M2_91860_132900 n1_M2_92940_132900 0.988200
R16814 n1_M2_92940_132900 n1_M2_94020_132900 0.988200
R16815 n1_M2_94020_132900 n1_M2_95100_132900 0.988200
R16816 n1_M2_95100_132900 n1_M2_96180_132900 0.988200
R16817 n1_M2_96180_132900 n1_M2_97260_132900 0.988200
R16818 n1_M2_97260_132900 n1_M2_98340_132900 0.988200
R16819 n1_M2_98340_132900 n1_M2_99420_132900 0.988200
R16820 n1_M2_99420_132900 n1_M2_100500_132900 0.988200
R16821 n1_M2_100500_132900 n1_M2_101580_132900 0.988200
R16822 n1_M2_101580_132900 n1_M2_102660_132900 0.988200
R16823 n1_M2_102660_132900 n1_M2_103740_132900 0.988200
R16824 n1_M2_103740_132900 n1_M2_104820_132900 0.988200
R16825 n1_M2_104820_132900 n1_M2_105900_132900 0.988200
R16826 n1_M2_105900_132900 n1_M2_106980_132900 0.988200
R16827 n1_M2_106980_132900 n1_M2_108060_132900 0.988200
R16828 n1_M2_108060_132900 n1_M2_109140_132900 0.988200
R16829 n1_M2_109140_132900 n1_M2_110220_132900 0.988200
R16830 n1_M2_110220_132900 n1_M2_111300_132900 0.988200
R16831 n1_M2_111300_132900 n1_M2_112380_132900 0.988200
R16832 n1_M2_112380_132900 n1_M2_113460_132900 0.988200
R16833 n1_M2_113460_132900 n1_M2_114540_132900 0.988200
R16834 n1_M2_114540_132900 n1_M2_115620_132900 0.988200
R16835 n1_M2_115620_132900 n1_M2_116700_132900 0.988200
R16836 n1_M2_116700_132900 n1_M2_117780_132900 0.988200
R16837 n1_M2_117780_132900 n1_M2_118860_132900 0.988200
R16838 n1_M2_118860_132900 n1_M2_119940_132900 0.988200
R16839 n1_M2_119940_132900 n1_M2_121020_132900 0.988200
R16840 n1_M2_121020_132900 n1_M2_122100_132900 0.988200
R16841 n1_M2_122100_132900 n1_M2_123180_132900 0.988200
R16842 n1_M2_123180_132900 n1_M2_124260_132900 0.988200
R16843 n1_M2_124260_132900 n1_M2_125340_132900 0.988200
R16844 n1_M2_125340_132900 n1_M2_126420_132900 0.988200
R16845 n1_M2_126420_132900 n1_M2_127500_132900 0.988200
R16846 n1_M2_127500_132900 n1_M2_128580_132900 0.988200
R16847 n1_M2_128580_132900 n1_M2_129660_132900 0.988200
R16848 n1_M2_129660_132900 n1_M2_130740_132900 0.988200
R16849 n1_M2_130740_132900 n1_M2_131820_132900 0.988200
R16850 n1_M2_131820_132900 n1_M2_132900_132900 0.988200
R16851 n1_M2_132900_132900 n1_M2_133980_132900 0.988200
R16852 n1_M2_133980_132900 n1_M2_135060_132900 0.988200
R16853 n1_M2_135060_132900 n1_M2_136140_132900 0.988200
R16854 n1_M2_136140_132900 n1_M2_137220_132900 0.988200
R16855 n1_M2_137220_132900 n1_M2_138300_132900 0.988200
R16856 n1_M2_138300_132900 n1_M2_139380_132900 0.988200
R16857 n1_M2_139380_132900 n1_M2_140460_132900 0.988200
R16858 n1_M2_140460_132900 n1_M2_141540_132900 0.988200
R16859 n1_M2_141540_132900 n1_M2_142620_132900 0.988200
R16860 n1_M2_142620_132900 n1_M2_143700_132900 0.988200
R16861 n1_M2_143700_132900 n1_M2_144780_132900 0.988200
R16862 n1_M2_144780_132900 n1_M2_145860_132900 0.988200
R16863 n1_M2_145860_132900 n1_M2_146940_132900 0.988200
R16864 n1_M2_60_133980 n1_M2_1140_133980 0.988200
R16865 n1_M2_1140_133980 n1_M2_2220_133980 0.988200
R16866 n1_M2_2220_133980 n1_M2_3300_133980 0.988200
R16867 n1_M2_3300_133980 n1_M2_4380_133980 0.988200
R16868 n1_M2_4380_133980 n1_M2_5460_133980 0.988200
R16869 n1_M2_5460_133980 n1_M2_6540_133980 0.988200
R16870 n1_M2_6540_133980 n1_M2_7620_133980 0.988200
R16871 n1_M2_7620_133980 n1_M2_8700_133980 0.988200
R16872 n1_M2_8700_133980 n1_M2_9780_133980 0.988200
R16873 n1_M2_9780_133980 n1_M2_10860_133980 0.988200
R16874 n1_M2_10860_133980 n1_M2_11940_133980 0.988200
R16875 n1_M2_11940_133980 n1_M2_13020_133980 0.988200
R16876 n1_M2_13020_133980 n1_M2_14100_133980 0.988200
R16877 n1_M2_14100_133980 n1_M2_15180_133980 0.988200
R16878 n1_M2_15180_133980 n1_M2_16260_133980 0.988200
R16879 n1_M2_16260_133980 n1_M2_17340_133980 0.988200
R16880 n1_M2_17340_133980 n1_M2_18420_133980 0.988200
R16881 n1_M2_18420_133980 n1_M2_19500_133980 0.988200
R16882 n1_M2_19500_133980 n1_M2_20580_133980 0.988200
R16883 n1_M2_20580_133980 n1_M2_21660_133980 0.988200
R16884 n1_M2_21660_133980 n1_M2_22740_133980 0.988200
R16885 n1_M2_22740_133980 n1_M2_23820_133980 0.988200
R16886 n1_M2_23820_133980 n1_M2_24900_133980 0.988200
R16887 n1_M2_24900_133980 n1_M2_25980_133980 0.988200
R16888 n1_M2_25980_133980 n1_M2_27060_133980 0.988200
R16889 n1_M2_27060_133980 n1_M2_28140_133980 0.988200
R16890 n1_M2_28140_133980 n1_M2_29220_133980 0.988200
R16891 n1_M2_29220_133980 n1_M2_30300_133980 0.988200
R16892 n1_M2_30300_133980 n1_M2_31380_133980 0.988200
R16893 n1_M2_31380_133980 n1_M2_32460_133980 0.988200
R16894 n1_M2_32460_133980 n1_M2_33540_133980 0.988200
R16895 n1_M2_33540_133980 n1_M2_34620_133980 0.988200
R16896 n1_M2_34620_133980 n1_M2_35700_133980 0.988200
R16897 n1_M2_35700_133980 n1_M2_36780_133980 0.988200
R16898 n1_M2_36780_133980 n1_M2_37860_133980 0.988200
R16899 n1_M2_37860_133980 n1_M2_38940_133980 0.988200
R16900 n1_M2_38940_133980 n1_M2_40020_133980 0.988200
R16901 n1_M2_40020_133980 n1_M2_41100_133980 0.988200
R16902 n1_M2_41100_133980 n1_M2_42180_133980 0.988200
R16903 n1_M2_42180_133980 n1_M2_43260_133980 0.988200
R16904 n1_M2_43260_133980 n1_M2_44340_133980 0.988200
R16905 n1_M2_44340_133980 n1_M2_45420_133980 0.988200
R16906 n1_M2_45420_133980 n1_M2_46500_133980 0.988200
R16907 n1_M2_46500_133980 n1_M2_47580_133980 0.988200
R16908 n1_M2_47580_133980 n1_M2_48660_133980 0.988200
R16909 n1_M2_48660_133980 n1_M2_49740_133980 0.988200
R16910 n1_M2_49740_133980 n1_M2_50820_133980 0.988200
R16911 n1_M2_50820_133980 n1_M2_51900_133980 0.988200
R16912 n1_M2_51900_133980 n1_M2_52980_133980 0.988200
R16913 n1_M2_52980_133980 n1_M2_54060_133980 0.988200
R16914 n1_M2_54060_133980 n1_M2_55140_133980 0.988200
R16915 n1_M2_55140_133980 n1_M2_56220_133980 0.988200
R16916 n1_M2_56220_133980 n1_M2_57300_133980 0.988200
R16917 n1_M2_57300_133980 n1_M2_58380_133980 0.988200
R16918 n1_M2_58380_133980 n1_M2_59460_133980 0.988200
R16919 n1_M2_59460_133980 n1_M2_60540_133980 0.988200
R16920 n1_M2_60540_133980 n1_M2_61620_133980 0.988200
R16921 n1_M2_61620_133980 n1_M2_62700_133980 0.988200
R16922 n1_M2_62700_133980 n1_M2_63780_133980 0.988200
R16923 n1_M2_63780_133980 n1_M2_64860_133980 0.988200
R16924 n1_M2_64860_133980 n1_M2_65940_133980 0.988200
R16925 n1_M2_65940_133980 n1_M2_67020_133980 0.988200
R16926 n1_M2_67020_133980 n1_M2_68100_133980 0.988200
R16927 n1_M2_68100_133980 n1_M2_69180_133980 0.988200
R16928 n1_M2_69180_133980 n1_M2_70260_133980 0.988200
R16929 n1_M2_70260_133980 n1_M2_71340_133980 0.988200
R16930 n1_M2_71340_133980 n1_M2_72420_133980 0.988200
R16931 n1_M2_72420_133980 n1_M2_73500_133980 0.988200
R16932 n1_M2_73500_133980 n1_M2_74580_133980 0.988200
R16933 n1_M2_74580_133980 n1_M2_75660_133980 0.988200
R16934 n1_M2_75660_133980 n1_M2_76740_133980 0.988200
R16935 n1_M2_76740_133980 n1_M2_77820_133980 0.988200
R16936 n1_M2_77820_133980 n1_M2_78900_133980 0.988200
R16937 n1_M2_78900_133980 n1_M2_79980_133980 0.988200
R16938 n1_M2_79980_133980 n1_M2_81060_133980 0.988200
R16939 n1_M2_81060_133980 n1_M2_82140_133980 0.988200
R16940 n1_M2_82140_133980 n1_M2_83220_133980 0.988200
R16941 n1_M2_83220_133980 n1_M2_84300_133980 0.988200
R16942 n1_M2_84300_133980 n1_M2_85380_133980 0.988200
R16943 n1_M2_85380_133980 n1_M2_86460_133980 0.988200
R16944 n1_M2_86460_133980 n1_M2_87540_133980 0.988200
R16945 n1_M2_87540_133980 n1_M2_88620_133980 0.988200
R16946 n1_M2_88620_133980 n1_M2_89700_133980 0.988200
R16947 n1_M2_89700_133980 n1_M2_90780_133980 0.988200
R16948 n1_M2_90780_133980 n1_M2_91860_133980 0.988200
R16949 n1_M2_91860_133980 n1_M2_92940_133980 0.988200
R16950 n1_M2_92940_133980 n1_M2_94020_133980 0.988200
R16951 n1_M2_94020_133980 n1_M2_95100_133980 0.988200
R16952 n1_M2_95100_133980 n1_M2_96180_133980 0.988200
R16953 n1_M2_96180_133980 n1_M2_97260_133980 0.988200
R16954 n1_M2_97260_133980 n1_M2_98340_133980 0.988200
R16955 n1_M2_98340_133980 n1_M2_99420_133980 0.988200
R16956 n1_M2_99420_133980 n1_M2_100500_133980 0.988200
R16957 n1_M2_100500_133980 n1_M2_101580_133980 0.988200
R16958 n1_M2_101580_133980 n1_M2_102660_133980 0.988200
R16959 n1_M2_102660_133980 n1_M2_103740_133980 0.988200
R16960 n1_M2_103740_133980 n1_M2_104820_133980 0.988200
R16961 n1_M2_104820_133980 n1_M2_105900_133980 0.988200
R16962 n1_M2_105900_133980 n1_M2_106980_133980 0.988200
R16963 n1_M2_106980_133980 n1_M2_108060_133980 0.988200
R16964 n1_M2_108060_133980 n1_M2_109140_133980 0.988200
R16965 n1_M2_109140_133980 n1_M2_110220_133980 0.988200
R16966 n1_M2_110220_133980 n1_M2_111300_133980 0.988200
R16967 n1_M2_111300_133980 n1_M2_112380_133980 0.988200
R16968 n1_M2_112380_133980 n1_M2_113460_133980 0.988200
R16969 n1_M2_113460_133980 n1_M2_114540_133980 0.988200
R16970 n1_M2_114540_133980 n1_M2_115620_133980 0.988200
R16971 n1_M2_115620_133980 n1_M2_116700_133980 0.988200
R16972 n1_M2_116700_133980 n1_M2_117780_133980 0.988200
R16973 n1_M2_117780_133980 n1_M2_118860_133980 0.988200
R16974 n1_M2_118860_133980 n1_M2_119940_133980 0.988200
R16975 n1_M2_119940_133980 n1_M2_121020_133980 0.988200
R16976 n1_M2_121020_133980 n1_M2_122100_133980 0.988200
R16977 n1_M2_122100_133980 n1_M2_123180_133980 0.988200
R16978 n1_M2_123180_133980 n1_M2_124260_133980 0.988200
R16979 n1_M2_124260_133980 n1_M2_125340_133980 0.988200
R16980 n1_M2_125340_133980 n1_M2_126420_133980 0.988200
R16981 n1_M2_126420_133980 n1_M2_127500_133980 0.988200
R16982 n1_M2_127500_133980 n1_M2_128580_133980 0.988200
R16983 n1_M2_128580_133980 n1_M2_129660_133980 0.988200
R16984 n1_M2_129660_133980 n1_M2_130740_133980 0.988200
R16985 n1_M2_130740_133980 n1_M2_131820_133980 0.988200
R16986 n1_M2_131820_133980 n1_M2_132900_133980 0.988200
R16987 n1_M2_132900_133980 n1_M2_133980_133980 0.988200
R16988 n1_M2_133980_133980 n1_M2_135060_133980 0.988200
R16989 n1_M2_135060_133980 n1_M2_136140_133980 0.988200
R16990 n1_M2_136140_133980 n1_M2_137220_133980 0.988200
R16991 n1_M2_137220_133980 n1_M2_138300_133980 0.988200
R16992 n1_M2_138300_133980 n1_M2_139380_133980 0.988200
R16993 n1_M2_139380_133980 n1_M2_140460_133980 0.988200
R16994 n1_M2_140460_133980 n1_M2_141540_133980 0.988200
R16995 n1_M2_141540_133980 n1_M2_142620_133980 0.988200
R16996 n1_M2_142620_133980 n1_M2_143700_133980 0.988200
R16997 n1_M2_143700_133980 n1_M2_144780_133980 0.988200
R16998 n1_M2_144780_133980 n1_M2_145860_133980 0.988200
R16999 n1_M2_145860_133980 n1_M2_146940_133980 0.988200
R17000 n1_M2_60_135060 n1_M2_1140_135060 0.988200
R17001 n1_M2_1140_135060 n1_M2_2220_135060 0.988200
R17002 n1_M2_2220_135060 n1_M2_3300_135060 0.988200
R17003 n1_M2_3300_135060 n1_M2_4380_135060 0.988200
R17004 n1_M2_4380_135060 n1_M2_5460_135060 0.988200
R17005 n1_M2_5460_135060 n1_M2_6540_135060 0.988200
R17006 n1_M2_6540_135060 n1_M2_7620_135060 0.988200
R17007 n1_M2_7620_135060 n1_M2_8700_135060 0.988200
R17008 n1_M2_8700_135060 n1_M2_9780_135060 0.988200
R17009 n1_M2_9780_135060 n1_M2_10860_135060 0.988200
R17010 n1_M2_10860_135060 n1_M2_11940_135060 0.988200
R17011 n1_M2_11940_135060 n1_M2_13020_135060 0.988200
R17012 n1_M2_13020_135060 n1_M2_14100_135060 0.988200
R17013 n1_M2_14100_135060 n1_M2_15180_135060 0.988200
R17014 n1_M2_15180_135060 n1_M2_16260_135060 0.988200
R17015 n1_M2_16260_135060 n1_M2_17340_135060 0.988200
R17016 n1_M2_17340_135060 n1_M2_18420_135060 0.988200
R17017 n1_M2_18420_135060 n1_M2_19500_135060 0.988200
R17018 n1_M2_19500_135060 n1_M2_20580_135060 0.988200
R17019 n1_M2_20580_135060 n1_M2_21660_135060 0.988200
R17020 n1_M2_21660_135060 n1_M2_22740_135060 0.988200
R17021 n1_M2_22740_135060 n1_M2_23820_135060 0.988200
R17022 n1_M2_23820_135060 n1_M2_24900_135060 0.988200
R17023 n1_M2_24900_135060 n1_M2_25980_135060 0.988200
R17024 n1_M2_25980_135060 n1_M2_27060_135060 0.988200
R17025 n1_M2_27060_135060 n1_M2_28140_135060 0.988200
R17026 n1_M2_28140_135060 n1_M2_29220_135060 0.988200
R17027 n1_M2_29220_135060 n1_M2_30300_135060 0.988200
R17028 n1_M2_30300_135060 n1_M2_31380_135060 0.988200
R17029 n1_M2_31380_135060 n1_M2_32460_135060 0.988200
R17030 n1_M2_32460_135060 n1_M2_33540_135060 0.988200
R17031 n1_M2_33540_135060 n1_M2_34620_135060 0.988200
R17032 n1_M2_34620_135060 n1_M2_35700_135060 0.988200
R17033 n1_M2_35700_135060 n1_M2_36780_135060 0.988200
R17034 n1_M2_36780_135060 n1_M2_37860_135060 0.988200
R17035 n1_M2_37860_135060 n1_M2_38940_135060 0.988200
R17036 n1_M2_38940_135060 n1_M2_40020_135060 0.988200
R17037 n1_M2_40020_135060 n1_M2_41100_135060 0.988200
R17038 n1_M2_41100_135060 n1_M2_42180_135060 0.988200
R17039 n1_M2_42180_135060 n1_M2_43260_135060 0.988200
R17040 n1_M2_43260_135060 n1_M2_44340_135060 0.988200
R17041 n1_M2_44340_135060 n1_M2_45420_135060 0.988200
R17042 n1_M2_45420_135060 n1_M2_46500_135060 0.988200
R17043 n1_M2_46500_135060 n1_M2_47580_135060 0.988200
R17044 n1_M2_47580_135060 n1_M2_48660_135060 0.988200
R17045 n1_M2_48660_135060 n1_M2_49740_135060 0.988200
R17046 n1_M2_49740_135060 n1_M2_50820_135060 0.988200
R17047 n1_M2_50820_135060 n1_M2_51900_135060 0.988200
R17048 n1_M2_51900_135060 n1_M2_52980_135060 0.988200
R17049 n1_M2_52980_135060 n1_M2_54060_135060 0.988200
R17050 n1_M2_54060_135060 n1_M2_55140_135060 0.988200
R17051 n1_M2_55140_135060 n1_M2_56220_135060 0.988200
R17052 n1_M2_56220_135060 n1_M2_57300_135060 0.988200
R17053 n1_M2_57300_135060 n1_M2_58380_135060 0.988200
R17054 n1_M2_58380_135060 n1_M2_59460_135060 0.988200
R17055 n1_M2_59460_135060 n1_M2_60540_135060 0.988200
R17056 n1_M2_60540_135060 n1_M2_61620_135060 0.988200
R17057 n1_M2_61620_135060 n1_M2_62700_135060 0.988200
R17058 n1_M2_62700_135060 n1_M2_63780_135060 0.988200
R17059 n1_M2_63780_135060 n1_M2_64860_135060 0.988200
R17060 n1_M2_64860_135060 n1_M2_65940_135060 0.988200
R17061 n1_M2_65940_135060 n1_M2_67020_135060 0.988200
R17062 n1_M2_67020_135060 n1_M2_68100_135060 0.988200
R17063 n1_M2_68100_135060 n1_M2_69180_135060 0.988200
R17064 n1_M2_69180_135060 n1_M2_70260_135060 0.988200
R17065 n1_M2_70260_135060 n1_M2_71340_135060 0.988200
R17066 n1_M2_71340_135060 n1_M2_72420_135060 0.988200
R17067 n1_M2_72420_135060 n1_M2_73500_135060 0.988200
R17068 n1_M2_73500_135060 n1_M2_74580_135060 0.988200
R17069 n1_M2_74580_135060 n1_M2_75660_135060 0.988200
R17070 n1_M2_75660_135060 n1_M2_76740_135060 0.988200
R17071 n1_M2_76740_135060 n1_M2_77820_135060 0.988200
R17072 n1_M2_77820_135060 n1_M2_78900_135060 0.988200
R17073 n1_M2_78900_135060 n1_M2_79980_135060 0.988200
R17074 n1_M2_79980_135060 n1_M2_81060_135060 0.988200
R17075 n1_M2_81060_135060 n1_M2_82140_135060 0.988200
R17076 n1_M2_82140_135060 n1_M2_83220_135060 0.988200
R17077 n1_M2_83220_135060 n1_M2_84300_135060 0.988200
R17078 n1_M2_84300_135060 n1_M2_85380_135060 0.988200
R17079 n1_M2_85380_135060 n1_M2_86460_135060 0.988200
R17080 n1_M2_86460_135060 n1_M2_87540_135060 0.988200
R17081 n1_M2_87540_135060 n1_M2_88620_135060 0.988200
R17082 n1_M2_88620_135060 n1_M2_89700_135060 0.988200
R17083 n1_M2_89700_135060 n1_M2_90780_135060 0.988200
R17084 n1_M2_90780_135060 n1_M2_91860_135060 0.988200
R17085 n1_M2_91860_135060 n1_M2_92940_135060 0.988200
R17086 n1_M2_92940_135060 n1_M2_94020_135060 0.988200
R17087 n1_M2_94020_135060 n1_M2_95100_135060 0.988200
R17088 n1_M2_95100_135060 n1_M2_96180_135060 0.988200
R17089 n1_M2_96180_135060 n1_M2_97260_135060 0.988200
R17090 n1_M2_97260_135060 n1_M2_98340_135060 0.988200
R17091 n1_M2_98340_135060 n1_M2_99420_135060 0.988200
R17092 n1_M2_99420_135060 n1_M2_100500_135060 0.988200
R17093 n1_M2_100500_135060 n1_M2_101580_135060 0.988200
R17094 n1_M2_101580_135060 n1_M2_102660_135060 0.988200
R17095 n1_M2_102660_135060 n1_M2_103740_135060 0.988200
R17096 n1_M2_103740_135060 n1_M2_104820_135060 0.988200
R17097 n1_M2_104820_135060 n1_M2_105900_135060 0.988200
R17098 n1_M2_105900_135060 n1_M2_106980_135060 0.988200
R17099 n1_M2_106980_135060 n1_M2_108060_135060 0.988200
R17100 n1_M2_108060_135060 n1_M2_109140_135060 0.988200
R17101 n1_M2_109140_135060 n1_M2_110220_135060 0.988200
R17102 n1_M2_110220_135060 n1_M2_111300_135060 0.988200
R17103 n1_M2_111300_135060 n1_M2_112380_135060 0.988200
R17104 n1_M2_112380_135060 n1_M2_113460_135060 0.988200
R17105 n1_M2_113460_135060 n1_M2_114540_135060 0.988200
R17106 n1_M2_114540_135060 n1_M2_115620_135060 0.988200
R17107 n1_M2_115620_135060 n1_M2_116700_135060 0.988200
R17108 n1_M2_116700_135060 n1_M2_117780_135060 0.988200
R17109 n1_M2_117780_135060 n1_M2_118860_135060 0.988200
R17110 n1_M2_118860_135060 n1_M2_119940_135060 0.988200
R17111 n1_M2_119940_135060 n1_M2_121020_135060 0.988200
R17112 n1_M2_121020_135060 n1_M2_122100_135060 0.988200
R17113 n1_M2_122100_135060 n1_M2_123180_135060 0.988200
R17114 n1_M2_123180_135060 n1_M2_124260_135060 0.988200
R17115 n1_M2_124260_135060 n1_M2_125340_135060 0.988200
R17116 n1_M2_125340_135060 n1_M2_126420_135060 0.988200
R17117 n1_M2_126420_135060 n1_M2_127500_135060 0.988200
R17118 n1_M2_127500_135060 n1_M2_128580_135060 0.988200
R17119 n1_M2_128580_135060 n1_M2_129660_135060 0.988200
R17120 n1_M2_129660_135060 n1_M2_130740_135060 0.988200
R17121 n1_M2_130740_135060 n1_M2_131820_135060 0.988200
R17122 n1_M2_131820_135060 n1_M2_132900_135060 0.988200
R17123 n1_M2_132900_135060 n1_M2_133980_135060 0.988200
R17124 n1_M2_133980_135060 n1_M2_135060_135060 0.988200
R17125 n1_M2_135060_135060 n1_M2_136140_135060 0.988200
R17126 n1_M2_136140_135060 n1_M2_137220_135060 0.988200
R17127 n1_M2_137220_135060 n1_M2_138300_135060 0.988200
R17128 n1_M2_138300_135060 n1_M2_139380_135060 0.988200
R17129 n1_M2_139380_135060 n1_M2_140460_135060 0.988200
R17130 n1_M2_140460_135060 n1_M2_141540_135060 0.988200
R17131 n1_M2_141540_135060 n1_M2_142620_135060 0.988200
R17132 n1_M2_142620_135060 n1_M2_143700_135060 0.988200
R17133 n1_M2_143700_135060 n1_M2_144780_135060 0.988200
R17134 n1_M2_144780_135060 n1_M2_145860_135060 0.988200
R17135 n1_M2_145860_135060 n1_M2_146940_135060 0.988200
R17136 n1_M2_60_136140 n1_M2_1140_136140 0.988200
R17137 n1_M2_1140_136140 n1_M2_2220_136140 0.988200
R17138 n1_M2_2220_136140 n1_M2_3300_136140 0.988200
R17139 n1_M2_3300_136140 n1_M2_4380_136140 0.988200
R17140 n1_M2_4380_136140 n1_M2_5460_136140 0.988200
R17141 n1_M2_5460_136140 n1_M2_6540_136140 0.988200
R17142 n1_M2_6540_136140 n1_M2_7620_136140 0.988200
R17143 n1_M2_7620_136140 n1_M2_8700_136140 0.988200
R17144 n1_M2_8700_136140 n1_M2_9780_136140 0.988200
R17145 n1_M2_9780_136140 n1_M2_10860_136140 0.988200
R17146 n1_M2_10860_136140 n1_M2_11940_136140 0.988200
R17147 n1_M2_11940_136140 n1_M2_13020_136140 0.988200
R17148 n1_M2_13020_136140 n1_M2_14100_136140 0.988200
R17149 n1_M2_14100_136140 n1_M2_15180_136140 0.988200
R17150 n1_M2_15180_136140 n1_M2_16260_136140 0.988200
R17151 n1_M2_16260_136140 n1_M2_17340_136140 0.988200
R17152 n1_M2_17340_136140 n1_M2_18420_136140 0.988200
R17153 n1_M2_18420_136140 n1_M2_19500_136140 0.988200
R17154 n1_M2_19500_136140 n1_M2_20580_136140 0.988200
R17155 n1_M2_20580_136140 n1_M2_21660_136140 0.988200
R17156 n1_M2_21660_136140 n1_M2_22740_136140 0.988200
R17157 n1_M2_22740_136140 n1_M2_23820_136140 0.988200
R17158 n1_M2_23820_136140 n1_M2_24900_136140 0.988200
R17159 n1_M2_24900_136140 n1_M2_25980_136140 0.988200
R17160 n1_M2_25980_136140 n1_M2_27060_136140 0.988200
R17161 n1_M2_27060_136140 n1_M2_28140_136140 0.988200
R17162 n1_M2_28140_136140 n1_M2_29220_136140 0.988200
R17163 n1_M2_29220_136140 n1_M2_30300_136140 0.988200
R17164 n1_M2_30300_136140 n1_M2_31380_136140 0.988200
R17165 n1_M2_31380_136140 n1_M2_32460_136140 0.988200
R17166 n1_M2_32460_136140 n1_M2_33540_136140 0.988200
R17167 n1_M2_33540_136140 n1_M2_34620_136140 0.988200
R17168 n1_M2_34620_136140 n1_M2_35700_136140 0.988200
R17169 n1_M2_35700_136140 n1_M2_36780_136140 0.988200
R17170 n1_M2_36780_136140 n1_M2_37860_136140 0.988200
R17171 n1_M2_37860_136140 n1_M2_38940_136140 0.988200
R17172 n1_M2_38940_136140 n1_M2_40020_136140 0.988200
R17173 n1_M2_40020_136140 n1_M2_41100_136140 0.988200
R17174 n1_M2_41100_136140 n1_M2_42180_136140 0.988200
R17175 n1_M2_42180_136140 n1_M2_43260_136140 0.988200
R17176 n1_M2_43260_136140 n1_M2_44340_136140 0.988200
R17177 n1_M2_44340_136140 n1_M2_45420_136140 0.988200
R17178 n1_M2_45420_136140 n1_M2_46500_136140 0.988200
R17179 n1_M2_46500_136140 n1_M2_47580_136140 0.988200
R17180 n1_M2_47580_136140 n1_M2_48660_136140 0.988200
R17181 n1_M2_48660_136140 n1_M2_49740_136140 0.988200
R17182 n1_M2_49740_136140 n1_M2_50820_136140 0.988200
R17183 n1_M2_50820_136140 n1_M2_51900_136140 0.988200
R17184 n1_M2_51900_136140 n1_M2_52980_136140 0.988200
R17185 n1_M2_52980_136140 n1_M2_54060_136140 0.988200
R17186 n1_M2_54060_136140 n1_M2_55140_136140 0.988200
R17187 n1_M2_55140_136140 n1_M2_56220_136140 0.988200
R17188 n1_M2_56220_136140 n1_M2_57300_136140 0.988200
R17189 n1_M2_57300_136140 n1_M2_58380_136140 0.988200
R17190 n1_M2_58380_136140 n1_M2_59460_136140 0.988200
R17191 n1_M2_59460_136140 n1_M2_60540_136140 0.988200
R17192 n1_M2_60540_136140 n1_M2_61620_136140 0.988200
R17193 n1_M2_61620_136140 n1_M2_62700_136140 0.988200
R17194 n1_M2_62700_136140 n1_M2_63780_136140 0.988200
R17195 n1_M2_63780_136140 n1_M2_64860_136140 0.988200
R17196 n1_M2_64860_136140 n1_M2_65940_136140 0.988200
R17197 n1_M2_65940_136140 n1_M2_67020_136140 0.988200
R17198 n1_M2_67020_136140 n1_M2_68100_136140 0.988200
R17199 n1_M2_68100_136140 n1_M2_69180_136140 0.988200
R17200 n1_M2_69180_136140 n1_M2_70260_136140 0.988200
R17201 n1_M2_70260_136140 n1_M2_71340_136140 0.988200
R17202 n1_M2_71340_136140 n1_M2_72420_136140 0.988200
R17203 n1_M2_72420_136140 n1_M2_73500_136140 0.988200
R17204 n1_M2_73500_136140 n1_M2_74580_136140 0.988200
R17205 n1_M2_74580_136140 n1_M2_75660_136140 0.988200
R17206 n1_M2_75660_136140 n1_M2_76740_136140 0.988200
R17207 n1_M2_76740_136140 n1_M2_77820_136140 0.988200
R17208 n1_M2_77820_136140 n1_M2_78900_136140 0.988200
R17209 n1_M2_78900_136140 n1_M2_79980_136140 0.988200
R17210 n1_M2_79980_136140 n1_M2_81060_136140 0.988200
R17211 n1_M2_81060_136140 n1_M2_82140_136140 0.988200
R17212 n1_M2_82140_136140 n1_M2_83220_136140 0.988200
R17213 n1_M2_83220_136140 n1_M2_84300_136140 0.988200
R17214 n1_M2_84300_136140 n1_M2_85380_136140 0.988200
R17215 n1_M2_85380_136140 n1_M2_86460_136140 0.988200
R17216 n1_M2_86460_136140 n1_M2_87540_136140 0.988200
R17217 n1_M2_87540_136140 n1_M2_88620_136140 0.988200
R17218 n1_M2_88620_136140 n1_M2_89700_136140 0.988200
R17219 n1_M2_89700_136140 n1_M2_90780_136140 0.988200
R17220 n1_M2_90780_136140 n1_M2_91860_136140 0.988200
R17221 n1_M2_91860_136140 n1_M2_92940_136140 0.988200
R17222 n1_M2_92940_136140 n1_M2_94020_136140 0.988200
R17223 n1_M2_94020_136140 n1_M2_95100_136140 0.988200
R17224 n1_M2_95100_136140 n1_M2_96180_136140 0.988200
R17225 n1_M2_96180_136140 n1_M2_97260_136140 0.988200
R17226 n1_M2_97260_136140 n1_M2_98340_136140 0.988200
R17227 n1_M2_98340_136140 n1_M2_99420_136140 0.988200
R17228 n1_M2_99420_136140 n1_M2_100500_136140 0.988200
R17229 n1_M2_100500_136140 n1_M2_101580_136140 0.988200
R17230 n1_M2_101580_136140 n1_M2_102660_136140 0.988200
R17231 n1_M2_102660_136140 n1_M2_103740_136140 0.988200
R17232 n1_M2_103740_136140 n1_M2_104820_136140 0.988200
R17233 n1_M2_104820_136140 n1_M2_105900_136140 0.988200
R17234 n1_M2_105900_136140 n1_M2_106980_136140 0.988200
R17235 n1_M2_106980_136140 n1_M2_108060_136140 0.988200
R17236 n1_M2_108060_136140 n1_M2_109140_136140 0.988200
R17237 n1_M2_109140_136140 n1_M2_110220_136140 0.988200
R17238 n1_M2_110220_136140 n1_M2_111300_136140 0.988200
R17239 n1_M2_111300_136140 n1_M2_112380_136140 0.988200
R17240 n1_M2_112380_136140 n1_M2_113460_136140 0.988200
R17241 n1_M2_113460_136140 n1_M2_114540_136140 0.988200
R17242 n1_M2_114540_136140 n1_M2_115620_136140 0.988200
R17243 n1_M2_115620_136140 n1_M2_116700_136140 0.988200
R17244 n1_M2_116700_136140 n1_M2_117780_136140 0.988200
R17245 n1_M2_117780_136140 n1_M2_118860_136140 0.988200
R17246 n1_M2_118860_136140 n1_M2_119940_136140 0.988200
R17247 n1_M2_119940_136140 n1_M2_121020_136140 0.988200
R17248 n1_M2_121020_136140 n1_M2_122100_136140 0.988200
R17249 n1_M2_122100_136140 n1_M2_123180_136140 0.988200
R17250 n1_M2_123180_136140 n1_M2_124260_136140 0.988200
R17251 n1_M2_124260_136140 n1_M2_125340_136140 0.988200
R17252 n1_M2_125340_136140 n1_M2_126420_136140 0.988200
R17253 n1_M2_126420_136140 n1_M2_127500_136140 0.988200
R17254 n1_M2_127500_136140 n1_M2_128580_136140 0.988200
R17255 n1_M2_128580_136140 n1_M2_129660_136140 0.988200
R17256 n1_M2_129660_136140 n1_M2_130740_136140 0.988200
R17257 n1_M2_130740_136140 n1_M2_131820_136140 0.988200
R17258 n1_M2_131820_136140 n1_M2_132900_136140 0.988200
R17259 n1_M2_132900_136140 n1_M2_133980_136140 0.988200
R17260 n1_M2_133980_136140 n1_M2_135060_136140 0.988200
R17261 n1_M2_135060_136140 n1_M2_136140_136140 0.988200
R17262 n1_M2_136140_136140 n1_M2_137220_136140 0.988200
R17263 n1_M2_137220_136140 n1_M2_138300_136140 0.988200
R17264 n1_M2_138300_136140 n1_M2_139380_136140 0.988200
R17265 n1_M2_139380_136140 n1_M2_140460_136140 0.988200
R17266 n1_M2_140460_136140 n1_M2_141540_136140 0.988200
R17267 n1_M2_141540_136140 n1_M2_142620_136140 0.988200
R17268 n1_M2_142620_136140 n1_M2_143700_136140 0.988200
R17269 n1_M2_143700_136140 n1_M2_144780_136140 0.988200
R17270 n1_M2_144780_136140 n1_M2_145860_136140 0.988200
R17271 n1_M2_145860_136140 n1_M2_146940_136140 0.988200
R17272 n1_M2_60_137220 n1_M2_1140_137220 0.988200
R17273 n1_M2_1140_137220 n1_M2_2220_137220 0.988200
R17274 n1_M2_2220_137220 n1_M2_3300_137220 0.988200
R17275 n1_M2_3300_137220 n1_M2_4380_137220 0.988200
R17276 n1_M2_4380_137220 n1_M2_5460_137220 0.988200
R17277 n1_M2_5460_137220 n1_M2_6540_137220 0.988200
R17278 n1_M2_6540_137220 n1_M2_7620_137220 0.988200
R17279 n1_M2_7620_137220 n1_M2_8700_137220 0.988200
R17280 n1_M2_8700_137220 n1_M2_9780_137220 0.988200
R17281 n1_M2_9780_137220 n1_M2_10860_137220 0.988200
R17282 n1_M2_10860_137220 n1_M2_11940_137220 0.988200
R17283 n1_M2_11940_137220 n1_M2_13020_137220 0.988200
R17284 n1_M2_13020_137220 n1_M2_14100_137220 0.988200
R17285 n1_M2_14100_137220 n1_M2_15180_137220 0.988200
R17286 n1_M2_15180_137220 n1_M2_16260_137220 0.988200
R17287 n1_M2_16260_137220 n1_M2_17340_137220 0.988200
R17288 n1_M2_17340_137220 n1_M2_18420_137220 0.988200
R17289 n1_M2_18420_137220 n1_M2_19500_137220 0.988200
R17290 n1_M2_19500_137220 n1_M2_20580_137220 0.988200
R17291 n1_M2_20580_137220 n1_M2_21660_137220 0.988200
R17292 n1_M2_21660_137220 n1_M2_22740_137220 0.988200
R17293 n1_M2_22740_137220 n1_M2_23820_137220 0.988200
R17294 n1_M2_23820_137220 n1_M2_24900_137220 0.988200
R17295 n1_M2_24900_137220 n1_M2_25980_137220 0.988200
R17296 n1_M2_25980_137220 n1_M2_27060_137220 0.988200
R17297 n1_M2_27060_137220 n1_M2_28140_137220 0.988200
R17298 n1_M2_28140_137220 n1_M2_29220_137220 0.988200
R17299 n1_M2_29220_137220 n1_M2_30300_137220 0.988200
R17300 n1_M2_30300_137220 n1_M2_31380_137220 0.988200
R17301 n1_M2_31380_137220 n1_M2_32460_137220 0.988200
R17302 n1_M2_32460_137220 n1_M2_33540_137220 0.988200
R17303 n1_M2_33540_137220 n1_M2_34620_137220 0.988200
R17304 n1_M2_34620_137220 n1_M2_35700_137220 0.988200
R17305 n1_M2_35700_137220 n1_M2_36780_137220 0.988200
R17306 n1_M2_36780_137220 n1_M2_37860_137220 0.988200
R17307 n1_M2_37860_137220 n1_M2_38940_137220 0.988200
R17308 n1_M2_38940_137220 n1_M2_40020_137220 0.988200
R17309 n1_M2_40020_137220 n1_M2_41100_137220 0.988200
R17310 n1_M2_41100_137220 n1_M2_42180_137220 0.988200
R17311 n1_M2_42180_137220 n1_M2_43260_137220 0.988200
R17312 n1_M2_43260_137220 n1_M2_44340_137220 0.988200
R17313 n1_M2_44340_137220 n1_M2_45420_137220 0.988200
R17314 n1_M2_45420_137220 n1_M2_46500_137220 0.988200
R17315 n1_M2_46500_137220 n1_M2_47580_137220 0.988200
R17316 n1_M2_47580_137220 n1_M2_48660_137220 0.988200
R17317 n1_M2_48660_137220 n1_M2_49740_137220 0.988200
R17318 n1_M2_49740_137220 n1_M2_50820_137220 0.988200
R17319 n1_M2_50820_137220 n1_M2_51900_137220 0.988200
R17320 n1_M2_51900_137220 n1_M2_52980_137220 0.988200
R17321 n1_M2_52980_137220 n1_M2_54060_137220 0.988200
R17322 n1_M2_54060_137220 n1_M2_55140_137220 0.988200
R17323 n1_M2_55140_137220 n1_M2_56220_137220 0.988200
R17324 n1_M2_56220_137220 n1_M2_57300_137220 0.988200
R17325 n1_M2_57300_137220 n1_M2_58380_137220 0.988200
R17326 n1_M2_58380_137220 n1_M2_59460_137220 0.988200
R17327 n1_M2_59460_137220 n1_M2_60540_137220 0.988200
R17328 n1_M2_60540_137220 n1_M2_61620_137220 0.988200
R17329 n1_M2_61620_137220 n1_M2_62700_137220 0.988200
R17330 n1_M2_62700_137220 n1_M2_63780_137220 0.988200
R17331 n1_M2_63780_137220 n1_M2_64860_137220 0.988200
R17332 n1_M2_64860_137220 n1_M2_65940_137220 0.988200
R17333 n1_M2_65940_137220 n1_M2_67020_137220 0.988200
R17334 n1_M2_67020_137220 n1_M2_68100_137220 0.988200
R17335 n1_M2_68100_137220 n1_M2_69180_137220 0.988200
R17336 n1_M2_69180_137220 n1_M2_70260_137220 0.988200
R17337 n1_M2_70260_137220 n1_M2_71340_137220 0.988200
R17338 n1_M2_71340_137220 n1_M2_72420_137220 0.988200
R17339 n1_M2_72420_137220 n1_M2_73500_137220 0.988200
R17340 n1_M2_73500_137220 n1_M2_74580_137220 0.988200
R17341 n1_M2_74580_137220 n1_M2_75660_137220 0.988200
R17342 n1_M2_75660_137220 n1_M2_76740_137220 0.988200
R17343 n1_M2_76740_137220 n1_M2_77820_137220 0.988200
R17344 n1_M2_77820_137220 n1_M2_78900_137220 0.988200
R17345 n1_M2_78900_137220 n1_M2_79980_137220 0.988200
R17346 n1_M2_79980_137220 n1_M2_81060_137220 0.988200
R17347 n1_M2_81060_137220 n1_M2_82140_137220 0.988200
R17348 n1_M2_82140_137220 n1_M2_83220_137220 0.988200
R17349 n1_M2_83220_137220 n1_M2_84300_137220 0.988200
R17350 n1_M2_84300_137220 n1_M2_85380_137220 0.988200
R17351 n1_M2_85380_137220 n1_M2_86460_137220 0.988200
R17352 n1_M2_86460_137220 n1_M2_87540_137220 0.988200
R17353 n1_M2_87540_137220 n1_M2_88620_137220 0.988200
R17354 n1_M2_88620_137220 n1_M2_89700_137220 0.988200
R17355 n1_M2_89700_137220 n1_M2_90780_137220 0.988200
R17356 n1_M2_90780_137220 n1_M2_91860_137220 0.988200
R17357 n1_M2_91860_137220 n1_M2_92940_137220 0.988200
R17358 n1_M2_92940_137220 n1_M2_94020_137220 0.988200
R17359 n1_M2_94020_137220 n1_M2_95100_137220 0.988200
R17360 n1_M2_95100_137220 n1_M2_96180_137220 0.988200
R17361 n1_M2_96180_137220 n1_M2_97260_137220 0.988200
R17362 n1_M2_97260_137220 n1_M2_98340_137220 0.988200
R17363 n1_M2_98340_137220 n1_M2_99420_137220 0.988200
R17364 n1_M2_99420_137220 n1_M2_100500_137220 0.988200
R17365 n1_M2_100500_137220 n1_M2_101580_137220 0.988200
R17366 n1_M2_101580_137220 n1_M2_102660_137220 0.988200
R17367 n1_M2_102660_137220 n1_M2_103740_137220 0.988200
R17368 n1_M2_103740_137220 n1_M2_104820_137220 0.988200
R17369 n1_M2_104820_137220 n1_M2_105900_137220 0.988200
R17370 n1_M2_105900_137220 n1_M2_106980_137220 0.988200
R17371 n1_M2_106980_137220 n1_M2_108060_137220 0.988200
R17372 n1_M2_108060_137220 n1_M2_109140_137220 0.988200
R17373 n1_M2_109140_137220 n1_M2_110220_137220 0.988200
R17374 n1_M2_110220_137220 n1_M2_111300_137220 0.988200
R17375 n1_M2_111300_137220 n1_M2_112380_137220 0.988200
R17376 n1_M2_112380_137220 n1_M2_113460_137220 0.988200
R17377 n1_M2_113460_137220 n1_M2_114540_137220 0.988200
R17378 n1_M2_114540_137220 n1_M2_115620_137220 0.988200
R17379 n1_M2_115620_137220 n1_M2_116700_137220 0.988200
R17380 n1_M2_116700_137220 n1_M2_117780_137220 0.988200
R17381 n1_M2_117780_137220 n1_M2_118860_137220 0.988200
R17382 n1_M2_118860_137220 n1_M2_119940_137220 0.988200
R17383 n1_M2_119940_137220 n1_M2_121020_137220 0.988200
R17384 n1_M2_121020_137220 n1_M2_122100_137220 0.988200
R17385 n1_M2_122100_137220 n1_M2_123180_137220 0.988200
R17386 n1_M2_123180_137220 n1_M2_124260_137220 0.988200
R17387 n1_M2_124260_137220 n1_M2_125340_137220 0.988200
R17388 n1_M2_125340_137220 n1_M2_126420_137220 0.988200
R17389 n1_M2_126420_137220 n1_M2_127500_137220 0.988200
R17390 n1_M2_127500_137220 n1_M2_128580_137220 0.988200
R17391 n1_M2_128580_137220 n1_M2_129660_137220 0.988200
R17392 n1_M2_129660_137220 n1_M2_130740_137220 0.988200
R17393 n1_M2_130740_137220 n1_M2_131820_137220 0.988200
R17394 n1_M2_131820_137220 n1_M2_132900_137220 0.988200
R17395 n1_M2_132900_137220 n1_M2_133980_137220 0.988200
R17396 n1_M2_133980_137220 n1_M2_135060_137220 0.988200
R17397 n1_M2_135060_137220 n1_M2_136140_137220 0.988200
R17398 n1_M2_136140_137220 n1_M2_137220_137220 0.988200
R17399 n1_M2_137220_137220 n1_M2_138300_137220 0.988200
R17400 n1_M2_138300_137220 n1_M2_139380_137220 0.988200
R17401 n1_M2_139380_137220 n1_M2_140460_137220 0.988200
R17402 n1_M2_140460_137220 n1_M2_141540_137220 0.988200
R17403 n1_M2_141540_137220 n1_M2_142620_137220 0.988200
R17404 n1_M2_142620_137220 n1_M2_143700_137220 0.988200
R17405 n1_M2_143700_137220 n1_M2_144780_137220 0.988200
R17406 n1_M2_144780_137220 n1_M2_145860_137220 0.988200
R17407 n1_M2_145860_137220 n1_M2_146940_137220 0.988200
R17408 n1_M2_60_138300 n1_M2_1140_138300 0.988200
R17409 n1_M2_1140_138300 n1_M2_2220_138300 0.988200
R17410 n1_M2_2220_138300 n1_M2_3300_138300 0.988200
R17411 n1_M2_3300_138300 n1_M2_4380_138300 0.988200
R17412 n1_M2_4380_138300 n1_M2_5460_138300 0.988200
R17413 n1_M2_5460_138300 n1_M2_6540_138300 0.988200
R17414 n1_M2_6540_138300 n1_M2_7620_138300 0.988200
R17415 n1_M2_7620_138300 n1_M2_8700_138300 0.988200
R17416 n1_M2_8700_138300 n1_M2_9780_138300 0.988200
R17417 n1_M2_9780_138300 n1_M2_10860_138300 0.988200
R17418 n1_M2_10860_138300 n1_M2_11940_138300 0.988200
R17419 n1_M2_11940_138300 n1_M2_13020_138300 0.988200
R17420 n1_M2_13020_138300 n1_M2_14100_138300 0.988200
R17421 n1_M2_14100_138300 n1_M2_15180_138300 0.988200
R17422 n1_M2_15180_138300 n1_M2_16260_138300 0.988200
R17423 n1_M2_16260_138300 n1_M2_17340_138300 0.988200
R17424 n1_M2_17340_138300 n1_M2_18420_138300 0.988200
R17425 n1_M2_18420_138300 n1_M2_19500_138300 0.988200
R17426 n1_M2_19500_138300 n1_M2_20580_138300 0.988200
R17427 n1_M2_20580_138300 n1_M2_21660_138300 0.988200
R17428 n1_M2_21660_138300 n1_M2_22740_138300 0.988200
R17429 n1_M2_22740_138300 n1_M2_23820_138300 0.988200
R17430 n1_M2_23820_138300 n1_M2_24900_138300 0.988200
R17431 n1_M2_24900_138300 n1_M2_25980_138300 0.988200
R17432 n1_M2_25980_138300 n1_M2_27060_138300 0.988200
R17433 n1_M2_27060_138300 n1_M2_28140_138300 0.988200
R17434 n1_M2_28140_138300 n1_M2_29220_138300 0.988200
R17435 n1_M2_29220_138300 n1_M2_30300_138300 0.988200
R17436 n1_M2_30300_138300 n1_M2_31380_138300 0.988200
R17437 n1_M2_31380_138300 n1_M2_32460_138300 0.988200
R17438 n1_M2_32460_138300 n1_M2_33540_138300 0.988200
R17439 n1_M2_33540_138300 n1_M2_34620_138300 0.988200
R17440 n1_M2_34620_138300 n1_M2_35700_138300 0.988200
R17441 n1_M2_35700_138300 n1_M2_36780_138300 0.988200
R17442 n1_M2_36780_138300 n1_M2_37860_138300 0.988200
R17443 n1_M2_37860_138300 n1_M2_38940_138300 0.988200
R17444 n1_M2_38940_138300 n1_M2_40020_138300 0.988200
R17445 n1_M2_40020_138300 n1_M2_41100_138300 0.988200
R17446 n1_M2_41100_138300 n1_M2_42180_138300 0.988200
R17447 n1_M2_42180_138300 n1_M2_43260_138300 0.988200
R17448 n1_M2_43260_138300 n1_M2_44340_138300 0.988200
R17449 n1_M2_44340_138300 n1_M2_45420_138300 0.988200
R17450 n1_M2_45420_138300 n1_M2_46500_138300 0.988200
R17451 n1_M2_46500_138300 n1_M2_47580_138300 0.988200
R17452 n1_M2_47580_138300 n1_M2_48660_138300 0.988200
R17453 n1_M2_48660_138300 n1_M2_49740_138300 0.988200
R17454 n1_M2_49740_138300 n1_M2_50820_138300 0.988200
R17455 n1_M2_50820_138300 n1_M2_51900_138300 0.988200
R17456 n1_M2_51900_138300 n1_M2_52980_138300 0.988200
R17457 n1_M2_52980_138300 n1_M2_54060_138300 0.988200
R17458 n1_M2_54060_138300 n1_M2_55140_138300 0.988200
R17459 n1_M2_55140_138300 n1_M2_56220_138300 0.988200
R17460 n1_M2_56220_138300 n1_M2_57300_138300 0.988200
R17461 n1_M2_57300_138300 n1_M2_58380_138300 0.988200
R17462 n1_M2_58380_138300 n1_M2_59460_138300 0.988200
R17463 n1_M2_59460_138300 n1_M2_60540_138300 0.988200
R17464 n1_M2_60540_138300 n1_M2_61620_138300 0.988200
R17465 n1_M2_61620_138300 n1_M2_62700_138300 0.988200
R17466 n1_M2_62700_138300 n1_M2_63780_138300 0.988200
R17467 n1_M2_63780_138300 n1_M2_64860_138300 0.988200
R17468 n1_M2_64860_138300 n1_M2_65940_138300 0.988200
R17469 n1_M2_65940_138300 n1_M2_67020_138300 0.988200
R17470 n1_M2_67020_138300 n1_M2_68100_138300 0.988200
R17471 n1_M2_68100_138300 n1_M2_69180_138300 0.988200
R17472 n1_M2_69180_138300 n1_M2_70260_138300 0.988200
R17473 n1_M2_70260_138300 n1_M2_71340_138300 0.988200
R17474 n1_M2_71340_138300 n1_M2_72420_138300 0.988200
R17475 n1_M2_72420_138300 n1_M2_73500_138300 0.988200
R17476 n1_M2_73500_138300 n1_M2_74580_138300 0.988200
R17477 n1_M2_74580_138300 n1_M2_75660_138300 0.988200
R17478 n1_M2_75660_138300 n1_M2_76740_138300 0.988200
R17479 n1_M2_76740_138300 n1_M2_77820_138300 0.988200
R17480 n1_M2_77820_138300 n1_M2_78900_138300 0.988200
R17481 n1_M2_78900_138300 n1_M2_79980_138300 0.988200
R17482 n1_M2_79980_138300 n1_M2_81060_138300 0.988200
R17483 n1_M2_81060_138300 n1_M2_82140_138300 0.988200
R17484 n1_M2_82140_138300 n1_M2_83220_138300 0.988200
R17485 n1_M2_83220_138300 n1_M2_84300_138300 0.988200
R17486 n1_M2_84300_138300 n1_M2_85380_138300 0.988200
R17487 n1_M2_85380_138300 n1_M2_86460_138300 0.988200
R17488 n1_M2_86460_138300 n1_M2_87540_138300 0.988200
R17489 n1_M2_87540_138300 n1_M2_88620_138300 0.988200
R17490 n1_M2_88620_138300 n1_M2_89700_138300 0.988200
R17491 n1_M2_89700_138300 n1_M2_90780_138300 0.988200
R17492 n1_M2_90780_138300 n1_M2_91860_138300 0.988200
R17493 n1_M2_91860_138300 n1_M2_92940_138300 0.988200
R17494 n1_M2_92940_138300 n1_M2_94020_138300 0.988200
R17495 n1_M2_94020_138300 n1_M2_95100_138300 0.988200
R17496 n1_M2_95100_138300 n1_M2_96180_138300 0.988200
R17497 n1_M2_96180_138300 n1_M2_97260_138300 0.988200
R17498 n1_M2_97260_138300 n1_M2_98340_138300 0.988200
R17499 n1_M2_98340_138300 n1_M2_99420_138300 0.988200
R17500 n1_M2_99420_138300 n1_M2_100500_138300 0.988200
R17501 n1_M2_100500_138300 n1_M2_101580_138300 0.988200
R17502 n1_M2_101580_138300 n1_M2_102660_138300 0.988200
R17503 n1_M2_102660_138300 n1_M2_103740_138300 0.988200
R17504 n1_M2_103740_138300 n1_M2_104820_138300 0.988200
R17505 n1_M2_104820_138300 n1_M2_105900_138300 0.988200
R17506 n1_M2_105900_138300 n1_M2_106980_138300 0.988200
R17507 n1_M2_106980_138300 n1_M2_108060_138300 0.988200
R17508 n1_M2_108060_138300 n1_M2_109140_138300 0.988200
R17509 n1_M2_109140_138300 n1_M2_110220_138300 0.988200
R17510 n1_M2_110220_138300 n1_M2_111300_138300 0.988200
R17511 n1_M2_111300_138300 n1_M2_112380_138300 0.988200
R17512 n1_M2_112380_138300 n1_M2_113460_138300 0.988200
R17513 n1_M2_113460_138300 n1_M2_114540_138300 0.988200
R17514 n1_M2_114540_138300 n1_M2_115620_138300 0.988200
R17515 n1_M2_115620_138300 n1_M2_116700_138300 0.988200
R17516 n1_M2_116700_138300 n1_M2_117780_138300 0.988200
R17517 n1_M2_117780_138300 n1_M2_118860_138300 0.988200
R17518 n1_M2_118860_138300 n1_M2_119940_138300 0.988200
R17519 n1_M2_119940_138300 n1_M2_121020_138300 0.988200
R17520 n1_M2_121020_138300 n1_M2_122100_138300 0.988200
R17521 n1_M2_122100_138300 n1_M2_123180_138300 0.988200
R17522 n1_M2_123180_138300 n1_M2_124260_138300 0.988200
R17523 n1_M2_124260_138300 n1_M2_125340_138300 0.988200
R17524 n1_M2_125340_138300 n1_M2_126420_138300 0.988200
R17525 n1_M2_126420_138300 n1_M2_127500_138300 0.988200
R17526 n1_M2_127500_138300 n1_M2_128580_138300 0.988200
R17527 n1_M2_128580_138300 n1_M2_129660_138300 0.988200
R17528 n1_M2_129660_138300 n1_M2_130740_138300 0.988200
R17529 n1_M2_130740_138300 n1_M2_131820_138300 0.988200
R17530 n1_M2_131820_138300 n1_M2_132900_138300 0.988200
R17531 n1_M2_132900_138300 n1_M2_133980_138300 0.988200
R17532 n1_M2_133980_138300 n1_M2_135060_138300 0.988200
R17533 n1_M2_135060_138300 n1_M2_136140_138300 0.988200
R17534 n1_M2_136140_138300 n1_M2_137220_138300 0.988200
R17535 n1_M2_137220_138300 n1_M2_138300_138300 0.988200
R17536 n1_M2_138300_138300 n1_M2_139380_138300 0.988200
R17537 n1_M2_139380_138300 n1_M2_140460_138300 0.988200
R17538 n1_M2_140460_138300 n1_M2_141540_138300 0.988200
R17539 n1_M2_141540_138300 n1_M2_142620_138300 0.988200
R17540 n1_M2_142620_138300 n1_M2_143700_138300 0.988200
R17541 n1_M2_143700_138300 n1_M2_144780_138300 0.988200
R17542 n1_M2_144780_138300 n1_M2_145860_138300 0.988200
R17543 n1_M2_145860_138300 n1_M2_146940_138300 0.988200
R17544 n1_M2_60_139380 n1_M2_1140_139380 0.988200
R17545 n1_M2_1140_139380 n1_M2_2220_139380 0.988200
R17546 n1_M2_2220_139380 n1_M2_3300_139380 0.988200
R17547 n1_M2_3300_139380 n1_M2_4380_139380 0.988200
R17548 n1_M2_4380_139380 n1_M2_5460_139380 0.988200
R17549 n1_M2_5460_139380 n1_M2_6540_139380 0.988200
R17550 n1_M2_6540_139380 n1_M2_7620_139380 0.988200
R17551 n1_M2_7620_139380 n1_M2_8700_139380 0.988200
R17552 n1_M2_8700_139380 n1_M2_9780_139380 0.988200
R17553 n1_M2_9780_139380 n1_M2_10860_139380 0.988200
R17554 n1_M2_10860_139380 n1_M2_11940_139380 0.988200
R17555 n1_M2_11940_139380 n1_M2_13020_139380 0.988200
R17556 n1_M2_13020_139380 n1_M2_14100_139380 0.988200
R17557 n1_M2_14100_139380 n1_M2_15180_139380 0.988200
R17558 n1_M2_15180_139380 n1_M2_16260_139380 0.988200
R17559 n1_M2_16260_139380 n1_M2_17340_139380 0.988200
R17560 n1_M2_17340_139380 n1_M2_18420_139380 0.988200
R17561 n1_M2_18420_139380 n1_M2_19500_139380 0.988200
R17562 n1_M2_19500_139380 n1_M2_20580_139380 0.988200
R17563 n1_M2_20580_139380 n1_M2_21660_139380 0.988200
R17564 n1_M2_21660_139380 n1_M2_22740_139380 0.988200
R17565 n1_M2_22740_139380 n1_M2_23820_139380 0.988200
R17566 n1_M2_23820_139380 n1_M2_24900_139380 0.988200
R17567 n1_M2_24900_139380 n1_M2_25980_139380 0.988200
R17568 n1_M2_25980_139380 n1_M2_27060_139380 0.988200
R17569 n1_M2_27060_139380 n1_M2_28140_139380 0.988200
R17570 n1_M2_28140_139380 n1_M2_29220_139380 0.988200
R17571 n1_M2_29220_139380 n1_M2_30300_139380 0.988200
R17572 n1_M2_30300_139380 n1_M2_31380_139380 0.988200
R17573 n1_M2_31380_139380 n1_M2_32460_139380 0.988200
R17574 n1_M2_32460_139380 n1_M2_33540_139380 0.988200
R17575 n1_M2_33540_139380 n1_M2_34620_139380 0.988200
R17576 n1_M2_34620_139380 n1_M2_35700_139380 0.988200
R17577 n1_M2_35700_139380 n1_M2_36780_139380 0.988200
R17578 n1_M2_36780_139380 n1_M2_37860_139380 0.988200
R17579 n1_M2_37860_139380 n1_M2_38940_139380 0.988200
R17580 n1_M2_38940_139380 n1_M2_40020_139380 0.988200
R17581 n1_M2_40020_139380 n1_M2_41100_139380 0.988200
R17582 n1_M2_41100_139380 n1_M2_42180_139380 0.988200
R17583 n1_M2_42180_139380 n1_M2_43260_139380 0.988200
R17584 n1_M2_43260_139380 n1_M2_44340_139380 0.988200
R17585 n1_M2_44340_139380 n1_M2_45420_139380 0.988200
R17586 n1_M2_45420_139380 n1_M2_46500_139380 0.988200
R17587 n1_M2_46500_139380 n1_M2_47580_139380 0.988200
R17588 n1_M2_47580_139380 n1_M2_48660_139380 0.988200
R17589 n1_M2_48660_139380 n1_M2_49740_139380 0.988200
R17590 n1_M2_49740_139380 n1_M2_50820_139380 0.988200
R17591 n1_M2_50820_139380 n1_M2_51900_139380 0.988200
R17592 n1_M2_51900_139380 n1_M2_52980_139380 0.988200
R17593 n1_M2_52980_139380 n1_M2_54060_139380 0.988200
R17594 n1_M2_54060_139380 n1_M2_55140_139380 0.988200
R17595 n1_M2_55140_139380 n1_M2_56220_139380 0.988200
R17596 n1_M2_56220_139380 n1_M2_57300_139380 0.988200
R17597 n1_M2_57300_139380 n1_M2_58380_139380 0.988200
R17598 n1_M2_58380_139380 n1_M2_59460_139380 0.988200
R17599 n1_M2_59460_139380 n1_M2_60540_139380 0.988200
R17600 n1_M2_60540_139380 n1_M2_61620_139380 0.988200
R17601 n1_M2_61620_139380 n1_M2_62700_139380 0.988200
R17602 n1_M2_62700_139380 n1_M2_63780_139380 0.988200
R17603 n1_M2_63780_139380 n1_M2_64860_139380 0.988200
R17604 n1_M2_64860_139380 n1_M2_65940_139380 0.988200
R17605 n1_M2_65940_139380 n1_M2_67020_139380 0.988200
R17606 n1_M2_67020_139380 n1_M2_68100_139380 0.988200
R17607 n1_M2_68100_139380 n1_M2_69180_139380 0.988200
R17608 n1_M2_69180_139380 n1_M2_70260_139380 0.988200
R17609 n1_M2_70260_139380 n1_M2_71340_139380 0.988200
R17610 n1_M2_71340_139380 n1_M2_72420_139380 0.988200
R17611 n1_M2_72420_139380 n1_M2_73500_139380 0.988200
R17612 n1_M2_73500_139380 n1_M2_74580_139380 0.988200
R17613 n1_M2_74580_139380 n1_M2_75660_139380 0.988200
R17614 n1_M2_75660_139380 n1_M2_76740_139380 0.988200
R17615 n1_M2_76740_139380 n1_M2_77820_139380 0.988200
R17616 n1_M2_77820_139380 n1_M2_78900_139380 0.988200
R17617 n1_M2_78900_139380 n1_M2_79980_139380 0.988200
R17618 n1_M2_79980_139380 n1_M2_81060_139380 0.988200
R17619 n1_M2_81060_139380 n1_M2_82140_139380 0.988200
R17620 n1_M2_82140_139380 n1_M2_83220_139380 0.988200
R17621 n1_M2_83220_139380 n1_M2_84300_139380 0.988200
R17622 n1_M2_84300_139380 n1_M2_85380_139380 0.988200
R17623 n1_M2_85380_139380 n1_M2_86460_139380 0.988200
R17624 n1_M2_86460_139380 n1_M2_87540_139380 0.988200
R17625 n1_M2_87540_139380 n1_M2_88620_139380 0.988200
R17626 n1_M2_88620_139380 n1_M2_89700_139380 0.988200
R17627 n1_M2_89700_139380 n1_M2_90780_139380 0.988200
R17628 n1_M2_90780_139380 n1_M2_91860_139380 0.988200
R17629 n1_M2_91860_139380 n1_M2_92940_139380 0.988200
R17630 n1_M2_92940_139380 n1_M2_94020_139380 0.988200
R17631 n1_M2_94020_139380 n1_M2_95100_139380 0.988200
R17632 n1_M2_95100_139380 n1_M2_96180_139380 0.988200
R17633 n1_M2_96180_139380 n1_M2_97260_139380 0.988200
R17634 n1_M2_97260_139380 n1_M2_98340_139380 0.988200
R17635 n1_M2_98340_139380 n1_M2_99420_139380 0.988200
R17636 n1_M2_99420_139380 n1_M2_100500_139380 0.988200
R17637 n1_M2_100500_139380 n1_M2_101580_139380 0.988200
R17638 n1_M2_101580_139380 n1_M2_102660_139380 0.988200
R17639 n1_M2_102660_139380 n1_M2_103740_139380 0.988200
R17640 n1_M2_103740_139380 n1_M2_104820_139380 0.988200
R17641 n1_M2_104820_139380 n1_M2_105900_139380 0.988200
R17642 n1_M2_105900_139380 n1_M2_106980_139380 0.988200
R17643 n1_M2_106980_139380 n1_M2_108060_139380 0.988200
R17644 n1_M2_108060_139380 n1_M2_109140_139380 0.988200
R17645 n1_M2_109140_139380 n1_M2_110220_139380 0.988200
R17646 n1_M2_110220_139380 n1_M2_111300_139380 0.988200
R17647 n1_M2_111300_139380 n1_M2_112380_139380 0.988200
R17648 n1_M2_112380_139380 n1_M2_113460_139380 0.988200
R17649 n1_M2_113460_139380 n1_M2_114540_139380 0.988200
R17650 n1_M2_114540_139380 n1_M2_115620_139380 0.988200
R17651 n1_M2_115620_139380 n1_M2_116700_139380 0.988200
R17652 n1_M2_116700_139380 n1_M2_117780_139380 0.988200
R17653 n1_M2_117780_139380 n1_M2_118860_139380 0.988200
R17654 n1_M2_118860_139380 n1_M2_119940_139380 0.988200
R17655 n1_M2_119940_139380 n1_M2_121020_139380 0.988200
R17656 n1_M2_121020_139380 n1_M2_122100_139380 0.988200
R17657 n1_M2_122100_139380 n1_M2_123180_139380 0.988200
R17658 n1_M2_123180_139380 n1_M2_124260_139380 0.988200
R17659 n1_M2_124260_139380 n1_M2_125340_139380 0.988200
R17660 n1_M2_125340_139380 n1_M2_126420_139380 0.988200
R17661 n1_M2_126420_139380 n1_M2_127500_139380 0.988200
R17662 n1_M2_127500_139380 n1_M2_128580_139380 0.988200
R17663 n1_M2_128580_139380 n1_M2_129660_139380 0.988200
R17664 n1_M2_129660_139380 n1_M2_130740_139380 0.988200
R17665 n1_M2_130740_139380 n1_M2_131820_139380 0.988200
R17666 n1_M2_131820_139380 n1_M2_132900_139380 0.988200
R17667 n1_M2_132900_139380 n1_M2_133980_139380 0.988200
R17668 n1_M2_133980_139380 n1_M2_135060_139380 0.988200
R17669 n1_M2_135060_139380 n1_M2_136140_139380 0.988200
R17670 n1_M2_136140_139380 n1_M2_137220_139380 0.988200
R17671 n1_M2_137220_139380 n1_M2_138300_139380 0.988200
R17672 n1_M2_138300_139380 n1_M2_139380_139380 0.988200
R17673 n1_M2_139380_139380 n1_M2_140460_139380 0.988200
R17674 n1_M2_140460_139380 n1_M2_141540_139380 0.988200
R17675 n1_M2_141540_139380 n1_M2_142620_139380 0.988200
R17676 n1_M2_142620_139380 n1_M2_143700_139380 0.988200
R17677 n1_M2_143700_139380 n1_M2_144780_139380 0.988200
R17678 n1_M2_144780_139380 n1_M2_145860_139380 0.988200
R17679 n1_M2_145860_139380 n1_M2_146940_139380 0.988200
R17680 n1_M2_60_140460 n1_M2_1140_140460 0.988200
R17681 n1_M2_1140_140460 n1_M2_2220_140460 0.988200
R17682 n1_M2_2220_140460 n1_M2_3300_140460 0.988200
R17683 n1_M2_3300_140460 n1_M2_4380_140460 0.988200
R17684 n1_M2_4380_140460 n1_M2_5460_140460 0.988200
R17685 n1_M2_5460_140460 n1_M2_6540_140460 0.988200
R17686 n1_M2_6540_140460 n1_M2_7620_140460 0.988200
R17687 n1_M2_7620_140460 n1_M2_8700_140460 0.988200
R17688 n1_M2_8700_140460 n1_M2_9780_140460 0.988200
R17689 n1_M2_9780_140460 n1_M2_10860_140460 0.988200
R17690 n1_M2_10860_140460 n1_M2_11940_140460 0.988200
R17691 n1_M2_11940_140460 n1_M2_13020_140460 0.988200
R17692 n1_M2_13020_140460 n1_M2_14100_140460 0.988200
R17693 n1_M2_14100_140460 n1_M2_15180_140460 0.988200
R17694 n1_M2_15180_140460 n1_M2_16260_140460 0.988200
R17695 n1_M2_16260_140460 n1_M2_17340_140460 0.988200
R17696 n1_M2_17340_140460 n1_M2_18420_140460 0.988200
R17697 n1_M2_18420_140460 n1_M2_19500_140460 0.988200
R17698 n1_M2_19500_140460 n1_M2_20580_140460 0.988200
R17699 n1_M2_20580_140460 n1_M2_21660_140460 0.988200
R17700 n1_M2_21660_140460 n1_M2_22740_140460 0.988200
R17701 n1_M2_22740_140460 n1_M2_23820_140460 0.988200
R17702 n1_M2_23820_140460 n1_M2_24900_140460 0.988200
R17703 n1_M2_24900_140460 n1_M2_25980_140460 0.988200
R17704 n1_M2_25980_140460 n1_M2_27060_140460 0.988200
R17705 n1_M2_27060_140460 n1_M2_28140_140460 0.988200
R17706 n1_M2_28140_140460 n1_M2_29220_140460 0.988200
R17707 n1_M2_29220_140460 n1_M2_30300_140460 0.988200
R17708 n1_M2_30300_140460 n1_M2_31380_140460 0.988200
R17709 n1_M2_31380_140460 n1_M2_32460_140460 0.988200
R17710 n1_M2_32460_140460 n1_M2_33540_140460 0.988200
R17711 n1_M2_33540_140460 n1_M2_34620_140460 0.988200
R17712 n1_M2_34620_140460 n1_M2_35700_140460 0.988200
R17713 n1_M2_35700_140460 n1_M2_36780_140460 0.988200
R17714 n1_M2_36780_140460 n1_M2_37860_140460 0.988200
R17715 n1_M2_37860_140460 n1_M2_38940_140460 0.988200
R17716 n1_M2_38940_140460 n1_M2_40020_140460 0.988200
R17717 n1_M2_40020_140460 n1_M2_41100_140460 0.988200
R17718 n1_M2_41100_140460 n1_M2_42180_140460 0.988200
R17719 n1_M2_42180_140460 n1_M2_43260_140460 0.988200
R17720 n1_M2_43260_140460 n1_M2_44340_140460 0.988200
R17721 n1_M2_44340_140460 n1_M2_45420_140460 0.988200
R17722 n1_M2_45420_140460 n1_M2_46500_140460 0.988200
R17723 n1_M2_46500_140460 n1_M2_47580_140460 0.988200
R17724 n1_M2_47580_140460 n1_M2_48660_140460 0.988200
R17725 n1_M2_48660_140460 n1_M2_49740_140460 0.988200
R17726 n1_M2_49740_140460 n1_M2_50820_140460 0.988200
R17727 n1_M2_50820_140460 n1_M2_51900_140460 0.988200
R17728 n1_M2_51900_140460 n1_M2_52980_140460 0.988200
R17729 n1_M2_52980_140460 n1_M2_54060_140460 0.988200
R17730 n1_M2_54060_140460 n1_M2_55140_140460 0.988200
R17731 n1_M2_55140_140460 n1_M2_56220_140460 0.988200
R17732 n1_M2_56220_140460 n1_M2_57300_140460 0.988200
R17733 n1_M2_57300_140460 n1_M2_58380_140460 0.988200
R17734 n1_M2_58380_140460 n1_M2_59460_140460 0.988200
R17735 n1_M2_59460_140460 n1_M2_60540_140460 0.988200
R17736 n1_M2_60540_140460 n1_M2_61620_140460 0.988200
R17737 n1_M2_61620_140460 n1_M2_62700_140460 0.988200
R17738 n1_M2_62700_140460 n1_M2_63780_140460 0.988200
R17739 n1_M2_63780_140460 n1_M2_64860_140460 0.988200
R17740 n1_M2_64860_140460 n1_M2_65940_140460 0.988200
R17741 n1_M2_65940_140460 n1_M2_67020_140460 0.988200
R17742 n1_M2_67020_140460 n1_M2_68100_140460 0.988200
R17743 n1_M2_68100_140460 n1_M2_69180_140460 0.988200
R17744 n1_M2_69180_140460 n1_M2_70260_140460 0.988200
R17745 n1_M2_70260_140460 n1_M2_71340_140460 0.988200
R17746 n1_M2_71340_140460 n1_M2_72420_140460 0.988200
R17747 n1_M2_72420_140460 n1_M2_73500_140460 0.988200
R17748 n1_M2_73500_140460 n1_M2_74580_140460 0.988200
R17749 n1_M2_74580_140460 n1_M2_75660_140460 0.988200
R17750 n1_M2_75660_140460 n1_M2_76740_140460 0.988200
R17751 n1_M2_76740_140460 n1_M2_77820_140460 0.988200
R17752 n1_M2_77820_140460 n1_M2_78900_140460 0.988200
R17753 n1_M2_78900_140460 n1_M2_79980_140460 0.988200
R17754 n1_M2_79980_140460 n1_M2_81060_140460 0.988200
R17755 n1_M2_81060_140460 n1_M2_82140_140460 0.988200
R17756 n1_M2_82140_140460 n1_M2_83220_140460 0.988200
R17757 n1_M2_83220_140460 n1_M2_84300_140460 0.988200
R17758 n1_M2_84300_140460 n1_M2_85380_140460 0.988200
R17759 n1_M2_85380_140460 n1_M2_86460_140460 0.988200
R17760 n1_M2_86460_140460 n1_M2_87540_140460 0.988200
R17761 n1_M2_87540_140460 n1_M2_88620_140460 0.988200
R17762 n1_M2_88620_140460 n1_M2_89700_140460 0.988200
R17763 n1_M2_89700_140460 n1_M2_90780_140460 0.988200
R17764 n1_M2_90780_140460 n1_M2_91860_140460 0.988200
R17765 n1_M2_91860_140460 n1_M2_92940_140460 0.988200
R17766 n1_M2_92940_140460 n1_M2_94020_140460 0.988200
R17767 n1_M2_94020_140460 n1_M2_95100_140460 0.988200
R17768 n1_M2_95100_140460 n1_M2_96180_140460 0.988200
R17769 n1_M2_96180_140460 n1_M2_97260_140460 0.988200
R17770 n1_M2_97260_140460 n1_M2_98340_140460 0.988200
R17771 n1_M2_98340_140460 n1_M2_99420_140460 0.988200
R17772 n1_M2_99420_140460 n1_M2_100500_140460 0.988200
R17773 n1_M2_100500_140460 n1_M2_101580_140460 0.988200
R17774 n1_M2_101580_140460 n1_M2_102660_140460 0.988200
R17775 n1_M2_102660_140460 n1_M2_103740_140460 0.988200
R17776 n1_M2_103740_140460 n1_M2_104820_140460 0.988200
R17777 n1_M2_104820_140460 n1_M2_105900_140460 0.988200
R17778 n1_M2_105900_140460 n1_M2_106980_140460 0.988200
R17779 n1_M2_106980_140460 n1_M2_108060_140460 0.988200
R17780 n1_M2_108060_140460 n1_M2_109140_140460 0.988200
R17781 n1_M2_109140_140460 n1_M2_110220_140460 0.988200
R17782 n1_M2_110220_140460 n1_M2_111300_140460 0.988200
R17783 n1_M2_111300_140460 n1_M2_112380_140460 0.988200
R17784 n1_M2_112380_140460 n1_M2_113460_140460 0.988200
R17785 n1_M2_113460_140460 n1_M2_114540_140460 0.988200
R17786 n1_M2_114540_140460 n1_M2_115620_140460 0.988200
R17787 n1_M2_115620_140460 n1_M2_116700_140460 0.988200
R17788 n1_M2_116700_140460 n1_M2_117780_140460 0.988200
R17789 n1_M2_117780_140460 n1_M2_118860_140460 0.988200
R17790 n1_M2_118860_140460 n1_M2_119940_140460 0.988200
R17791 n1_M2_119940_140460 n1_M2_121020_140460 0.988200
R17792 n1_M2_121020_140460 n1_M2_122100_140460 0.988200
R17793 n1_M2_122100_140460 n1_M2_123180_140460 0.988200
R17794 n1_M2_123180_140460 n1_M2_124260_140460 0.988200
R17795 n1_M2_124260_140460 n1_M2_125340_140460 0.988200
R17796 n1_M2_125340_140460 n1_M2_126420_140460 0.988200
R17797 n1_M2_126420_140460 n1_M2_127500_140460 0.988200
R17798 n1_M2_127500_140460 n1_M2_128580_140460 0.988200
R17799 n1_M2_128580_140460 n1_M2_129660_140460 0.988200
R17800 n1_M2_129660_140460 n1_M2_130740_140460 0.988200
R17801 n1_M2_130740_140460 n1_M2_131820_140460 0.988200
R17802 n1_M2_131820_140460 n1_M2_132900_140460 0.988200
R17803 n1_M2_132900_140460 n1_M2_133980_140460 0.988200
R17804 n1_M2_133980_140460 n1_M2_135060_140460 0.988200
R17805 n1_M2_135060_140460 n1_M2_136140_140460 0.988200
R17806 n1_M2_136140_140460 n1_M2_137220_140460 0.988200
R17807 n1_M2_137220_140460 n1_M2_138300_140460 0.988200
R17808 n1_M2_138300_140460 n1_M2_139380_140460 0.988200
R17809 n1_M2_139380_140460 n1_M2_140460_140460 0.988200
R17810 n1_M2_140460_140460 n1_M2_141540_140460 0.988200
R17811 n1_M2_141540_140460 n1_M2_142620_140460 0.988200
R17812 n1_M2_142620_140460 n1_M2_143700_140460 0.988200
R17813 n1_M2_143700_140460 n1_M2_144780_140460 0.988200
R17814 n1_M2_144780_140460 n1_M2_145860_140460 0.988200
R17815 n1_M2_145860_140460 n1_M2_146940_140460 0.988200
R17816 n1_M2_60_141540 n1_M2_1140_141540 0.988200
R17817 n1_M2_1140_141540 n1_M2_2220_141540 0.988200
R17818 n1_M2_2220_141540 n1_M2_3300_141540 0.988200
R17819 n1_M2_3300_141540 n1_M2_4380_141540 0.988200
R17820 n1_M2_4380_141540 n1_M2_5460_141540 0.988200
R17821 n1_M2_5460_141540 n1_M2_6540_141540 0.988200
R17822 n1_M2_6540_141540 n1_M2_7620_141540 0.988200
R17823 n1_M2_7620_141540 n1_M2_8700_141540 0.988200
R17824 n1_M2_8700_141540 n1_M2_9780_141540 0.988200
R17825 n1_M2_9780_141540 n1_M2_10860_141540 0.988200
R17826 n1_M2_10860_141540 n1_M2_11940_141540 0.988200
R17827 n1_M2_11940_141540 n1_M2_13020_141540 0.988200
R17828 n1_M2_13020_141540 n1_M2_14100_141540 0.988200
R17829 n1_M2_14100_141540 n1_M2_15180_141540 0.988200
R17830 n1_M2_15180_141540 n1_M2_16260_141540 0.988200
R17831 n1_M2_16260_141540 n1_M2_17340_141540 0.988200
R17832 n1_M2_17340_141540 n1_M2_18420_141540 0.988200
R17833 n1_M2_18420_141540 n1_M2_19500_141540 0.988200
R17834 n1_M2_19500_141540 n1_M2_20580_141540 0.988200
R17835 n1_M2_20580_141540 n1_M2_21660_141540 0.988200
R17836 n1_M2_21660_141540 n1_M2_22740_141540 0.988200
R17837 n1_M2_22740_141540 n1_M2_23820_141540 0.988200
R17838 n1_M2_23820_141540 n1_M2_24900_141540 0.988200
R17839 n1_M2_24900_141540 n1_M2_25980_141540 0.988200
R17840 n1_M2_25980_141540 n1_M2_27060_141540 0.988200
R17841 n1_M2_27060_141540 n1_M2_28140_141540 0.988200
R17842 n1_M2_28140_141540 n1_M2_29220_141540 0.988200
R17843 n1_M2_29220_141540 n1_M2_30300_141540 0.988200
R17844 n1_M2_30300_141540 n1_M2_31380_141540 0.988200
R17845 n1_M2_31380_141540 n1_M2_32460_141540 0.988200
R17846 n1_M2_32460_141540 n1_M2_33540_141540 0.988200
R17847 n1_M2_33540_141540 n1_M2_34620_141540 0.988200
R17848 n1_M2_34620_141540 n1_M2_35700_141540 0.988200
R17849 n1_M2_35700_141540 n1_M2_36780_141540 0.988200
R17850 n1_M2_36780_141540 n1_M2_37860_141540 0.988200
R17851 n1_M2_37860_141540 n1_M2_38940_141540 0.988200
R17852 n1_M2_38940_141540 n1_M2_40020_141540 0.988200
R17853 n1_M2_40020_141540 n1_M2_41100_141540 0.988200
R17854 n1_M2_41100_141540 n1_M2_42180_141540 0.988200
R17855 n1_M2_42180_141540 n1_M2_43260_141540 0.988200
R17856 n1_M2_43260_141540 n1_M2_44340_141540 0.988200
R17857 n1_M2_44340_141540 n1_M2_45420_141540 0.988200
R17858 n1_M2_45420_141540 n1_M2_46500_141540 0.988200
R17859 n1_M2_46500_141540 n1_M2_47580_141540 0.988200
R17860 n1_M2_47580_141540 n1_M2_48660_141540 0.988200
R17861 n1_M2_48660_141540 n1_M2_49740_141540 0.988200
R17862 n1_M2_49740_141540 n1_M2_50820_141540 0.988200
R17863 n1_M2_50820_141540 n1_M2_51900_141540 0.988200
R17864 n1_M2_51900_141540 n1_M2_52980_141540 0.988200
R17865 n1_M2_52980_141540 n1_M2_54060_141540 0.988200
R17866 n1_M2_54060_141540 n1_M2_55140_141540 0.988200
R17867 n1_M2_55140_141540 n1_M2_56220_141540 0.988200
R17868 n1_M2_56220_141540 n1_M2_57300_141540 0.988200
R17869 n1_M2_57300_141540 n1_M2_58380_141540 0.988200
R17870 n1_M2_58380_141540 n1_M2_59460_141540 0.988200
R17871 n1_M2_59460_141540 n1_M2_60540_141540 0.988200
R17872 n1_M2_60540_141540 n1_M2_61620_141540 0.988200
R17873 n1_M2_61620_141540 n1_M2_62700_141540 0.988200
R17874 n1_M2_62700_141540 n1_M2_63780_141540 0.988200
R17875 n1_M2_63780_141540 n1_M2_64860_141540 0.988200
R17876 n1_M2_64860_141540 n1_M2_65940_141540 0.988200
R17877 n1_M2_65940_141540 n1_M2_67020_141540 0.988200
R17878 n1_M2_67020_141540 n1_M2_68100_141540 0.988200
R17879 n1_M2_68100_141540 n1_M2_69180_141540 0.988200
R17880 n1_M2_69180_141540 n1_M2_70260_141540 0.988200
R17881 n1_M2_70260_141540 n1_M2_71340_141540 0.988200
R17882 n1_M2_71340_141540 n1_M2_72420_141540 0.988200
R17883 n1_M2_72420_141540 n1_M2_73500_141540 0.988200
R17884 n1_M2_73500_141540 n1_M2_74580_141540 0.988200
R17885 n1_M2_74580_141540 n1_M2_75660_141540 0.988200
R17886 n1_M2_75660_141540 n1_M2_76740_141540 0.988200
R17887 n1_M2_76740_141540 n1_M2_77820_141540 0.988200
R17888 n1_M2_77820_141540 n1_M2_78900_141540 0.988200
R17889 n1_M2_78900_141540 n1_M2_79980_141540 0.988200
R17890 n1_M2_79980_141540 n1_M2_81060_141540 0.988200
R17891 n1_M2_81060_141540 n1_M2_82140_141540 0.988200
R17892 n1_M2_82140_141540 n1_M2_83220_141540 0.988200
R17893 n1_M2_83220_141540 n1_M2_84300_141540 0.988200
R17894 n1_M2_84300_141540 n1_M2_85380_141540 0.988200
R17895 n1_M2_85380_141540 n1_M2_86460_141540 0.988200
R17896 n1_M2_86460_141540 n1_M2_87540_141540 0.988200
R17897 n1_M2_87540_141540 n1_M2_88620_141540 0.988200
R17898 n1_M2_88620_141540 n1_M2_89700_141540 0.988200
R17899 n1_M2_89700_141540 n1_M2_90780_141540 0.988200
R17900 n1_M2_90780_141540 n1_M2_91860_141540 0.988200
R17901 n1_M2_91860_141540 n1_M2_92940_141540 0.988200
R17902 n1_M2_92940_141540 n1_M2_94020_141540 0.988200
R17903 n1_M2_94020_141540 n1_M2_95100_141540 0.988200
R17904 n1_M2_95100_141540 n1_M2_96180_141540 0.988200
R17905 n1_M2_96180_141540 n1_M2_97260_141540 0.988200
R17906 n1_M2_97260_141540 n1_M2_98340_141540 0.988200
R17907 n1_M2_98340_141540 n1_M2_99420_141540 0.988200
R17908 n1_M2_99420_141540 n1_M2_100500_141540 0.988200
R17909 n1_M2_100500_141540 n1_M2_101580_141540 0.988200
R17910 n1_M2_101580_141540 n1_M2_102660_141540 0.988200
R17911 n1_M2_102660_141540 n1_M2_103740_141540 0.988200
R17912 n1_M2_103740_141540 n1_M2_104820_141540 0.988200
R17913 n1_M2_104820_141540 n1_M2_105900_141540 0.988200
R17914 n1_M2_105900_141540 n1_M2_106980_141540 0.988200
R17915 n1_M2_106980_141540 n1_M2_108060_141540 0.988200
R17916 n1_M2_108060_141540 n1_M2_109140_141540 0.988200
R17917 n1_M2_109140_141540 n1_M2_110220_141540 0.988200
R17918 n1_M2_110220_141540 n1_M2_111300_141540 0.988200
R17919 n1_M2_111300_141540 n1_M2_112380_141540 0.988200
R17920 n1_M2_112380_141540 n1_M2_113460_141540 0.988200
R17921 n1_M2_113460_141540 n1_M2_114540_141540 0.988200
R17922 n1_M2_114540_141540 n1_M2_115620_141540 0.988200
R17923 n1_M2_115620_141540 n1_M2_116700_141540 0.988200
R17924 n1_M2_116700_141540 n1_M2_117780_141540 0.988200
R17925 n1_M2_117780_141540 n1_M2_118860_141540 0.988200
R17926 n1_M2_118860_141540 n1_M2_119940_141540 0.988200
R17927 n1_M2_119940_141540 n1_M2_121020_141540 0.988200
R17928 n1_M2_121020_141540 n1_M2_122100_141540 0.988200
R17929 n1_M2_122100_141540 n1_M2_123180_141540 0.988200
R17930 n1_M2_123180_141540 n1_M2_124260_141540 0.988200
R17931 n1_M2_124260_141540 n1_M2_125340_141540 0.988200
R17932 n1_M2_125340_141540 n1_M2_126420_141540 0.988200
R17933 n1_M2_126420_141540 n1_M2_127500_141540 0.988200
R17934 n1_M2_127500_141540 n1_M2_128580_141540 0.988200
R17935 n1_M2_128580_141540 n1_M2_129660_141540 0.988200
R17936 n1_M2_129660_141540 n1_M2_130740_141540 0.988200
R17937 n1_M2_130740_141540 n1_M2_131820_141540 0.988200
R17938 n1_M2_131820_141540 n1_M2_132900_141540 0.988200
R17939 n1_M2_132900_141540 n1_M2_133980_141540 0.988200
R17940 n1_M2_133980_141540 n1_M2_135060_141540 0.988200
R17941 n1_M2_135060_141540 n1_M2_136140_141540 0.988200
R17942 n1_M2_136140_141540 n1_M2_137220_141540 0.988200
R17943 n1_M2_137220_141540 n1_M2_138300_141540 0.988200
R17944 n1_M2_138300_141540 n1_M2_139380_141540 0.988200
R17945 n1_M2_139380_141540 n1_M2_140460_141540 0.988200
R17946 n1_M2_140460_141540 n1_M2_141540_141540 0.988200
R17947 n1_M2_141540_141540 n1_M2_142620_141540 0.988200
R17948 n1_M2_142620_141540 n1_M2_143700_141540 0.988200
R17949 n1_M2_143700_141540 n1_M2_144780_141540 0.988200
R17950 n1_M2_144780_141540 n1_M2_145860_141540 0.988200
R17951 n1_M2_145860_141540 n1_M2_146940_141540 0.988200
R17952 n1_M2_60_142620 n1_M2_1140_142620 0.988200
R17953 n1_M2_1140_142620 n1_M2_2220_142620 0.988200
R17954 n1_M2_2220_142620 n1_M2_3300_142620 0.988200
R17955 n1_M2_3300_142620 n1_M2_4380_142620 0.988200
R17956 n1_M2_4380_142620 n1_M2_5460_142620 0.988200
R17957 n1_M2_5460_142620 n1_M2_6540_142620 0.988200
R17958 n1_M2_6540_142620 n1_M2_7620_142620 0.988200
R17959 n1_M2_7620_142620 n1_M2_8700_142620 0.988200
R17960 n1_M2_8700_142620 n1_M2_9780_142620 0.988200
R17961 n1_M2_9780_142620 n1_M2_10860_142620 0.988200
R17962 n1_M2_10860_142620 n1_M2_11940_142620 0.988200
R17963 n1_M2_11940_142620 n1_M2_13020_142620 0.988200
R17964 n1_M2_13020_142620 n1_M2_14100_142620 0.988200
R17965 n1_M2_14100_142620 n1_M2_15180_142620 0.988200
R17966 n1_M2_15180_142620 n1_M2_16260_142620 0.988200
R17967 n1_M2_16260_142620 n1_M2_17340_142620 0.988200
R17968 n1_M2_17340_142620 n1_M2_18420_142620 0.988200
R17969 n1_M2_18420_142620 n1_M2_19500_142620 0.988200
R17970 n1_M2_19500_142620 n1_M2_20580_142620 0.988200
R17971 n1_M2_20580_142620 n1_M2_21660_142620 0.988200
R17972 n1_M2_21660_142620 n1_M2_22740_142620 0.988200
R17973 n1_M2_22740_142620 n1_M2_23820_142620 0.988200
R17974 n1_M2_23820_142620 n1_M2_24900_142620 0.988200
R17975 n1_M2_24900_142620 n1_M2_25980_142620 0.988200
R17976 n1_M2_25980_142620 n1_M2_27060_142620 0.988200
R17977 n1_M2_27060_142620 n1_M2_28140_142620 0.988200
R17978 n1_M2_28140_142620 n1_M2_29220_142620 0.988200
R17979 n1_M2_29220_142620 n1_M2_30300_142620 0.988200
R17980 n1_M2_30300_142620 n1_M2_31380_142620 0.988200
R17981 n1_M2_31380_142620 n1_M2_32460_142620 0.988200
R17982 n1_M2_32460_142620 n1_M2_33540_142620 0.988200
R17983 n1_M2_33540_142620 n1_M2_34620_142620 0.988200
R17984 n1_M2_34620_142620 n1_M2_35700_142620 0.988200
R17985 n1_M2_35700_142620 n1_M2_36780_142620 0.988200
R17986 n1_M2_36780_142620 n1_M2_37860_142620 0.988200
R17987 n1_M2_37860_142620 n1_M2_38940_142620 0.988200
R17988 n1_M2_38940_142620 n1_M2_40020_142620 0.988200
R17989 n1_M2_40020_142620 n1_M2_41100_142620 0.988200
R17990 n1_M2_41100_142620 n1_M2_42180_142620 0.988200
R17991 n1_M2_42180_142620 n1_M2_43260_142620 0.988200
R17992 n1_M2_43260_142620 n1_M2_44340_142620 0.988200
R17993 n1_M2_44340_142620 n1_M2_45420_142620 0.988200
R17994 n1_M2_45420_142620 n1_M2_46500_142620 0.988200
R17995 n1_M2_46500_142620 n1_M2_47580_142620 0.988200
R17996 n1_M2_47580_142620 n1_M2_48660_142620 0.988200
R17997 n1_M2_48660_142620 n1_M2_49740_142620 0.988200
R17998 n1_M2_49740_142620 n1_M2_50820_142620 0.988200
R17999 n1_M2_50820_142620 n1_M2_51900_142620 0.988200
R18000 n1_M2_51900_142620 n1_M2_52980_142620 0.988200
R18001 n1_M2_52980_142620 n1_M2_54060_142620 0.988200
R18002 n1_M2_54060_142620 n1_M2_55140_142620 0.988200
R18003 n1_M2_55140_142620 n1_M2_56220_142620 0.988200
R18004 n1_M2_56220_142620 n1_M2_57300_142620 0.988200
R18005 n1_M2_57300_142620 n1_M2_58380_142620 0.988200
R18006 n1_M2_58380_142620 n1_M2_59460_142620 0.988200
R18007 n1_M2_59460_142620 n1_M2_60540_142620 0.988200
R18008 n1_M2_60540_142620 n1_M2_61620_142620 0.988200
R18009 n1_M2_61620_142620 n1_M2_62700_142620 0.988200
R18010 n1_M2_62700_142620 n1_M2_63780_142620 0.988200
R18011 n1_M2_63780_142620 n1_M2_64860_142620 0.988200
R18012 n1_M2_64860_142620 n1_M2_65940_142620 0.988200
R18013 n1_M2_65940_142620 n1_M2_67020_142620 0.988200
R18014 n1_M2_67020_142620 n1_M2_68100_142620 0.988200
R18015 n1_M2_68100_142620 n1_M2_69180_142620 0.988200
R18016 n1_M2_69180_142620 n1_M2_70260_142620 0.988200
R18017 n1_M2_70260_142620 n1_M2_71340_142620 0.988200
R18018 n1_M2_71340_142620 n1_M2_72420_142620 0.988200
R18019 n1_M2_72420_142620 n1_M2_73500_142620 0.988200
R18020 n1_M2_73500_142620 n1_M2_74580_142620 0.988200
R18021 n1_M2_74580_142620 n1_M2_75660_142620 0.988200
R18022 n1_M2_75660_142620 n1_M2_76740_142620 0.988200
R18023 n1_M2_76740_142620 n1_M2_77820_142620 0.988200
R18024 n1_M2_77820_142620 n1_M2_78900_142620 0.988200
R18025 n1_M2_78900_142620 n1_M2_79980_142620 0.988200
R18026 n1_M2_79980_142620 n1_M2_81060_142620 0.988200
R18027 n1_M2_81060_142620 n1_M2_82140_142620 0.988200
R18028 n1_M2_82140_142620 n1_M2_83220_142620 0.988200
R18029 n1_M2_83220_142620 n1_M2_84300_142620 0.988200
R18030 n1_M2_84300_142620 n1_M2_85380_142620 0.988200
R18031 n1_M2_85380_142620 n1_M2_86460_142620 0.988200
R18032 n1_M2_86460_142620 n1_M2_87540_142620 0.988200
R18033 n1_M2_87540_142620 n1_M2_88620_142620 0.988200
R18034 n1_M2_88620_142620 n1_M2_89700_142620 0.988200
R18035 n1_M2_89700_142620 n1_M2_90780_142620 0.988200
R18036 n1_M2_90780_142620 n1_M2_91860_142620 0.988200
R18037 n1_M2_91860_142620 n1_M2_92940_142620 0.988200
R18038 n1_M2_92940_142620 n1_M2_94020_142620 0.988200
R18039 n1_M2_94020_142620 n1_M2_95100_142620 0.988200
R18040 n1_M2_95100_142620 n1_M2_96180_142620 0.988200
R18041 n1_M2_96180_142620 n1_M2_97260_142620 0.988200
R18042 n1_M2_97260_142620 n1_M2_98340_142620 0.988200
R18043 n1_M2_98340_142620 n1_M2_99420_142620 0.988200
R18044 n1_M2_99420_142620 n1_M2_100500_142620 0.988200
R18045 n1_M2_100500_142620 n1_M2_101580_142620 0.988200
R18046 n1_M2_101580_142620 n1_M2_102660_142620 0.988200
R18047 n1_M2_102660_142620 n1_M2_103740_142620 0.988200
R18048 n1_M2_103740_142620 n1_M2_104820_142620 0.988200
R18049 n1_M2_104820_142620 n1_M2_105900_142620 0.988200
R18050 n1_M2_105900_142620 n1_M2_106980_142620 0.988200
R18051 n1_M2_106980_142620 n1_M2_108060_142620 0.988200
R18052 n1_M2_108060_142620 n1_M2_109140_142620 0.988200
R18053 n1_M2_109140_142620 n1_M2_110220_142620 0.988200
R18054 n1_M2_110220_142620 n1_M2_111300_142620 0.988200
R18055 n1_M2_111300_142620 n1_M2_112380_142620 0.988200
R18056 n1_M2_112380_142620 n1_M2_113460_142620 0.988200
R18057 n1_M2_113460_142620 n1_M2_114540_142620 0.988200
R18058 n1_M2_114540_142620 n1_M2_115620_142620 0.988200
R18059 n1_M2_115620_142620 n1_M2_116700_142620 0.988200
R18060 n1_M2_116700_142620 n1_M2_117780_142620 0.988200
R18061 n1_M2_117780_142620 n1_M2_118860_142620 0.988200
R18062 n1_M2_118860_142620 n1_M2_119940_142620 0.988200
R18063 n1_M2_119940_142620 n1_M2_121020_142620 0.988200
R18064 n1_M2_121020_142620 n1_M2_122100_142620 0.988200
R18065 n1_M2_122100_142620 n1_M2_123180_142620 0.988200
R18066 n1_M2_123180_142620 n1_M2_124260_142620 0.988200
R18067 n1_M2_124260_142620 n1_M2_125340_142620 0.988200
R18068 n1_M2_125340_142620 n1_M2_126420_142620 0.988200
R18069 n1_M2_126420_142620 n1_M2_127500_142620 0.988200
R18070 n1_M2_127500_142620 n1_M2_128580_142620 0.988200
R18071 n1_M2_128580_142620 n1_M2_129660_142620 0.988200
R18072 n1_M2_129660_142620 n1_M2_130740_142620 0.988200
R18073 n1_M2_130740_142620 n1_M2_131820_142620 0.988200
R18074 n1_M2_131820_142620 n1_M2_132900_142620 0.988200
R18075 n1_M2_132900_142620 n1_M2_133980_142620 0.988200
R18076 n1_M2_133980_142620 n1_M2_135060_142620 0.988200
R18077 n1_M2_135060_142620 n1_M2_136140_142620 0.988200
R18078 n1_M2_136140_142620 n1_M2_137220_142620 0.988200
R18079 n1_M2_137220_142620 n1_M2_138300_142620 0.988200
R18080 n1_M2_138300_142620 n1_M2_139380_142620 0.988200
R18081 n1_M2_139380_142620 n1_M2_140460_142620 0.988200
R18082 n1_M2_140460_142620 n1_M2_141540_142620 0.988200
R18083 n1_M2_141540_142620 n1_M2_142620_142620 0.988200
R18084 n1_M2_142620_142620 n1_M2_143700_142620 0.988200
R18085 n1_M2_143700_142620 n1_M2_144780_142620 0.988200
R18086 n1_M2_144780_142620 n1_M2_145860_142620 0.988200
R18087 n1_M2_145860_142620 n1_M2_146940_142620 0.988200
R18088 n1_M2_60_143700 n1_M2_1140_143700 0.988200
R18089 n1_M2_1140_143700 n1_M2_2220_143700 0.988200
R18090 n1_M2_2220_143700 n1_M2_3300_143700 0.988200
R18091 n1_M2_3300_143700 n1_M2_4380_143700 0.988200
R18092 n1_M2_4380_143700 n1_M2_5460_143700 0.988200
R18093 n1_M2_5460_143700 n1_M2_6540_143700 0.988200
R18094 n1_M2_6540_143700 n1_M2_7620_143700 0.988200
R18095 n1_M2_7620_143700 n1_M2_8700_143700 0.988200
R18096 n1_M2_8700_143700 n1_M2_9780_143700 0.988200
R18097 n1_M2_9780_143700 n1_M2_10860_143700 0.988200
R18098 n1_M2_10860_143700 n1_M2_11940_143700 0.988200
R18099 n1_M2_11940_143700 n1_M2_13020_143700 0.988200
R18100 n1_M2_13020_143700 n1_M2_14100_143700 0.988200
R18101 n1_M2_14100_143700 n1_M2_15180_143700 0.988200
R18102 n1_M2_15180_143700 n1_M2_16260_143700 0.988200
R18103 n1_M2_16260_143700 n1_M2_17340_143700 0.988200
R18104 n1_M2_17340_143700 n1_M2_18420_143700 0.988200
R18105 n1_M2_18420_143700 n1_M2_19500_143700 0.988200
R18106 n1_M2_19500_143700 n1_M2_20580_143700 0.988200
R18107 n1_M2_20580_143700 n1_M2_21660_143700 0.988200
R18108 n1_M2_21660_143700 n1_M2_22740_143700 0.988200
R18109 n1_M2_22740_143700 n1_M2_23820_143700 0.988200
R18110 n1_M2_23820_143700 n1_M2_24900_143700 0.988200
R18111 n1_M2_24900_143700 n1_M2_25980_143700 0.988200
R18112 n1_M2_25980_143700 n1_M2_27060_143700 0.988200
R18113 n1_M2_27060_143700 n1_M2_28140_143700 0.988200
R18114 n1_M2_28140_143700 n1_M2_29220_143700 0.988200
R18115 n1_M2_29220_143700 n1_M2_30300_143700 0.988200
R18116 n1_M2_30300_143700 n1_M2_31380_143700 0.988200
R18117 n1_M2_31380_143700 n1_M2_32460_143700 0.988200
R18118 n1_M2_32460_143700 n1_M2_33540_143700 0.988200
R18119 n1_M2_33540_143700 n1_M2_34620_143700 0.988200
R18120 n1_M2_34620_143700 n1_M2_35700_143700 0.988200
R18121 n1_M2_35700_143700 n1_M2_36780_143700 0.988200
R18122 n1_M2_36780_143700 n1_M2_37860_143700 0.988200
R18123 n1_M2_37860_143700 n1_M2_38940_143700 0.988200
R18124 n1_M2_38940_143700 n1_M2_40020_143700 0.988200
R18125 n1_M2_40020_143700 n1_M2_41100_143700 0.988200
R18126 n1_M2_41100_143700 n1_M2_42180_143700 0.988200
R18127 n1_M2_42180_143700 n1_M2_43260_143700 0.988200
R18128 n1_M2_43260_143700 n1_M2_44340_143700 0.988200
R18129 n1_M2_44340_143700 n1_M2_45420_143700 0.988200
R18130 n1_M2_45420_143700 n1_M2_46500_143700 0.988200
R18131 n1_M2_46500_143700 n1_M2_47580_143700 0.988200
R18132 n1_M2_47580_143700 n1_M2_48660_143700 0.988200
R18133 n1_M2_48660_143700 n1_M2_49740_143700 0.988200
R18134 n1_M2_49740_143700 n1_M2_50820_143700 0.988200
R18135 n1_M2_50820_143700 n1_M2_51900_143700 0.988200
R18136 n1_M2_51900_143700 n1_M2_52980_143700 0.988200
R18137 n1_M2_52980_143700 n1_M2_54060_143700 0.988200
R18138 n1_M2_54060_143700 n1_M2_55140_143700 0.988200
R18139 n1_M2_55140_143700 n1_M2_56220_143700 0.988200
R18140 n1_M2_56220_143700 n1_M2_57300_143700 0.988200
R18141 n1_M2_57300_143700 n1_M2_58380_143700 0.988200
R18142 n1_M2_58380_143700 n1_M2_59460_143700 0.988200
R18143 n1_M2_59460_143700 n1_M2_60540_143700 0.988200
R18144 n1_M2_60540_143700 n1_M2_61620_143700 0.988200
R18145 n1_M2_61620_143700 n1_M2_62700_143700 0.988200
R18146 n1_M2_62700_143700 n1_M2_63780_143700 0.988200
R18147 n1_M2_63780_143700 n1_M2_64860_143700 0.988200
R18148 n1_M2_64860_143700 n1_M2_65940_143700 0.988200
R18149 n1_M2_65940_143700 n1_M2_67020_143700 0.988200
R18150 n1_M2_67020_143700 n1_M2_68100_143700 0.988200
R18151 n1_M2_68100_143700 n1_M2_69180_143700 0.988200
R18152 n1_M2_69180_143700 n1_M2_70260_143700 0.988200
R18153 n1_M2_70260_143700 n1_M2_71340_143700 0.988200
R18154 n1_M2_71340_143700 n1_M2_72420_143700 0.988200
R18155 n1_M2_72420_143700 n1_M2_73500_143700 0.988200
R18156 n1_M2_73500_143700 n1_M2_74580_143700 0.988200
R18157 n1_M2_74580_143700 n1_M2_75660_143700 0.988200
R18158 n1_M2_75660_143700 n1_M2_76740_143700 0.988200
R18159 n1_M2_76740_143700 n1_M2_77820_143700 0.988200
R18160 n1_M2_77820_143700 n1_M2_78900_143700 0.988200
R18161 n1_M2_78900_143700 n1_M2_79980_143700 0.988200
R18162 n1_M2_79980_143700 n1_M2_81060_143700 0.988200
R18163 n1_M2_81060_143700 n1_M2_82140_143700 0.988200
R18164 n1_M2_82140_143700 n1_M2_83220_143700 0.988200
R18165 n1_M2_83220_143700 n1_M2_84300_143700 0.988200
R18166 n1_M2_84300_143700 n1_M2_85380_143700 0.988200
R18167 n1_M2_85380_143700 n1_M2_86460_143700 0.988200
R18168 n1_M2_86460_143700 n1_M2_87540_143700 0.988200
R18169 n1_M2_87540_143700 n1_M2_88620_143700 0.988200
R18170 n1_M2_88620_143700 n1_M2_89700_143700 0.988200
R18171 n1_M2_89700_143700 n1_M2_90780_143700 0.988200
R18172 n1_M2_90780_143700 n1_M2_91860_143700 0.988200
R18173 n1_M2_91860_143700 n1_M2_92940_143700 0.988200
R18174 n1_M2_92940_143700 n1_M2_94020_143700 0.988200
R18175 n1_M2_94020_143700 n1_M2_95100_143700 0.988200
R18176 n1_M2_95100_143700 n1_M2_96180_143700 0.988200
R18177 n1_M2_96180_143700 n1_M2_97260_143700 0.988200
R18178 n1_M2_97260_143700 n1_M2_98340_143700 0.988200
R18179 n1_M2_98340_143700 n1_M2_99420_143700 0.988200
R18180 n1_M2_99420_143700 n1_M2_100500_143700 0.988200
R18181 n1_M2_100500_143700 n1_M2_101580_143700 0.988200
R18182 n1_M2_101580_143700 n1_M2_102660_143700 0.988200
R18183 n1_M2_102660_143700 n1_M2_103740_143700 0.988200
R18184 n1_M2_103740_143700 n1_M2_104820_143700 0.988200
R18185 n1_M2_104820_143700 n1_M2_105900_143700 0.988200
R18186 n1_M2_105900_143700 n1_M2_106980_143700 0.988200
R18187 n1_M2_106980_143700 n1_M2_108060_143700 0.988200
R18188 n1_M2_108060_143700 n1_M2_109140_143700 0.988200
R18189 n1_M2_109140_143700 n1_M2_110220_143700 0.988200
R18190 n1_M2_110220_143700 n1_M2_111300_143700 0.988200
R18191 n1_M2_111300_143700 n1_M2_112380_143700 0.988200
R18192 n1_M2_112380_143700 n1_M2_113460_143700 0.988200
R18193 n1_M2_113460_143700 n1_M2_114540_143700 0.988200
R18194 n1_M2_114540_143700 n1_M2_115620_143700 0.988200
R18195 n1_M2_115620_143700 n1_M2_116700_143700 0.988200
R18196 n1_M2_116700_143700 n1_M2_117780_143700 0.988200
R18197 n1_M2_117780_143700 n1_M2_118860_143700 0.988200
R18198 n1_M2_118860_143700 n1_M2_119940_143700 0.988200
R18199 n1_M2_119940_143700 n1_M2_121020_143700 0.988200
R18200 n1_M2_121020_143700 n1_M2_122100_143700 0.988200
R18201 n1_M2_122100_143700 n1_M2_123180_143700 0.988200
R18202 n1_M2_123180_143700 n1_M2_124260_143700 0.988200
R18203 n1_M2_124260_143700 n1_M2_125340_143700 0.988200
R18204 n1_M2_125340_143700 n1_M2_126420_143700 0.988200
R18205 n1_M2_126420_143700 n1_M2_127500_143700 0.988200
R18206 n1_M2_127500_143700 n1_M2_128580_143700 0.988200
R18207 n1_M2_128580_143700 n1_M2_129660_143700 0.988200
R18208 n1_M2_129660_143700 n1_M2_130740_143700 0.988200
R18209 n1_M2_130740_143700 n1_M2_131820_143700 0.988200
R18210 n1_M2_131820_143700 n1_M2_132900_143700 0.988200
R18211 n1_M2_132900_143700 n1_M2_133980_143700 0.988200
R18212 n1_M2_133980_143700 n1_M2_135060_143700 0.988200
R18213 n1_M2_135060_143700 n1_M2_136140_143700 0.988200
R18214 n1_M2_136140_143700 n1_M2_137220_143700 0.988200
R18215 n1_M2_137220_143700 n1_M2_138300_143700 0.988200
R18216 n1_M2_138300_143700 n1_M2_139380_143700 0.988200
R18217 n1_M2_139380_143700 n1_M2_140460_143700 0.988200
R18218 n1_M2_140460_143700 n1_M2_141540_143700 0.988200
R18219 n1_M2_141540_143700 n1_M2_142620_143700 0.988200
R18220 n1_M2_142620_143700 n1_M2_143700_143700 0.988200
R18221 n1_M2_143700_143700 n1_M2_144780_143700 0.988200
R18222 n1_M2_144780_143700 n1_M2_145860_143700 0.988200
R18223 n1_M2_145860_143700 n1_M2_146940_143700 0.988200
R18224 n1_M2_60_144780 n1_M2_1140_144780 0.988200
R18225 n1_M2_1140_144780 n1_M2_2220_144780 0.988200
R18226 n1_M2_2220_144780 n1_M2_3300_144780 0.988200
R18227 n1_M2_3300_144780 n1_M2_4380_144780 0.988200
R18228 n1_M2_4380_144780 n1_M2_5460_144780 0.988200
R18229 n1_M2_5460_144780 n1_M2_6540_144780 0.988200
R18230 n1_M2_6540_144780 n1_M2_7620_144780 0.988200
R18231 n1_M2_7620_144780 n1_M2_8700_144780 0.988200
R18232 n1_M2_8700_144780 n1_M2_9780_144780 0.988200
R18233 n1_M2_9780_144780 n1_M2_10860_144780 0.988200
R18234 n1_M2_10860_144780 n1_M2_11940_144780 0.988200
R18235 n1_M2_11940_144780 n1_M2_13020_144780 0.988200
R18236 n1_M2_13020_144780 n1_M2_14100_144780 0.988200
R18237 n1_M2_14100_144780 n1_M2_15180_144780 0.988200
R18238 n1_M2_15180_144780 n1_M2_16260_144780 0.988200
R18239 n1_M2_16260_144780 n1_M2_17340_144780 0.988200
R18240 n1_M2_17340_144780 n1_M2_18420_144780 0.988200
R18241 n1_M2_18420_144780 n1_M2_19500_144780 0.988200
R18242 n1_M2_19500_144780 n1_M2_20580_144780 0.988200
R18243 n1_M2_20580_144780 n1_M2_21660_144780 0.988200
R18244 n1_M2_21660_144780 n1_M2_22740_144780 0.988200
R18245 n1_M2_22740_144780 n1_M2_23820_144780 0.988200
R18246 n1_M2_23820_144780 n1_M2_24900_144780 0.988200
R18247 n1_M2_24900_144780 n1_M2_25980_144780 0.988200
R18248 n1_M2_25980_144780 n1_M2_27060_144780 0.988200
R18249 n1_M2_27060_144780 n1_M2_28140_144780 0.988200
R18250 n1_M2_28140_144780 n1_M2_29220_144780 0.988200
R18251 n1_M2_29220_144780 n1_M2_30300_144780 0.988200
R18252 n1_M2_30300_144780 n1_M2_31380_144780 0.988200
R18253 n1_M2_31380_144780 n1_M2_32460_144780 0.988200
R18254 n1_M2_32460_144780 n1_M2_33540_144780 0.988200
R18255 n1_M2_33540_144780 n1_M2_34620_144780 0.988200
R18256 n1_M2_34620_144780 n1_M2_35700_144780 0.988200
R18257 n1_M2_35700_144780 n1_M2_36780_144780 0.988200
R18258 n1_M2_36780_144780 n1_M2_37860_144780 0.988200
R18259 n1_M2_37860_144780 n1_M2_38940_144780 0.988200
R18260 n1_M2_38940_144780 n1_M2_40020_144780 0.988200
R18261 n1_M2_40020_144780 n1_M2_41100_144780 0.988200
R18262 n1_M2_41100_144780 n1_M2_42180_144780 0.988200
R18263 n1_M2_42180_144780 n1_M2_43260_144780 0.988200
R18264 n1_M2_43260_144780 n1_M2_44340_144780 0.988200
R18265 n1_M2_44340_144780 n1_M2_45420_144780 0.988200
R18266 n1_M2_45420_144780 n1_M2_46500_144780 0.988200
R18267 n1_M2_46500_144780 n1_M2_47580_144780 0.988200
R18268 n1_M2_47580_144780 n1_M2_48660_144780 0.988200
R18269 n1_M2_48660_144780 n1_M2_49740_144780 0.988200
R18270 n1_M2_49740_144780 n1_M2_50820_144780 0.988200
R18271 n1_M2_50820_144780 n1_M2_51900_144780 0.988200
R18272 n1_M2_51900_144780 n1_M2_52980_144780 0.988200
R18273 n1_M2_52980_144780 n1_M2_54060_144780 0.988200
R18274 n1_M2_54060_144780 n1_M2_55140_144780 0.988200
R18275 n1_M2_55140_144780 n1_M2_56220_144780 0.988200
R18276 n1_M2_56220_144780 n1_M2_57300_144780 0.988200
R18277 n1_M2_57300_144780 n1_M2_58380_144780 0.988200
R18278 n1_M2_58380_144780 n1_M2_59460_144780 0.988200
R18279 n1_M2_59460_144780 n1_M2_60540_144780 0.988200
R18280 n1_M2_60540_144780 n1_M2_61620_144780 0.988200
R18281 n1_M2_61620_144780 n1_M2_62700_144780 0.988200
R18282 n1_M2_62700_144780 n1_M2_63780_144780 0.988200
R18283 n1_M2_63780_144780 n1_M2_64860_144780 0.988200
R18284 n1_M2_64860_144780 n1_M2_65940_144780 0.988200
R18285 n1_M2_65940_144780 n1_M2_67020_144780 0.988200
R18286 n1_M2_67020_144780 n1_M2_68100_144780 0.988200
R18287 n1_M2_68100_144780 n1_M2_69180_144780 0.988200
R18288 n1_M2_69180_144780 n1_M2_70260_144780 0.988200
R18289 n1_M2_70260_144780 n1_M2_71340_144780 0.988200
R18290 n1_M2_71340_144780 n1_M2_72420_144780 0.988200
R18291 n1_M2_72420_144780 n1_M2_73500_144780 0.988200
R18292 n1_M2_73500_144780 n1_M2_74580_144780 0.988200
R18293 n1_M2_74580_144780 n1_M2_75660_144780 0.988200
R18294 n1_M2_75660_144780 n1_M2_76740_144780 0.988200
R18295 n1_M2_76740_144780 n1_M2_77820_144780 0.988200
R18296 n1_M2_77820_144780 n1_M2_78900_144780 0.988200
R18297 n1_M2_78900_144780 n1_M2_79980_144780 0.988200
R18298 n1_M2_79980_144780 n1_M2_81060_144780 0.988200
R18299 n1_M2_81060_144780 n1_M2_82140_144780 0.988200
R18300 n1_M2_82140_144780 n1_M2_83220_144780 0.988200
R18301 n1_M2_83220_144780 n1_M2_84300_144780 0.988200
R18302 n1_M2_84300_144780 n1_M2_85380_144780 0.988200
R18303 n1_M2_85380_144780 n1_M2_86460_144780 0.988200
R18304 n1_M2_86460_144780 n1_M2_87540_144780 0.988200
R18305 n1_M2_87540_144780 n1_M2_88620_144780 0.988200
R18306 n1_M2_88620_144780 n1_M2_89700_144780 0.988200
R18307 n1_M2_89700_144780 n1_M2_90780_144780 0.988200
R18308 n1_M2_90780_144780 n1_M2_91860_144780 0.988200
R18309 n1_M2_91860_144780 n1_M2_92940_144780 0.988200
R18310 n1_M2_92940_144780 n1_M2_94020_144780 0.988200
R18311 n1_M2_94020_144780 n1_M2_95100_144780 0.988200
R18312 n1_M2_95100_144780 n1_M2_96180_144780 0.988200
R18313 n1_M2_96180_144780 n1_M2_97260_144780 0.988200
R18314 n1_M2_97260_144780 n1_M2_98340_144780 0.988200
R18315 n1_M2_98340_144780 n1_M2_99420_144780 0.988200
R18316 n1_M2_99420_144780 n1_M2_100500_144780 0.988200
R18317 n1_M2_100500_144780 n1_M2_101580_144780 0.988200
R18318 n1_M2_101580_144780 n1_M2_102660_144780 0.988200
R18319 n1_M2_102660_144780 n1_M2_103740_144780 0.988200
R18320 n1_M2_103740_144780 n1_M2_104820_144780 0.988200
R18321 n1_M2_104820_144780 n1_M2_105900_144780 0.988200
R18322 n1_M2_105900_144780 n1_M2_106980_144780 0.988200
R18323 n1_M2_106980_144780 n1_M2_108060_144780 0.988200
R18324 n1_M2_108060_144780 n1_M2_109140_144780 0.988200
R18325 n1_M2_109140_144780 n1_M2_110220_144780 0.988200
R18326 n1_M2_110220_144780 n1_M2_111300_144780 0.988200
R18327 n1_M2_111300_144780 n1_M2_112380_144780 0.988200
R18328 n1_M2_112380_144780 n1_M2_113460_144780 0.988200
R18329 n1_M2_113460_144780 n1_M2_114540_144780 0.988200
R18330 n1_M2_114540_144780 n1_M2_115620_144780 0.988200
R18331 n1_M2_115620_144780 n1_M2_116700_144780 0.988200
R18332 n1_M2_116700_144780 n1_M2_117780_144780 0.988200
R18333 n1_M2_117780_144780 n1_M2_118860_144780 0.988200
R18334 n1_M2_118860_144780 n1_M2_119940_144780 0.988200
R18335 n1_M2_119940_144780 n1_M2_121020_144780 0.988200
R18336 n1_M2_121020_144780 n1_M2_122100_144780 0.988200
R18337 n1_M2_122100_144780 n1_M2_123180_144780 0.988200
R18338 n1_M2_123180_144780 n1_M2_124260_144780 0.988200
R18339 n1_M2_124260_144780 n1_M2_125340_144780 0.988200
R18340 n1_M2_125340_144780 n1_M2_126420_144780 0.988200
R18341 n1_M2_126420_144780 n1_M2_127500_144780 0.988200
R18342 n1_M2_127500_144780 n1_M2_128580_144780 0.988200
R18343 n1_M2_128580_144780 n1_M2_129660_144780 0.988200
R18344 n1_M2_129660_144780 n1_M2_130740_144780 0.988200
R18345 n1_M2_130740_144780 n1_M2_131820_144780 0.988200
R18346 n1_M2_131820_144780 n1_M2_132900_144780 0.988200
R18347 n1_M2_132900_144780 n1_M2_133980_144780 0.988200
R18348 n1_M2_133980_144780 n1_M2_135060_144780 0.988200
R18349 n1_M2_135060_144780 n1_M2_136140_144780 0.988200
R18350 n1_M2_136140_144780 n1_M2_137220_144780 0.988200
R18351 n1_M2_137220_144780 n1_M2_138300_144780 0.988200
R18352 n1_M2_138300_144780 n1_M2_139380_144780 0.988200
R18353 n1_M2_139380_144780 n1_M2_140460_144780 0.988200
R18354 n1_M2_140460_144780 n1_M2_141540_144780 0.988200
R18355 n1_M2_141540_144780 n1_M2_142620_144780 0.988200
R18356 n1_M2_142620_144780 n1_M2_143700_144780 0.988200
R18357 n1_M2_143700_144780 n1_M2_144780_144780 0.988200
R18358 n1_M2_144780_144780 n1_M2_145860_144780 0.988200
R18359 n1_M2_145860_144780 n1_M2_146940_144780 0.988200
R18360 n1_M2_60_145860 n1_M2_1140_145860 0.988200
R18361 n1_M2_1140_145860 n1_M2_2220_145860 0.988200
R18362 n1_M2_2220_145860 n1_M2_3300_145860 0.988200
R18363 n1_M2_3300_145860 n1_M2_4380_145860 0.988200
R18364 n1_M2_4380_145860 n1_M2_5460_145860 0.988200
R18365 n1_M2_5460_145860 n1_M2_6540_145860 0.988200
R18366 n1_M2_6540_145860 n1_M2_7620_145860 0.988200
R18367 n1_M2_7620_145860 n1_M2_8700_145860 0.988200
R18368 n1_M2_8700_145860 n1_M2_9780_145860 0.988200
R18369 n1_M2_9780_145860 n1_M2_10860_145860 0.988200
R18370 n1_M2_10860_145860 n1_M2_11940_145860 0.988200
R18371 n1_M2_11940_145860 n1_M2_13020_145860 0.988200
R18372 n1_M2_13020_145860 n1_M2_14100_145860 0.988200
R18373 n1_M2_14100_145860 n1_M2_15180_145860 0.988200
R18374 n1_M2_15180_145860 n1_M2_16260_145860 0.988200
R18375 n1_M2_16260_145860 n1_M2_17340_145860 0.988200
R18376 n1_M2_17340_145860 n1_M2_18420_145860 0.988200
R18377 n1_M2_18420_145860 n1_M2_19500_145860 0.988200
R18378 n1_M2_19500_145860 n1_M2_20580_145860 0.988200
R18379 n1_M2_20580_145860 n1_M2_21660_145860 0.988200
R18380 n1_M2_21660_145860 n1_M2_22740_145860 0.988200
R18381 n1_M2_22740_145860 n1_M2_23820_145860 0.988200
R18382 n1_M2_23820_145860 n1_M2_24900_145860 0.988200
R18383 n1_M2_24900_145860 n1_M2_25980_145860 0.988200
R18384 n1_M2_25980_145860 n1_M2_27060_145860 0.988200
R18385 n1_M2_27060_145860 n1_M2_28140_145860 0.988200
R18386 n1_M2_28140_145860 n1_M2_29220_145860 0.988200
R18387 n1_M2_29220_145860 n1_M2_30300_145860 0.988200
R18388 n1_M2_30300_145860 n1_M2_31380_145860 0.988200
R18389 n1_M2_31380_145860 n1_M2_32460_145860 0.988200
R18390 n1_M2_32460_145860 n1_M2_33540_145860 0.988200
R18391 n1_M2_33540_145860 n1_M2_34620_145860 0.988200
R18392 n1_M2_34620_145860 n1_M2_35700_145860 0.988200
R18393 n1_M2_35700_145860 n1_M2_36780_145860 0.988200
R18394 n1_M2_36780_145860 n1_M2_37860_145860 0.988200
R18395 n1_M2_37860_145860 n1_M2_38940_145860 0.988200
R18396 n1_M2_38940_145860 n1_M2_40020_145860 0.988200
R18397 n1_M2_40020_145860 n1_M2_41100_145860 0.988200
R18398 n1_M2_41100_145860 n1_M2_42180_145860 0.988200
R18399 n1_M2_42180_145860 n1_M2_43260_145860 0.988200
R18400 n1_M2_43260_145860 n1_M2_44340_145860 0.988200
R18401 n1_M2_44340_145860 n1_M2_45420_145860 0.988200
R18402 n1_M2_45420_145860 n1_M2_46500_145860 0.988200
R18403 n1_M2_46500_145860 n1_M2_47580_145860 0.988200
R18404 n1_M2_47580_145860 n1_M2_48660_145860 0.988200
R18405 n1_M2_48660_145860 n1_M2_49740_145860 0.988200
R18406 n1_M2_49740_145860 n1_M2_50820_145860 0.988200
R18407 n1_M2_50820_145860 n1_M2_51900_145860 0.988200
R18408 n1_M2_51900_145860 n1_M2_52980_145860 0.988200
R18409 n1_M2_52980_145860 n1_M2_54060_145860 0.988200
R18410 n1_M2_54060_145860 n1_M2_55140_145860 0.988200
R18411 n1_M2_55140_145860 n1_M2_56220_145860 0.988200
R18412 n1_M2_56220_145860 n1_M2_57300_145860 0.988200
R18413 n1_M2_57300_145860 n1_M2_58380_145860 0.988200
R18414 n1_M2_58380_145860 n1_M2_59460_145860 0.988200
R18415 n1_M2_59460_145860 n1_M2_60540_145860 0.988200
R18416 n1_M2_60540_145860 n1_M2_61620_145860 0.988200
R18417 n1_M2_61620_145860 n1_M2_62700_145860 0.988200
R18418 n1_M2_62700_145860 n1_M2_63780_145860 0.988200
R18419 n1_M2_63780_145860 n1_M2_64860_145860 0.988200
R18420 n1_M2_64860_145860 n1_M2_65940_145860 0.988200
R18421 n1_M2_65940_145860 n1_M2_67020_145860 0.988200
R18422 n1_M2_67020_145860 n1_M2_68100_145860 0.988200
R18423 n1_M2_68100_145860 n1_M2_69180_145860 0.988200
R18424 n1_M2_69180_145860 n1_M2_70260_145860 0.988200
R18425 n1_M2_70260_145860 n1_M2_71340_145860 0.988200
R18426 n1_M2_71340_145860 n1_M2_72420_145860 0.988200
R18427 n1_M2_72420_145860 n1_M2_73500_145860 0.988200
R18428 n1_M2_73500_145860 n1_M2_74580_145860 0.988200
R18429 n1_M2_74580_145860 n1_M2_75660_145860 0.988200
R18430 n1_M2_75660_145860 n1_M2_76740_145860 0.988200
R18431 n1_M2_76740_145860 n1_M2_77820_145860 0.988200
R18432 n1_M2_77820_145860 n1_M2_78900_145860 0.988200
R18433 n1_M2_78900_145860 n1_M2_79980_145860 0.988200
R18434 n1_M2_79980_145860 n1_M2_81060_145860 0.988200
R18435 n1_M2_81060_145860 n1_M2_82140_145860 0.988200
R18436 n1_M2_82140_145860 n1_M2_83220_145860 0.988200
R18437 n1_M2_83220_145860 n1_M2_84300_145860 0.988200
R18438 n1_M2_84300_145860 n1_M2_85380_145860 0.988200
R18439 n1_M2_85380_145860 n1_M2_86460_145860 0.988200
R18440 n1_M2_86460_145860 n1_M2_87540_145860 0.988200
R18441 n1_M2_87540_145860 n1_M2_88620_145860 0.988200
R18442 n1_M2_88620_145860 n1_M2_89700_145860 0.988200
R18443 n1_M2_89700_145860 n1_M2_90780_145860 0.988200
R18444 n1_M2_90780_145860 n1_M2_91860_145860 0.988200
R18445 n1_M2_91860_145860 n1_M2_92940_145860 0.988200
R18446 n1_M2_92940_145860 n1_M2_94020_145860 0.988200
R18447 n1_M2_94020_145860 n1_M2_95100_145860 0.988200
R18448 n1_M2_95100_145860 n1_M2_96180_145860 0.988200
R18449 n1_M2_96180_145860 n1_M2_97260_145860 0.988200
R18450 n1_M2_97260_145860 n1_M2_98340_145860 0.988200
R18451 n1_M2_98340_145860 n1_M2_99420_145860 0.988200
R18452 n1_M2_99420_145860 n1_M2_100500_145860 0.988200
R18453 n1_M2_100500_145860 n1_M2_101580_145860 0.988200
R18454 n1_M2_101580_145860 n1_M2_102660_145860 0.988200
R18455 n1_M2_102660_145860 n1_M2_103740_145860 0.988200
R18456 n1_M2_103740_145860 n1_M2_104820_145860 0.988200
R18457 n1_M2_104820_145860 n1_M2_105900_145860 0.988200
R18458 n1_M2_105900_145860 n1_M2_106980_145860 0.988200
R18459 n1_M2_106980_145860 n1_M2_108060_145860 0.988200
R18460 n1_M2_108060_145860 n1_M2_109140_145860 0.988200
R18461 n1_M2_109140_145860 n1_M2_110220_145860 0.988200
R18462 n1_M2_110220_145860 n1_M2_111300_145860 0.988200
R18463 n1_M2_111300_145860 n1_M2_112380_145860 0.988200
R18464 n1_M2_112380_145860 n1_M2_113460_145860 0.988200
R18465 n1_M2_113460_145860 n1_M2_114540_145860 0.988200
R18466 n1_M2_114540_145860 n1_M2_115620_145860 0.988200
R18467 n1_M2_115620_145860 n1_M2_116700_145860 0.988200
R18468 n1_M2_116700_145860 n1_M2_117780_145860 0.988200
R18469 n1_M2_117780_145860 n1_M2_118860_145860 0.988200
R18470 n1_M2_118860_145860 n1_M2_119940_145860 0.988200
R18471 n1_M2_119940_145860 n1_M2_121020_145860 0.988200
R18472 n1_M2_121020_145860 n1_M2_122100_145860 0.988200
R18473 n1_M2_122100_145860 n1_M2_123180_145860 0.988200
R18474 n1_M2_123180_145860 n1_M2_124260_145860 0.988200
R18475 n1_M2_124260_145860 n1_M2_125340_145860 0.988200
R18476 n1_M2_125340_145860 n1_M2_126420_145860 0.988200
R18477 n1_M2_126420_145860 n1_M2_127500_145860 0.988200
R18478 n1_M2_127500_145860 n1_M2_128580_145860 0.988200
R18479 n1_M2_128580_145860 n1_M2_129660_145860 0.988200
R18480 n1_M2_129660_145860 n1_M2_130740_145860 0.988200
R18481 n1_M2_130740_145860 n1_M2_131820_145860 0.988200
R18482 n1_M2_131820_145860 n1_M2_132900_145860 0.988200
R18483 n1_M2_132900_145860 n1_M2_133980_145860 0.988200
R18484 n1_M2_133980_145860 n1_M2_135060_145860 0.988200
R18485 n1_M2_135060_145860 n1_M2_136140_145860 0.988200
R18486 n1_M2_136140_145860 n1_M2_137220_145860 0.988200
R18487 n1_M2_137220_145860 n1_M2_138300_145860 0.988200
R18488 n1_M2_138300_145860 n1_M2_139380_145860 0.988200
R18489 n1_M2_139380_145860 n1_M2_140460_145860 0.988200
R18490 n1_M2_140460_145860 n1_M2_141540_145860 0.988200
R18491 n1_M2_141540_145860 n1_M2_142620_145860 0.988200
R18492 n1_M2_142620_145860 n1_M2_143700_145860 0.988200
R18493 n1_M2_143700_145860 n1_M2_144780_145860 0.988200
R18494 n1_M2_144780_145860 n1_M2_145860_145860 0.988200
R18495 n1_M2_145860_145860 n1_M2_146940_145860 0.988200
R18496 n1_M2_60_146940 n1_M2_1140_146940 0.988200
R18497 n1_M2_1140_146940 n1_M2_2220_146940 0.988200
R18498 n1_M2_2220_146940 n1_M2_3300_146940 0.988200
R18499 n1_M2_3300_146940 n1_M2_4380_146940 0.988200
R18500 n1_M2_4380_146940 n1_M2_5460_146940 0.988200
R18501 n1_M2_5460_146940 n1_M2_6540_146940 0.988200
R18502 n1_M2_6540_146940 n1_M2_7620_146940 0.988200
R18503 n1_M2_7620_146940 n1_M2_8700_146940 0.988200
R18504 n1_M2_8700_146940 n1_M2_9780_146940 0.988200
R18505 n1_M2_9780_146940 n1_M2_10860_146940 0.988200
R18506 n1_M2_10860_146940 n1_M2_11940_146940 0.988200
R18507 n1_M2_11940_146940 n1_M2_13020_146940 0.988200
R18508 n1_M2_13020_146940 n1_M2_14100_146940 0.988200
R18509 n1_M2_14100_146940 n1_M2_15180_146940 0.988200
R18510 n1_M2_15180_146940 n1_M2_16260_146940 0.988200
R18511 n1_M2_16260_146940 n1_M2_17340_146940 0.988200
R18512 n1_M2_17340_146940 n1_M2_18420_146940 0.988200
R18513 n1_M2_18420_146940 n1_M2_19500_146940 0.988200
R18514 n1_M2_19500_146940 n1_M2_20580_146940 0.988200
R18515 n1_M2_20580_146940 n1_M2_21660_146940 0.988200
R18516 n1_M2_21660_146940 n1_M2_22740_146940 0.988200
R18517 n1_M2_22740_146940 n1_M2_23820_146940 0.988200
R18518 n1_M2_23820_146940 n1_M2_24900_146940 0.988200
R18519 n1_M2_24900_146940 n1_M2_25980_146940 0.988200
R18520 n1_M2_25980_146940 n1_M2_27060_146940 0.988200
R18521 n1_M2_27060_146940 n1_M2_28140_146940 0.988200
R18522 n1_M2_28140_146940 n1_M2_29220_146940 0.988200
R18523 n1_M2_29220_146940 n1_M2_30300_146940 0.988200
R18524 n1_M2_30300_146940 n1_M2_31380_146940 0.988200
R18525 n1_M2_31380_146940 n1_M2_32460_146940 0.988200
R18526 n1_M2_32460_146940 n1_M2_33540_146940 0.988200
R18527 n1_M2_33540_146940 n1_M2_34620_146940 0.988200
R18528 n1_M2_34620_146940 n1_M2_35700_146940 0.988200
R18529 n1_M2_35700_146940 n1_M2_36780_146940 0.988200
R18530 n1_M2_36780_146940 n1_M2_37860_146940 0.988200
R18531 n1_M2_37860_146940 n1_M2_38940_146940 0.988200
R18532 n1_M2_38940_146940 n1_M2_40020_146940 0.988200
R18533 n1_M2_40020_146940 n1_M2_41100_146940 0.988200
R18534 n1_M2_41100_146940 n1_M2_42180_146940 0.988200
R18535 n1_M2_42180_146940 n1_M2_43260_146940 0.988200
R18536 n1_M2_43260_146940 n1_M2_44340_146940 0.988200
R18537 n1_M2_44340_146940 n1_M2_45420_146940 0.988200
R18538 n1_M2_45420_146940 n1_M2_46500_146940 0.988200
R18539 n1_M2_46500_146940 n1_M2_47580_146940 0.988200
R18540 n1_M2_47580_146940 n1_M2_48660_146940 0.988200
R18541 n1_M2_48660_146940 n1_M2_49740_146940 0.988200
R18542 n1_M2_49740_146940 n1_M2_50820_146940 0.988200
R18543 n1_M2_50820_146940 n1_M2_51900_146940 0.988200
R18544 n1_M2_51900_146940 n1_M2_52980_146940 0.988200
R18545 n1_M2_52980_146940 n1_M2_54060_146940 0.988200
R18546 n1_M2_54060_146940 n1_M2_55140_146940 0.988200
R18547 n1_M2_55140_146940 n1_M2_56220_146940 0.988200
R18548 n1_M2_56220_146940 n1_M2_57300_146940 0.988200
R18549 n1_M2_57300_146940 n1_M2_58380_146940 0.988200
R18550 n1_M2_58380_146940 n1_M2_59460_146940 0.988200
R18551 n1_M2_59460_146940 n1_M2_60540_146940 0.988200
R18552 n1_M2_60540_146940 n1_M2_61620_146940 0.988200
R18553 n1_M2_61620_146940 n1_M2_62700_146940 0.988200
R18554 n1_M2_62700_146940 n1_M2_63780_146940 0.988200
R18555 n1_M2_63780_146940 n1_M2_64860_146940 0.988200
R18556 n1_M2_64860_146940 n1_M2_65940_146940 0.988200
R18557 n1_M2_65940_146940 n1_M2_67020_146940 0.988200
R18558 n1_M2_67020_146940 n1_M2_68100_146940 0.988200
R18559 n1_M2_68100_146940 n1_M2_69180_146940 0.988200
R18560 n1_M2_69180_146940 n1_M2_70260_146940 0.988200
R18561 n1_M2_70260_146940 n1_M2_71340_146940 0.988200
R18562 n1_M2_71340_146940 n1_M2_72420_146940 0.988200
R18563 n1_M2_72420_146940 n1_M2_73500_146940 0.988200
R18564 n1_M2_73500_146940 n1_M2_74580_146940 0.988200
R18565 n1_M2_74580_146940 n1_M2_75660_146940 0.988200
R18566 n1_M2_75660_146940 n1_M2_76740_146940 0.988200
R18567 n1_M2_76740_146940 n1_M2_77820_146940 0.988200
R18568 n1_M2_77820_146940 n1_M2_78900_146940 0.988200
R18569 n1_M2_78900_146940 n1_M2_79980_146940 0.988200
R18570 n1_M2_79980_146940 n1_M2_81060_146940 0.988200
R18571 n1_M2_81060_146940 n1_M2_82140_146940 0.988200
R18572 n1_M2_82140_146940 n1_M2_83220_146940 0.988200
R18573 n1_M2_83220_146940 n1_M2_84300_146940 0.988200
R18574 n1_M2_84300_146940 n1_M2_85380_146940 0.988200
R18575 n1_M2_85380_146940 n1_M2_86460_146940 0.988200
R18576 n1_M2_86460_146940 n1_M2_87540_146940 0.988200
R18577 n1_M2_87540_146940 n1_M2_88620_146940 0.988200
R18578 n1_M2_88620_146940 n1_M2_89700_146940 0.988200
R18579 n1_M2_89700_146940 n1_M2_90780_146940 0.988200
R18580 n1_M2_90780_146940 n1_M2_91860_146940 0.988200
R18581 n1_M2_91860_146940 n1_M2_92940_146940 0.988200
R18582 n1_M2_92940_146940 n1_M2_94020_146940 0.988200
R18583 n1_M2_94020_146940 n1_M2_95100_146940 0.988200
R18584 n1_M2_95100_146940 n1_M2_96180_146940 0.988200
R18585 n1_M2_96180_146940 n1_M2_97260_146940 0.988200
R18586 n1_M2_97260_146940 n1_M2_98340_146940 0.988200
R18587 n1_M2_98340_146940 n1_M2_99420_146940 0.988200
R18588 n1_M2_99420_146940 n1_M2_100500_146940 0.988200
R18589 n1_M2_100500_146940 n1_M2_101580_146940 0.988200
R18590 n1_M2_101580_146940 n1_M2_102660_146940 0.988200
R18591 n1_M2_102660_146940 n1_M2_103740_146940 0.988200
R18592 n1_M2_103740_146940 n1_M2_104820_146940 0.988200
R18593 n1_M2_104820_146940 n1_M2_105900_146940 0.988200
R18594 n1_M2_105900_146940 n1_M2_106980_146940 0.988200
R18595 n1_M2_106980_146940 n1_M2_108060_146940 0.988200
R18596 n1_M2_108060_146940 n1_M2_109140_146940 0.988200
R18597 n1_M2_109140_146940 n1_M2_110220_146940 0.988200
R18598 n1_M2_110220_146940 n1_M2_111300_146940 0.988200
R18599 n1_M2_111300_146940 n1_M2_112380_146940 0.988200
R18600 n1_M2_112380_146940 n1_M2_113460_146940 0.988200
R18601 n1_M2_113460_146940 n1_M2_114540_146940 0.988200
R18602 n1_M2_114540_146940 n1_M2_115620_146940 0.988200
R18603 n1_M2_115620_146940 n1_M2_116700_146940 0.988200
R18604 n1_M2_116700_146940 n1_M2_117780_146940 0.988200
R18605 n1_M2_117780_146940 n1_M2_118860_146940 0.988200
R18606 n1_M2_118860_146940 n1_M2_119940_146940 0.988200
R18607 n1_M2_119940_146940 n1_M2_121020_146940 0.988200
R18608 n1_M2_121020_146940 n1_M2_122100_146940 0.988200
R18609 n1_M2_122100_146940 n1_M2_123180_146940 0.988200
R18610 n1_M2_123180_146940 n1_M2_124260_146940 0.988200
R18611 n1_M2_124260_146940 n1_M2_125340_146940 0.988200
R18612 n1_M2_125340_146940 n1_M2_126420_146940 0.988200
R18613 n1_M2_126420_146940 n1_M2_127500_146940 0.988200
R18614 n1_M2_127500_146940 n1_M2_128580_146940 0.988200
R18615 n1_M2_128580_146940 n1_M2_129660_146940 0.988200
R18616 n1_M2_129660_146940 n1_M2_130740_146940 0.988200
R18617 n1_M2_130740_146940 n1_M2_131820_146940 0.988200
R18618 n1_M2_131820_146940 n1_M2_132900_146940 0.988200
R18619 n1_M2_132900_146940 n1_M2_133980_146940 0.988200
R18620 n1_M2_133980_146940 n1_M2_135060_146940 0.988200
R18621 n1_M2_135060_146940 n1_M2_136140_146940 0.988200
R18622 n1_M2_136140_146940 n1_M2_137220_146940 0.988200
R18623 n1_M2_137220_146940 n1_M2_138300_146940 0.988200
R18624 n1_M2_138300_146940 n1_M2_139380_146940 0.988200
R18625 n1_M2_139380_146940 n1_M2_140460_146940 0.988200
R18626 n1_M2_140460_146940 n1_M2_141540_146940 0.988200
R18627 n1_M2_141540_146940 n1_M2_142620_146940 0.988200
R18628 n1_M2_142620_146940 n1_M2_143700_146940 0.988200
R18629 n1_M2_143700_146940 n1_M2_144780_146940 0.988200
R18630 n1_M2_144780_146940 n1_M2_145860_146940 0.988200
R18631 n1_M2_145860_146940 n1_M2_146940_146940 0.988200
R18632 n1_M5_60_60 n1_M5_60_1140 0.197640
R18633 n1_M5_60_1140 n1_M5_60_2220 0.197640
R18634 n1_M5_60_2220 n1_M5_60_3300 0.197640
R18635 n1_M5_60_3300 n1_M5_60_4380 0.197640
R18636 n1_M5_60_4380 n1_M5_60_5460 0.197640
R18637 n1_M5_60_5460 n1_M5_60_6540 0.197640
R18638 n1_M5_60_6540 n1_M5_60_7620 0.197640
R18639 n1_M5_60_7620 n1_M5_60_8700 0.197640
R18640 n1_M5_60_8700 n1_M5_60_9780 0.197640
R18641 n1_M5_60_9780 n1_M5_60_10860 0.197640
R18642 n1_M5_60_10860 n1_M5_60_11940 0.197640
R18643 n1_M5_60_11940 n1_M5_60_12060 0.021960
R18644 n1_M5_60_13020 n1_M5_60_12060 0.175680
R18645 n1_M5_60_13020 n1_M5_60_14100 0.197640
R18646 n1_M5_60_14100 n1_M5_60_15180 0.197640
R18647 n1_M5_60_15180 n1_M5_60_16260 0.197640
R18648 n1_M5_60_16260 n1_M5_60_17340 0.197640
R18649 n1_M5_60_17340 n1_M5_60_18420 0.197640
R18650 n1_M5_60_18420 n1_M5_60_19500 0.197640
R18651 n1_M5_60_19500 n1_M5_60_20580 0.197640
R18652 n1_M5_60_20580 n1_M5_60_21660 0.197640
R18653 n1_M5_60_21660 n1_M5_60_22740 0.197640
R18654 n1_M5_60_22740 n1_M5_60_23820 0.197640
R18655 n1_M5_60_23820 n1_M5_60_24060 0.043920
R18656 n1_M5_60_24900 n1_M5_60_24060 0.153720
R18657 n1_M5_60_24900 n1_M5_60_25980 0.197640
R18658 n1_M5_60_25980 n1_M5_60_27060 0.197640
R18659 n1_M5_60_27060 n1_M5_60_28140 0.197640
R18660 n1_M5_60_28140 n1_M5_60_29220 0.197640
R18661 n1_M5_60_29220 n1_M5_60_30300 0.197640
R18662 n1_M5_60_30300 n1_M5_60_31380 0.197640
R18663 n1_M5_60_31380 n1_M5_60_32460 0.197640
R18664 n1_M5_60_32460 n1_M5_60_33540 0.197640
R18665 n1_M5_60_33540 n1_M5_60_34620 0.197640
R18666 n1_M5_60_34620 n1_M5_60_35700 0.197640
R18667 n1_M5_60_35700 n1_M5_60_36060 0.065880
R18668 n1_M5_60_36780 n1_M5_60_36060 0.131760
R18669 n1_M5_60_36780 n1_M5_60_37860 0.197640
R18670 n1_M5_60_37860 n1_M5_60_38940 0.197640
R18671 n1_M5_60_38940 n1_M5_60_40020 0.197640
R18672 n1_M5_60_40020 n1_M5_60_41100 0.197640
R18673 n1_M5_60_41100 n1_M5_60_42180 0.197640
R18674 n1_M5_60_42180 n1_M5_60_43260 0.197640
R18675 n1_M5_60_43260 n1_M5_60_44340 0.197640
R18676 n1_M5_60_44340 n1_M5_60_45420 0.197640
R18677 n1_M5_60_45420 n1_M5_60_46500 0.197640
R18678 n1_M5_60_46500 n1_M5_60_47580 0.197640
R18679 n1_M5_60_47580 n1_M5_60_48060 0.087840
R18680 n1_M5_60_48660 n1_M5_60_48060 0.109800
R18681 n1_M5_60_48660 n1_M5_60_49740 0.197640
R18682 n1_M5_60_49740 n1_M5_60_50820 0.197640
R18683 n1_M5_60_50820 n1_M5_60_51900 0.197640
R18684 n1_M5_60_51900 n1_M5_60_52980 0.197640
R18685 n1_M5_60_52980 n1_M5_60_54060 0.197640
R18686 n1_M5_60_54060 n1_M5_60_55140 0.197640
R18687 n1_M5_60_55140 n1_M5_60_56220 0.197640
R18688 n1_M5_60_56220 n1_M5_60_57300 0.197640
R18689 n1_M5_60_57300 n1_M5_60_58380 0.197640
R18690 n1_M5_60_58380 n1_M5_60_59460 0.197640
R18691 n1_M5_60_59460 n1_M5_60_60060 0.109800
R18692 n1_M5_60_60540 n1_M5_60_60060 0.087840
R18693 n1_M5_60_60540 n1_M5_60_61620 0.197640
R18694 n1_M5_60_61620 n1_M5_60_62700 0.197640
R18695 n1_M5_60_62700 n1_M5_60_63780 0.197640
R18696 n1_M5_60_63780 n1_M5_60_64860 0.197640
R18697 n1_M5_60_64860 n1_M5_60_65940 0.197640
R18698 n1_M5_60_65940 n1_M5_60_67020 0.197640
R18699 n1_M5_60_67020 n1_M5_60_68100 0.197640
R18700 n1_M5_60_68100 n1_M5_60_69180 0.197640
R18701 n1_M5_60_69180 n1_M5_60_70260 0.197640
R18702 n1_M5_60_70260 n1_M5_60_71340 0.197640
R18703 n1_M5_60_71340 n1_M5_60_72060 0.131760
R18704 n1_M5_60_72420 n1_M5_60_72060 0.065880
R18705 n1_M5_60_72420 n1_M5_60_73500 0.197640
R18706 n1_M5_60_73500 n1_M5_60_74580 0.197640
R18707 n1_M5_60_74580 n1_M5_60_75660 0.197640
R18708 n1_M5_60_75660 n1_M5_60_76740 0.197640
R18709 n1_M5_60_76740 n1_M5_60_77820 0.197640
R18710 n1_M5_60_77820 n1_M5_60_78900 0.197640
R18711 n1_M5_60_78900 n1_M5_60_79980 0.197640
R18712 n1_M5_60_79980 n1_M5_60_81060 0.197640
R18713 n1_M5_60_81060 n1_M5_60_82140 0.197640
R18714 n1_M5_60_82140 n1_M5_60_83220 0.197640
R18715 n1_M5_60_83220 n1_M5_60_84060 0.153720
R18716 n1_M5_60_84300 n1_M5_60_84060 0.043920
R18717 n1_M5_60_84300 n1_M5_60_85380 0.197640
R18718 n1_M5_60_85380 n1_M5_60_86460 0.197640
R18719 n1_M5_60_86460 n1_M5_60_87540 0.197640
R18720 n1_M5_60_87540 n1_M5_60_88620 0.197640
R18721 n1_M5_60_88620 n1_M5_60_89700 0.197640
R18722 n1_M5_60_89700 n1_M5_60_90780 0.197640
R18723 n1_M5_60_90780 n1_M5_60_91860 0.197640
R18724 n1_M5_60_91860 n1_M5_60_92940 0.197640
R18725 n1_M5_60_92940 n1_M5_60_94020 0.197640
R18726 n1_M5_60_94020 n1_M5_60_95100 0.197640
R18727 n1_M5_60_95100 n1_M5_60_96060 0.175680
R18728 n1_M5_60_96180 n1_M5_60_96060 0.021960
R18729 n1_M5_60_96180 n1_M5_60_97260 0.197640
R18730 n1_M5_60_97260 n1_M5_60_98340 0.197640
R18731 n1_M5_60_98340 n1_M5_60_99420 0.197640
R18732 n1_M5_60_99420 n1_M5_60_100500 0.197640
R18733 n1_M5_60_100500 n1_M5_60_101580 0.197640
R18734 n1_M5_60_101580 n1_M5_60_102660 0.197640
R18735 n1_M5_60_102660 n1_M5_60_103740 0.197640
R18736 n1_M5_60_103740 n1_M5_60_104820 0.197640
R18737 n1_M5_60_104820 n1_M5_60_105900 0.197640
R18738 n1_M5_60_105900 n1_M5_60_106980 0.197640
R18739 n1_M5_60_106980 n1_M5_60_108060 0.197640
R18740 n1_M5_60_108060 n1_M5_60_109140 0.197640
R18741 n1_M5_60_109140 n1_M5_60_110220 0.197640
R18742 n1_M5_60_110220 n1_M5_60_111300 0.197640
R18743 n1_M5_60_111300 n1_M5_60_112380 0.197640
R18744 n1_M5_60_112380 n1_M5_60_113460 0.197640
R18745 n1_M5_60_113460 n1_M5_60_114540 0.197640
R18746 n1_M5_60_114540 n1_M5_60_115620 0.197640
R18747 n1_M5_60_115620 n1_M5_60_116700 0.197640
R18748 n1_M5_60_116700 n1_M5_60_117780 0.197640
R18749 n1_M5_60_117780 n1_M5_60_118860 0.197640
R18750 n1_M5_60_118860 n1_M5_60_119940 0.197640
R18751 n1_M5_60_119940 n1_M5_60_120060 0.021960
R18752 n1_M5_60_121020 n1_M5_60_120060 0.175680
R18753 n1_M5_60_121020 n1_M5_60_122100 0.197640
R18754 n1_M5_60_122100 n1_M5_60_123180 0.197640
R18755 n1_M5_60_123180 n1_M5_60_124260 0.197640
R18756 n1_M5_60_124260 n1_M5_60_125340 0.197640
R18757 n1_M5_60_125340 n1_M5_60_126420 0.197640
R18758 n1_M5_60_126420 n1_M5_60_127500 0.197640
R18759 n1_M5_60_127500 n1_M5_60_128580 0.197640
R18760 n1_M5_60_128580 n1_M5_60_129660 0.197640
R18761 n1_M5_60_129660 n1_M5_60_130740 0.197640
R18762 n1_M5_60_130740 n1_M5_60_131820 0.197640
R18763 n1_M5_60_131820 n1_M5_60_132060 0.043920
R18764 n1_M5_60_132900 n1_M5_60_132060 0.153720
R18765 n1_M5_60_132900 n1_M5_60_133980 0.197640
R18766 n1_M5_60_133980 n1_M5_60_135060 0.197640
R18767 n1_M5_60_135060 n1_M5_60_136140 0.197640
R18768 n1_M5_60_136140 n1_M5_60_137220 0.197640
R18769 n1_M5_60_137220 n1_M5_60_138300 0.197640
R18770 n1_M5_60_138300 n1_M5_60_139380 0.197640
R18771 n1_M5_60_139380 n1_M5_60_140460 0.197640
R18772 n1_M5_60_140460 n1_M5_60_141540 0.197640
R18773 n1_M5_60_141540 n1_M5_60_142620 0.197640
R18774 n1_M5_60_142620 n1_M5_60_143700 0.197640
R18775 n1_M5_60_143700 n1_M5_60_144060 0.065880
R18776 n1_M5_60_144780 n1_M5_60_144060 0.131760
R18777 n1_M5_60_144780 n1_M5_60_145860 0.197640
R18778 n1_M5_60_145860 n1_M5_60_146940 0.197640
R18779 n1_M5_24060_60 n1_M5_24060_1140 0.197640
R18780 n1_M5_24060_1140 n1_M5_24060_2220 0.197640
R18781 n1_M5_24060_2220 n1_M5_24060_3300 0.197640
R18782 n1_M5_24060_3300 n1_M5_24060_4380 0.197640
R18783 n1_M5_24060_4380 n1_M5_24060_5460 0.197640
R18784 n1_M5_24060_5460 n1_M5_24060_6540 0.197640
R18785 n1_M5_24060_6540 n1_M5_24060_7620 0.197640
R18786 n1_M5_24060_7620 n1_M5_24060_8700 0.197640
R18787 n1_M5_24060_8700 n1_M5_24060_9780 0.197640
R18788 n1_M5_24060_9780 n1_M5_24060_10860 0.197640
R18789 n1_M5_24060_10860 n1_M5_24060_11940 0.197640
R18790 n1_M5_24060_11940 n1_M5_24060_12060 0.021960
R18791 n1_M5_24060_13020 n1_M5_24060_12060 0.175680
R18792 n1_M5_24060_13020 n1_M5_24060_14100 0.197640
R18793 n1_M5_24060_14100 n1_M5_24060_15180 0.197640
R18794 n1_M5_24060_15180 n1_M5_24060_16260 0.197640
R18795 n1_M5_24060_16260 n1_M5_24060_17340 0.197640
R18796 n1_M5_24060_17340 n1_M5_24060_18420 0.197640
R18797 n1_M5_24060_18420 n1_M5_24060_19500 0.197640
R18798 n1_M5_24060_19500 n1_M5_24060_20580 0.197640
R18799 n1_M5_24060_20580 n1_M5_24060_21660 0.197640
R18800 n1_M5_24060_21660 n1_M5_24060_22740 0.197640
R18801 n1_M5_24060_22740 n1_M5_24060_23820 0.197640
R18802 n1_M5_24060_23820 n1_M5_24060_24060 0.043920
R18803 n1_M5_24060_24900 n1_M5_24060_24060 0.153720
R18804 n1_M5_24060_24900 n1_M5_24060_25980 0.197640
R18805 n1_M5_24060_25980 n1_M5_24060_27060 0.197640
R18806 n1_M5_24060_27060 n1_M5_24060_28140 0.197640
R18807 n1_M5_24060_28140 n1_M5_24060_29220 0.197640
R18808 n1_M5_24060_29220 n1_M5_24060_30300 0.197640
R18809 n1_M5_24060_30300 n1_M5_24060_31380 0.197640
R18810 n1_M5_24060_31380 n1_M5_24060_32460 0.197640
R18811 n1_M5_24060_32460 n1_M5_24060_33540 0.197640
R18812 n1_M5_24060_33540 n1_M5_24060_34620 0.197640
R18813 n1_M5_24060_34620 n1_M5_24060_35700 0.197640
R18814 n1_M5_24060_35700 n1_M5_24060_36060 0.065880
R18815 n1_M5_24060_36780 n1_M5_24060_36060 0.131760
R18816 n1_M5_24060_36780 n1_M5_24060_37860 0.197640
R18817 n1_M5_24060_37860 n1_M5_24060_38940 0.197640
R18818 n1_M5_24060_38940 n1_M5_24060_40020 0.197640
R18819 n1_M5_24060_40020 n1_M5_24060_41100 0.197640
R18820 n1_M5_24060_41100 n1_M5_24060_42180 0.197640
R18821 n1_M5_24060_42180 n1_M5_24060_43260 0.197640
R18822 n1_M5_24060_43260 n1_M5_24060_44340 0.197640
R18823 n1_M5_24060_44340 n1_M5_24060_45420 0.197640
R18824 n1_M5_24060_45420 n1_M5_24060_46500 0.197640
R18825 n1_M5_24060_46500 n1_M5_24060_47580 0.197640
R18826 n1_M5_24060_47580 n1_M5_24060_48060 0.087840
R18827 n1_M5_24060_48660 n1_M5_24060_48060 0.109800
R18828 n1_M5_24060_48660 n1_M5_24060_49740 0.197640
R18829 n1_M5_24060_49740 n1_M5_24060_50820 0.197640
R18830 n1_M5_24060_50820 n1_M5_24060_51900 0.197640
R18831 n1_M5_24060_51900 n1_M5_24060_52980 0.197640
R18832 n1_M5_24060_52980 n1_M5_24060_54060 0.197640
R18833 n1_M5_24060_54060 n1_M5_24060_55140 0.197640
R18834 n1_M5_24060_55140 n1_M5_24060_56220 0.197640
R18835 n1_M5_24060_56220 n1_M5_24060_57300 0.197640
R18836 n1_M5_24060_57300 n1_M5_24060_58380 0.197640
R18837 n1_M5_24060_58380 n1_M5_24060_59460 0.197640
R18838 n1_M5_24060_59460 n1_M5_24060_60060 0.109800
R18839 n1_M5_24060_60540 n1_M5_24060_60060 0.087840
R18840 n1_M5_24060_60540 n1_M5_24060_61620 0.197640
R18841 n1_M5_24060_61620 n1_M5_24060_62700 0.197640
R18842 n1_M5_24060_62700 n1_M5_24060_63780 0.197640
R18843 n1_M5_24060_63780 n1_M5_24060_64860 0.197640
R18844 n1_M5_24060_64860 n1_M5_24060_65940 0.197640
R18845 n1_M5_24060_65940 n1_M5_24060_67020 0.197640
R18846 n1_M5_24060_67020 n1_M5_24060_68100 0.197640
R18847 n1_M5_24060_68100 n1_M5_24060_69180 0.197640
R18848 n1_M5_24060_69180 n1_M5_24060_70260 0.197640
R18849 n1_M5_24060_70260 n1_M5_24060_71340 0.197640
R18850 n1_M5_24060_71340 n1_M5_24060_72060 0.131760
R18851 n1_M5_24060_72420 n1_M5_24060_72060 0.065880
R18852 n1_M5_24060_72420 n1_M5_24060_73500 0.197640
R18853 n1_M5_24060_73500 n1_M5_24060_74580 0.197640
R18854 n1_M5_24060_74580 n1_M5_24060_75660 0.197640
R18855 n1_M5_24060_75660 n1_M5_24060_76740 0.197640
R18856 n1_M5_24060_76740 n1_M5_24060_77820 0.197640
R18857 n1_M5_24060_77820 n1_M5_24060_78900 0.197640
R18858 n1_M5_24060_78900 n1_M5_24060_79980 0.197640
R18859 n1_M5_24060_79980 n1_M5_24060_81060 0.197640
R18860 n1_M5_24060_81060 n1_M5_24060_82140 0.197640
R18861 n1_M5_24060_82140 n1_M5_24060_83220 0.197640
R18862 n1_M5_24060_83220 n1_M5_24060_84060 0.153720
R18863 n1_M5_24060_84300 n1_M5_24060_84060 0.043920
R18864 n1_M5_24060_84300 n1_M5_24060_85380 0.197640
R18865 n1_M5_24060_85380 n1_M5_24060_86460 0.197640
R18866 n1_M5_24060_86460 n1_M5_24060_87540 0.197640
R18867 n1_M5_24060_87540 n1_M5_24060_88620 0.197640
R18868 n1_M5_24060_88620 n1_M5_24060_89700 0.197640
R18869 n1_M5_24060_89700 n1_M5_24060_90780 0.197640
R18870 n1_M5_24060_90780 n1_M5_24060_91860 0.197640
R18871 n1_M5_24060_91860 n1_M5_24060_92940 0.197640
R18872 n1_M5_24060_92940 n1_M5_24060_94020 0.197640
R18873 n1_M5_24060_94020 n1_M5_24060_95100 0.197640
R18874 n1_M5_24060_95100 n1_M5_24060_96060 0.175680
R18875 n1_M5_24060_96180 n1_M5_24060_96060 0.021960
R18876 n1_M5_24060_96180 n1_M5_24060_97260 0.197640
R18877 n1_M5_24060_97260 n1_M5_24060_98340 0.197640
R18878 n1_M5_24060_98340 n1_M5_24060_99420 0.197640
R18879 n1_M5_24060_99420 n1_M5_24060_100500 0.197640
R18880 n1_M5_24060_100500 n1_M5_24060_101580 0.197640
R18881 n1_M5_24060_101580 n1_M5_24060_102660 0.197640
R18882 n1_M5_24060_102660 n1_M5_24060_103740 0.197640
R18883 n1_M5_24060_103740 n1_M5_24060_104820 0.197640
R18884 n1_M5_24060_104820 n1_M5_24060_105900 0.197640
R18885 n1_M5_24060_105900 n1_M5_24060_106980 0.197640
R18886 n1_M5_24060_106980 n1_M5_24060_108060 0.197640
R18887 n1_M5_24060_108060 n1_M5_24060_109140 0.197640
R18888 n1_M5_24060_109140 n1_M5_24060_110220 0.197640
R18889 n1_M5_24060_110220 n1_M5_24060_111300 0.197640
R18890 n1_M5_24060_111300 n1_M5_24060_112380 0.197640
R18891 n1_M5_24060_112380 n1_M5_24060_113460 0.197640
R18892 n1_M5_24060_113460 n1_M5_24060_114540 0.197640
R18893 n1_M5_24060_114540 n1_M5_24060_115620 0.197640
R18894 n1_M5_24060_115620 n1_M5_24060_116700 0.197640
R18895 n1_M5_24060_116700 n1_M5_24060_117780 0.197640
R18896 n1_M5_24060_117780 n1_M5_24060_118860 0.197640
R18897 n1_M5_24060_118860 n1_M5_24060_119940 0.197640
R18898 n1_M5_24060_119940 n1_M5_24060_120060 0.021960
R18899 n1_M5_24060_121020 n1_M5_24060_120060 0.175680
R18900 n1_M5_24060_121020 n1_M5_24060_122100 0.197640
R18901 n1_M5_24060_122100 n1_M5_24060_123180 0.197640
R18902 n1_M5_24060_123180 n1_M5_24060_124260 0.197640
R18903 n1_M5_24060_124260 n1_M5_24060_125340 0.197640
R18904 n1_M5_24060_125340 n1_M5_24060_126420 0.197640
R18905 n1_M5_24060_126420 n1_M5_24060_127500 0.197640
R18906 n1_M5_24060_127500 n1_M5_24060_128580 0.197640
R18907 n1_M5_24060_128580 n1_M5_24060_129660 0.197640
R18908 n1_M5_24060_129660 n1_M5_24060_130740 0.197640
R18909 n1_M5_24060_130740 n1_M5_24060_131820 0.197640
R18910 n1_M5_24060_131820 n1_M5_24060_132060 0.043920
R18911 n1_M5_24060_132900 n1_M5_24060_132060 0.153720
R18912 n1_M5_24060_132900 n1_M5_24060_133980 0.197640
R18913 n1_M5_24060_133980 n1_M5_24060_135060 0.197640
R18914 n1_M5_24060_135060 n1_M5_24060_136140 0.197640
R18915 n1_M5_24060_136140 n1_M5_24060_137220 0.197640
R18916 n1_M5_24060_137220 n1_M5_24060_138300 0.197640
R18917 n1_M5_24060_138300 n1_M5_24060_139380 0.197640
R18918 n1_M5_24060_139380 n1_M5_24060_140460 0.197640
R18919 n1_M5_24060_140460 n1_M5_24060_141540 0.197640
R18920 n1_M5_24060_141540 n1_M5_24060_142620 0.197640
R18921 n1_M5_24060_142620 n1_M5_24060_143700 0.197640
R18922 n1_M5_24060_143700 n1_M5_24060_144060 0.065880
R18923 n1_M5_24060_144780 n1_M5_24060_144060 0.131760
R18924 n1_M5_24060_144780 n1_M5_24060_145860 0.197640
R18925 n1_M5_24060_145860 n1_M5_24060_146940 0.197640
R18926 n1_M5_48060_60 n1_M5_48060_1140 0.197640
R18927 n1_M5_48060_1140 n1_M5_48060_2220 0.197640
R18928 n1_M5_48060_2220 n1_M5_48060_3300 0.197640
R18929 n1_M5_48060_3300 n1_M5_48060_4380 0.197640
R18930 n1_M5_48060_4380 n1_M5_48060_5460 0.197640
R18931 n1_M5_48060_5460 n1_M5_48060_6540 0.197640
R18932 n1_M5_48060_6540 n1_M5_48060_7620 0.197640
R18933 n1_M5_48060_7620 n1_M5_48060_8700 0.197640
R18934 n1_M5_48060_8700 n1_M5_48060_9780 0.197640
R18935 n1_M5_48060_9780 n1_M5_48060_10860 0.197640
R18936 n1_M5_48060_10860 n1_M5_48060_11940 0.197640
R18937 n1_M5_48060_11940 n1_M5_48060_12060 0.021960
R18938 n1_M5_48060_13020 n1_M5_48060_12060 0.175680
R18939 n1_M5_48060_13020 n1_M5_48060_14100 0.197640
R18940 n1_M5_48060_14100 n1_M5_48060_15180 0.197640
R18941 n1_M5_48060_15180 n1_M5_48060_16260 0.197640
R18942 n1_M5_48060_16260 n1_M5_48060_17340 0.197640
R18943 n1_M5_48060_17340 n1_M5_48060_18420 0.197640
R18944 n1_M5_48060_18420 n1_M5_48060_19500 0.197640
R18945 n1_M5_48060_19500 n1_M5_48060_20580 0.197640
R18946 n1_M5_48060_20580 n1_M5_48060_21660 0.197640
R18947 n1_M5_48060_21660 n1_M5_48060_22740 0.197640
R18948 n1_M5_48060_22740 n1_M5_48060_23820 0.197640
R18949 n1_M5_48060_23820 n1_M5_48060_24060 0.043920
R18950 n1_M5_48060_24900 n1_M5_48060_24060 0.153720
R18951 n1_M5_48060_24900 n1_M5_48060_25980 0.197640
R18952 n1_M5_48060_25980 n1_M5_48060_27060 0.197640
R18953 n1_M5_48060_27060 n1_M5_48060_28140 0.197640
R18954 n1_M5_48060_28140 n1_M5_48060_29220 0.197640
R18955 n1_M5_48060_29220 n1_M5_48060_30300 0.197640
R18956 n1_M5_48060_30300 n1_M5_48060_31380 0.197640
R18957 n1_M5_48060_31380 n1_M5_48060_32460 0.197640
R18958 n1_M5_48060_32460 n1_M5_48060_33540 0.197640
R18959 n1_M5_48060_33540 n1_M5_48060_34620 0.197640
R18960 n1_M5_48060_34620 n1_M5_48060_35700 0.197640
R18961 n1_M5_48060_35700 n1_M5_48060_36060 0.065880
R18962 n1_M5_48060_36780 n1_M5_48060_36060 0.131760
R18963 n1_M5_48060_36780 n1_M5_48060_37860 0.197640
R18964 n1_M5_48060_37860 n1_M5_48060_38940 0.197640
R18965 n1_M5_48060_38940 n1_M5_48060_40020 0.197640
R18966 n1_M5_48060_40020 n1_M5_48060_41100 0.197640
R18967 n1_M5_48060_41100 n1_M5_48060_42180 0.197640
R18968 n1_M5_48060_42180 n1_M5_48060_43260 0.197640
R18969 n1_M5_48060_43260 n1_M5_48060_44340 0.197640
R18970 n1_M5_48060_44340 n1_M5_48060_45420 0.197640
R18971 n1_M5_48060_45420 n1_M5_48060_46500 0.197640
R18972 n1_M5_48060_46500 n1_M5_48060_47580 0.197640
R18973 n1_M5_48060_47580 n1_M5_48060_48060 0.087840
R18974 n1_M5_48060_48660 n1_M5_48060_48060 0.109800
R18975 n1_M5_48060_48660 n1_M5_48060_49740 0.197640
R18976 n1_M5_48060_49740 n1_M5_48060_50820 0.197640
R18977 n1_M5_48060_50820 n1_M5_48060_51900 0.197640
R18978 n1_M5_48060_51900 n1_M5_48060_52980 0.197640
R18979 n1_M5_48060_52980 n1_M5_48060_54060 0.197640
R18980 n1_M5_48060_54060 n1_M5_48060_55140 0.197640
R18981 n1_M5_48060_55140 n1_M5_48060_56220 0.197640
R18982 n1_M5_48060_56220 n1_M5_48060_57300 0.197640
R18983 n1_M5_48060_57300 n1_M5_48060_58380 0.197640
R18984 n1_M5_48060_58380 n1_M5_48060_59460 0.197640
R18985 n1_M5_48060_59460 n1_M5_48060_60060 0.109800
R18986 n1_M5_48060_60540 n1_M5_48060_60060 0.087840
R18987 n1_M5_48060_60540 n1_M5_48060_61620 0.197640
R18988 n1_M5_48060_61620 n1_M5_48060_62700 0.197640
R18989 n1_M5_48060_62700 n1_M5_48060_63780 0.197640
R18990 n1_M5_48060_63780 n1_M5_48060_64860 0.197640
R18991 n1_M5_48060_64860 n1_M5_48060_65940 0.197640
R18992 n1_M5_48060_65940 n1_M5_48060_67020 0.197640
R18993 n1_M5_48060_67020 n1_M5_48060_68100 0.197640
R18994 n1_M5_48060_68100 n1_M5_48060_69180 0.197640
R18995 n1_M5_48060_69180 n1_M5_48060_70260 0.197640
R18996 n1_M5_48060_70260 n1_M5_48060_71340 0.197640
R18997 n1_M5_48060_71340 n1_M5_48060_72060 0.131760
R18998 n1_M5_48060_72420 n1_M5_48060_72060 0.065880
R18999 n1_M5_48060_72420 n1_M5_48060_73500 0.197640
R19000 n1_M5_48060_73500 n1_M5_48060_74580 0.197640
R19001 n1_M5_48060_74580 n1_M5_48060_75660 0.197640
R19002 n1_M5_48060_75660 n1_M5_48060_76740 0.197640
R19003 n1_M5_48060_76740 n1_M5_48060_77820 0.197640
R19004 n1_M5_48060_77820 n1_M5_48060_78900 0.197640
R19005 n1_M5_48060_78900 n1_M5_48060_79980 0.197640
R19006 n1_M5_48060_79980 n1_M5_48060_81060 0.197640
R19007 n1_M5_48060_81060 n1_M5_48060_82140 0.197640
R19008 n1_M5_48060_82140 n1_M5_48060_83220 0.197640
R19009 n1_M5_48060_83220 n1_M5_48060_84060 0.153720
R19010 n1_M5_48060_84300 n1_M5_48060_84060 0.043920
R19011 n1_M5_48060_84300 n1_M5_48060_85380 0.197640
R19012 n1_M5_48060_85380 n1_M5_48060_86460 0.197640
R19013 n1_M5_48060_86460 n1_M5_48060_87540 0.197640
R19014 n1_M5_48060_87540 n1_M5_48060_88620 0.197640
R19015 n1_M5_48060_88620 n1_M5_48060_89700 0.197640
R19016 n1_M5_48060_89700 n1_M5_48060_90780 0.197640
R19017 n1_M5_48060_90780 n1_M5_48060_91860 0.197640
R19018 n1_M5_48060_91860 n1_M5_48060_92940 0.197640
R19019 n1_M5_48060_92940 n1_M5_48060_94020 0.197640
R19020 n1_M5_48060_94020 n1_M5_48060_95100 0.197640
R19021 n1_M5_48060_95100 n1_M5_48060_96060 0.175680
R19022 n1_M5_48060_96180 n1_M5_48060_96060 0.021960
R19023 n1_M5_48060_96180 n1_M5_48060_97260 0.197640
R19024 n1_M5_48060_97260 n1_M5_48060_98340 0.197640
R19025 n1_M5_48060_98340 n1_M5_48060_99420 0.197640
R19026 n1_M5_48060_99420 n1_M5_48060_100500 0.197640
R19027 n1_M5_48060_100500 n1_M5_48060_101580 0.197640
R19028 n1_M5_48060_101580 n1_M5_48060_102660 0.197640
R19029 n1_M5_48060_102660 n1_M5_48060_103740 0.197640
R19030 n1_M5_48060_103740 n1_M5_48060_104820 0.197640
R19031 n1_M5_48060_104820 n1_M5_48060_105900 0.197640
R19032 n1_M5_48060_105900 n1_M5_48060_106980 0.197640
R19033 n1_M5_48060_106980 n1_M5_48060_108060 0.197640
R19034 n1_M5_48060_108060 n1_M5_48060_109140 0.197640
R19035 n1_M5_48060_109140 n1_M5_48060_110220 0.197640
R19036 n1_M5_48060_110220 n1_M5_48060_111300 0.197640
R19037 n1_M5_48060_111300 n1_M5_48060_112380 0.197640
R19038 n1_M5_48060_112380 n1_M5_48060_113460 0.197640
R19039 n1_M5_48060_113460 n1_M5_48060_114540 0.197640
R19040 n1_M5_48060_114540 n1_M5_48060_115620 0.197640
R19041 n1_M5_48060_115620 n1_M5_48060_116700 0.197640
R19042 n1_M5_48060_116700 n1_M5_48060_117780 0.197640
R19043 n1_M5_48060_117780 n1_M5_48060_118860 0.197640
R19044 n1_M5_48060_118860 n1_M5_48060_119940 0.197640
R19045 n1_M5_48060_119940 n1_M5_48060_120060 0.021960
R19046 n1_M5_48060_121020 n1_M5_48060_120060 0.175680
R19047 n1_M5_48060_121020 n1_M5_48060_122100 0.197640
R19048 n1_M5_48060_122100 n1_M5_48060_123180 0.197640
R19049 n1_M5_48060_123180 n1_M5_48060_124260 0.197640
R19050 n1_M5_48060_124260 n1_M5_48060_125340 0.197640
R19051 n1_M5_48060_125340 n1_M5_48060_126420 0.197640
R19052 n1_M5_48060_126420 n1_M5_48060_127500 0.197640
R19053 n1_M5_48060_127500 n1_M5_48060_128580 0.197640
R19054 n1_M5_48060_128580 n1_M5_48060_129660 0.197640
R19055 n1_M5_48060_129660 n1_M5_48060_130740 0.197640
R19056 n1_M5_48060_130740 n1_M5_48060_131820 0.197640
R19057 n1_M5_48060_131820 n1_M5_48060_132060 0.043920
R19058 n1_M5_48060_132900 n1_M5_48060_132060 0.153720
R19059 n1_M5_48060_132900 n1_M5_48060_133980 0.197640
R19060 n1_M5_48060_133980 n1_M5_48060_135060 0.197640
R19061 n1_M5_48060_135060 n1_M5_48060_136140 0.197640
R19062 n1_M5_48060_136140 n1_M5_48060_137220 0.197640
R19063 n1_M5_48060_137220 n1_M5_48060_138300 0.197640
R19064 n1_M5_48060_138300 n1_M5_48060_139380 0.197640
R19065 n1_M5_48060_139380 n1_M5_48060_140460 0.197640
R19066 n1_M5_48060_140460 n1_M5_48060_141540 0.197640
R19067 n1_M5_48060_141540 n1_M5_48060_142620 0.197640
R19068 n1_M5_48060_142620 n1_M5_48060_143700 0.197640
R19069 n1_M5_48060_143700 n1_M5_48060_144060 0.065880
R19070 n1_M5_48060_144780 n1_M5_48060_144060 0.131760
R19071 n1_M5_48060_144780 n1_M5_48060_145860 0.197640
R19072 n1_M5_48060_145860 n1_M5_48060_146940 0.197640
R19073 n1_M5_72060_60 n1_M5_72060_1140 0.197640
R19074 n1_M5_72060_1140 n1_M5_72060_2220 0.197640
R19075 n1_M5_72060_2220 n1_M5_72060_3300 0.197640
R19076 n1_M5_72060_3300 n1_M5_72060_4380 0.197640
R19077 n1_M5_72060_4380 n1_M5_72060_5460 0.197640
R19078 n1_M5_72060_5460 n1_M5_72060_6540 0.197640
R19079 n1_M5_72060_6540 n1_M5_72060_7620 0.197640
R19080 n1_M5_72060_7620 n1_M5_72060_8700 0.197640
R19081 n1_M5_72060_8700 n1_M5_72060_9780 0.197640
R19082 n1_M5_72060_9780 n1_M5_72060_10860 0.197640
R19083 n1_M5_72060_10860 n1_M5_72060_11940 0.197640
R19084 n1_M5_72060_11940 n1_M5_72060_12060 0.021960
R19085 n1_M5_72060_13020 n1_M5_72060_12060 0.175680
R19086 n1_M5_72060_13020 n1_M5_72060_14100 0.197640
R19087 n1_M5_72060_14100 n1_M5_72060_15180 0.197640
R19088 n1_M5_72060_15180 n1_M5_72060_16260 0.197640
R19089 n1_M5_72060_16260 n1_M5_72060_17340 0.197640
R19090 n1_M5_72060_17340 n1_M5_72060_18420 0.197640
R19091 n1_M5_72060_18420 n1_M5_72060_19500 0.197640
R19092 n1_M5_72060_19500 n1_M5_72060_20580 0.197640
R19093 n1_M5_72060_20580 n1_M5_72060_21660 0.197640
R19094 n1_M5_72060_21660 n1_M5_72060_22740 0.197640
R19095 n1_M5_72060_22740 n1_M5_72060_23820 0.197640
R19096 n1_M5_72060_23820 n1_M5_72060_24060 0.043920
R19097 n1_M5_72060_24900 n1_M5_72060_24060 0.153720
R19098 n1_M5_72060_24900 n1_M5_72060_25980 0.197640
R19099 n1_M5_72060_25980 n1_M5_72060_27060 0.197640
R19100 n1_M5_72060_27060 n1_M5_72060_28140 0.197640
R19101 n1_M5_72060_28140 n1_M5_72060_29220 0.197640
R19102 n1_M5_72060_29220 n1_M5_72060_30300 0.197640
R19103 n1_M5_72060_30300 n1_M5_72060_31380 0.197640
R19104 n1_M5_72060_31380 n1_M5_72060_32460 0.197640
R19105 n1_M5_72060_32460 n1_M5_72060_33540 0.197640
R19106 n1_M5_72060_33540 n1_M5_72060_34620 0.197640
R19107 n1_M5_72060_34620 n1_M5_72060_35700 0.197640
R19108 n1_M5_72060_35700 n1_M5_72060_36060 0.065880
R19109 n1_M5_72060_36780 n1_M5_72060_36060 0.131760
R19110 n1_M5_72060_36780 n1_M5_72060_37860 0.197640
R19111 n1_M5_72060_37860 n1_M5_72060_38940 0.197640
R19112 n1_M5_72060_38940 n1_M5_72060_40020 0.197640
R19113 n1_M5_72060_40020 n1_M5_72060_41100 0.197640
R19114 n1_M5_72060_41100 n1_M5_72060_42180 0.197640
R19115 n1_M5_72060_42180 n1_M5_72060_43260 0.197640
R19116 n1_M5_72060_43260 n1_M5_72060_44340 0.197640
R19117 n1_M5_72060_44340 n1_M5_72060_45420 0.197640
R19118 n1_M5_72060_45420 n1_M5_72060_46500 0.197640
R19119 n1_M5_72060_46500 n1_M5_72060_47580 0.197640
R19120 n1_M5_72060_47580 n1_M5_72060_48060 0.087840
R19121 n1_M5_72060_48660 n1_M5_72060_48060 0.109800
R19122 n1_M5_72060_48660 n1_M5_72060_49740 0.197640
R19123 n1_M5_72060_49740 n1_M5_72060_50820 0.197640
R19124 n1_M5_72060_50820 n1_M5_72060_51900 0.197640
R19125 n1_M5_72060_51900 n1_M5_72060_52980 0.197640
R19126 n1_M5_72060_52980 n1_M5_72060_54060 0.197640
R19127 n1_M5_72060_54060 n1_M5_72060_55140 0.197640
R19128 n1_M5_72060_55140 n1_M5_72060_56220 0.197640
R19129 n1_M5_72060_56220 n1_M5_72060_57300 0.197640
R19130 n1_M5_72060_57300 n1_M5_72060_58380 0.197640
R19131 n1_M5_72060_58380 n1_M5_72060_59460 0.197640
R19132 n1_M5_72060_59460 n1_M5_72060_60060 0.109800
R19133 n1_M5_72060_60540 n1_M5_72060_60060 0.087840
R19134 n1_M5_72060_60540 n1_M5_72060_61620 0.197640
R19135 n1_M5_72060_61620 n1_M5_72060_62700 0.197640
R19136 n1_M5_72060_62700 n1_M5_72060_63780 0.197640
R19137 n1_M5_72060_63780 n1_M5_72060_64860 0.197640
R19138 n1_M5_72060_64860 n1_M5_72060_65940 0.197640
R19139 n1_M5_72060_65940 n1_M5_72060_67020 0.197640
R19140 n1_M5_72060_67020 n1_M5_72060_68100 0.197640
R19141 n1_M5_72060_68100 n1_M5_72060_69180 0.197640
R19142 n1_M5_72060_69180 n1_M5_72060_70260 0.197640
R19143 n1_M5_72060_70260 n1_M5_72060_71340 0.197640
R19144 n1_M5_72060_71340 n1_M5_72060_72060 0.131760
R19145 n1_M5_72060_72420 n1_M5_72060_72060 0.065880
R19146 n1_M5_72060_72420 n1_M5_72060_73500 0.197640
R19147 n1_M5_72060_73500 n1_M5_72060_74580 0.197640
R19148 n1_M5_72060_74580 n1_M5_72060_75660 0.197640
R19149 n1_M5_72060_75660 n1_M5_72060_76740 0.197640
R19150 n1_M5_72060_76740 n1_M5_72060_77820 0.197640
R19151 n1_M5_72060_77820 n1_M5_72060_78900 0.197640
R19152 n1_M5_72060_78900 n1_M5_72060_79980 0.197640
R19153 n1_M5_72060_79980 n1_M5_72060_81060 0.197640
R19154 n1_M5_72060_81060 n1_M5_72060_82140 0.197640
R19155 n1_M5_72060_82140 n1_M5_72060_83220 0.197640
R19156 n1_M5_72060_83220 n1_M5_72060_84060 0.153720
R19157 n1_M5_72060_84300 n1_M5_72060_84060 0.043920
R19158 n1_M5_72060_84300 n1_M5_72060_85380 0.197640
R19159 n1_M5_72060_85380 n1_M5_72060_86460 0.197640
R19160 n1_M5_72060_86460 n1_M5_72060_87540 0.197640
R19161 n1_M5_72060_87540 n1_M5_72060_88620 0.197640
R19162 n1_M5_72060_88620 n1_M5_72060_89700 0.197640
R19163 n1_M5_72060_89700 n1_M5_72060_90780 0.197640
R19164 n1_M5_72060_90780 n1_M5_72060_91860 0.197640
R19165 n1_M5_72060_91860 n1_M5_72060_92940 0.197640
R19166 n1_M5_72060_92940 n1_M5_72060_94020 0.197640
R19167 n1_M5_72060_94020 n1_M5_72060_95100 0.197640
R19168 n1_M5_72060_95100 n1_M5_72060_96060 0.175680
R19169 n1_M5_72060_96180 n1_M5_72060_96060 0.021960
R19170 n1_M5_72060_96180 n1_M5_72060_97260 0.197640
R19171 n1_M5_72060_97260 n1_M5_72060_98340 0.197640
R19172 n1_M5_72060_98340 n1_M5_72060_99420 0.197640
R19173 n1_M5_72060_99420 n1_M5_72060_100500 0.197640
R19174 n1_M5_72060_100500 n1_M5_72060_101580 0.197640
R19175 n1_M5_72060_101580 n1_M5_72060_102660 0.197640
R19176 n1_M5_72060_102660 n1_M5_72060_103740 0.197640
R19177 n1_M5_72060_103740 n1_M5_72060_104820 0.197640
R19178 n1_M5_72060_104820 n1_M5_72060_105900 0.197640
R19179 n1_M5_72060_105900 n1_M5_72060_106980 0.197640
R19180 n1_M5_72060_106980 n1_M5_72060_108060 0.197640
R19181 n1_M5_72060_108060 n1_M5_72060_109140 0.197640
R19182 n1_M5_72060_109140 n1_M5_72060_110220 0.197640
R19183 n1_M5_72060_110220 n1_M5_72060_111300 0.197640
R19184 n1_M5_72060_111300 n1_M5_72060_112380 0.197640
R19185 n1_M5_72060_112380 n1_M5_72060_113460 0.197640
R19186 n1_M5_72060_113460 n1_M5_72060_114540 0.197640
R19187 n1_M5_72060_114540 n1_M5_72060_115620 0.197640
R19188 n1_M5_72060_115620 n1_M5_72060_116700 0.197640
R19189 n1_M5_72060_116700 n1_M5_72060_117780 0.197640
R19190 n1_M5_72060_117780 n1_M5_72060_118860 0.197640
R19191 n1_M5_72060_118860 n1_M5_72060_119940 0.197640
R19192 n1_M5_72060_119940 n1_M5_72060_120060 0.021960
R19193 n1_M5_72060_121020 n1_M5_72060_120060 0.175680
R19194 n1_M5_72060_121020 n1_M5_72060_122100 0.197640
R19195 n1_M5_72060_122100 n1_M5_72060_123180 0.197640
R19196 n1_M5_72060_123180 n1_M5_72060_124260 0.197640
R19197 n1_M5_72060_124260 n1_M5_72060_125340 0.197640
R19198 n1_M5_72060_125340 n1_M5_72060_126420 0.197640
R19199 n1_M5_72060_126420 n1_M5_72060_127500 0.197640
R19200 n1_M5_72060_127500 n1_M5_72060_128580 0.197640
R19201 n1_M5_72060_128580 n1_M5_72060_129660 0.197640
R19202 n1_M5_72060_129660 n1_M5_72060_130740 0.197640
R19203 n1_M5_72060_130740 n1_M5_72060_131820 0.197640
R19204 n1_M5_72060_131820 n1_M5_72060_132060 0.043920
R19205 n1_M5_72060_132900 n1_M5_72060_132060 0.153720
R19206 n1_M5_72060_132900 n1_M5_72060_133980 0.197640
R19207 n1_M5_72060_133980 n1_M5_72060_135060 0.197640
R19208 n1_M5_72060_135060 n1_M5_72060_136140 0.197640
R19209 n1_M5_72060_136140 n1_M5_72060_137220 0.197640
R19210 n1_M5_72060_137220 n1_M5_72060_138300 0.197640
R19211 n1_M5_72060_138300 n1_M5_72060_139380 0.197640
R19212 n1_M5_72060_139380 n1_M5_72060_140460 0.197640
R19213 n1_M5_72060_140460 n1_M5_72060_141540 0.197640
R19214 n1_M5_72060_141540 n1_M5_72060_142620 0.197640
R19215 n1_M5_72060_142620 n1_M5_72060_143700 0.197640
R19216 n1_M5_72060_143700 n1_M5_72060_144060 0.065880
R19217 n1_M5_72060_144780 n1_M5_72060_144060 0.131760
R19218 n1_M5_72060_144780 n1_M5_72060_145860 0.197640
R19219 n1_M5_72060_145860 n1_M5_72060_146940 0.197640
R19220 n1_M5_96060_60 n1_M5_96060_1140 0.197640
R19221 n1_M5_96060_1140 n1_M5_96060_2220 0.197640
R19222 n1_M5_96060_2220 n1_M5_96060_3300 0.197640
R19223 n1_M5_96060_3300 n1_M5_96060_4380 0.197640
R19224 n1_M5_96060_4380 n1_M5_96060_5460 0.197640
R19225 n1_M5_96060_5460 n1_M5_96060_6540 0.197640
R19226 n1_M5_96060_6540 n1_M5_96060_7620 0.197640
R19227 n1_M5_96060_7620 n1_M5_96060_8700 0.197640
R19228 n1_M5_96060_8700 n1_M5_96060_9780 0.197640
R19229 n1_M5_96060_9780 n1_M5_96060_10860 0.197640
R19230 n1_M5_96060_10860 n1_M5_96060_11940 0.197640
R19231 n1_M5_96060_11940 n1_M5_96060_12060 0.021960
R19232 n1_M5_96060_13020 n1_M5_96060_12060 0.175680
R19233 n1_M5_96060_13020 n1_M5_96060_14100 0.197640
R19234 n1_M5_96060_14100 n1_M5_96060_15180 0.197640
R19235 n1_M5_96060_15180 n1_M5_96060_16260 0.197640
R19236 n1_M5_96060_16260 n1_M5_96060_17340 0.197640
R19237 n1_M5_96060_17340 n1_M5_96060_18420 0.197640
R19238 n1_M5_96060_18420 n1_M5_96060_19500 0.197640
R19239 n1_M5_96060_19500 n1_M5_96060_20580 0.197640
R19240 n1_M5_96060_20580 n1_M5_96060_21660 0.197640
R19241 n1_M5_96060_21660 n1_M5_96060_22740 0.197640
R19242 n1_M5_96060_22740 n1_M5_96060_23820 0.197640
R19243 n1_M5_96060_23820 n1_M5_96060_24060 0.043920
R19244 n1_M5_96060_24900 n1_M5_96060_24060 0.153720
R19245 n1_M5_96060_24900 n1_M5_96060_25980 0.197640
R19246 n1_M5_96060_25980 n1_M5_96060_27060 0.197640
R19247 n1_M5_96060_27060 n1_M5_96060_28140 0.197640
R19248 n1_M5_96060_28140 n1_M5_96060_29220 0.197640
R19249 n1_M5_96060_29220 n1_M5_96060_30300 0.197640
R19250 n1_M5_96060_30300 n1_M5_96060_31380 0.197640
R19251 n1_M5_96060_31380 n1_M5_96060_32460 0.197640
R19252 n1_M5_96060_32460 n1_M5_96060_33540 0.197640
R19253 n1_M5_96060_33540 n1_M5_96060_34620 0.197640
R19254 n1_M5_96060_34620 n1_M5_96060_35700 0.197640
R19255 n1_M5_96060_35700 n1_M5_96060_36060 0.065880
R19256 n1_M5_96060_36780 n1_M5_96060_36060 0.131760
R19257 n1_M5_96060_36780 n1_M5_96060_37860 0.197640
R19258 n1_M5_96060_37860 n1_M5_96060_38940 0.197640
R19259 n1_M5_96060_38940 n1_M5_96060_40020 0.197640
R19260 n1_M5_96060_40020 n1_M5_96060_41100 0.197640
R19261 n1_M5_96060_41100 n1_M5_96060_42180 0.197640
R19262 n1_M5_96060_42180 n1_M5_96060_43260 0.197640
R19263 n1_M5_96060_43260 n1_M5_96060_44340 0.197640
R19264 n1_M5_96060_44340 n1_M5_96060_45420 0.197640
R19265 n1_M5_96060_45420 n1_M5_96060_46500 0.197640
R19266 n1_M5_96060_46500 n1_M5_96060_47580 0.197640
R19267 n1_M5_96060_47580 n1_M5_96060_48060 0.087840
R19268 n1_M5_96060_48660 n1_M5_96060_48060 0.109800
R19269 n1_M5_96060_48660 n1_M5_96060_49740 0.197640
R19270 n1_M5_96060_49740 n1_M5_96060_50820 0.197640
R19271 n1_M5_96060_50820 n1_M5_96060_51900 0.197640
R19272 n1_M5_96060_51900 n1_M5_96060_52980 0.197640
R19273 n1_M5_96060_52980 n1_M5_96060_54060 0.197640
R19274 n1_M5_96060_54060 n1_M5_96060_55140 0.197640
R19275 n1_M5_96060_55140 n1_M5_96060_56220 0.197640
R19276 n1_M5_96060_56220 n1_M5_96060_57300 0.197640
R19277 n1_M5_96060_57300 n1_M5_96060_58380 0.197640
R19278 n1_M5_96060_58380 n1_M5_96060_59460 0.197640
R19279 n1_M5_96060_59460 n1_M5_96060_60060 0.109800
R19280 n1_M5_96060_60540 n1_M5_96060_60060 0.087840
R19281 n1_M5_96060_60540 n1_M5_96060_61620 0.197640
R19282 n1_M5_96060_61620 n1_M5_96060_62700 0.197640
R19283 n1_M5_96060_62700 n1_M5_96060_63780 0.197640
R19284 n1_M5_96060_63780 n1_M5_96060_64860 0.197640
R19285 n1_M5_96060_64860 n1_M5_96060_65940 0.197640
R19286 n1_M5_96060_65940 n1_M5_96060_67020 0.197640
R19287 n1_M5_96060_67020 n1_M5_96060_68100 0.197640
R19288 n1_M5_96060_68100 n1_M5_96060_69180 0.197640
R19289 n1_M5_96060_69180 n1_M5_96060_70260 0.197640
R19290 n1_M5_96060_70260 n1_M5_96060_71340 0.197640
R19291 n1_M5_96060_71340 n1_M5_96060_72060 0.131760
R19292 n1_M5_96060_72420 n1_M5_96060_72060 0.065880
R19293 n1_M5_96060_72420 n1_M5_96060_73500 0.197640
R19294 n1_M5_96060_73500 n1_M5_96060_74580 0.197640
R19295 n1_M5_96060_74580 n1_M5_96060_75660 0.197640
R19296 n1_M5_96060_75660 n1_M5_96060_76740 0.197640
R19297 n1_M5_96060_76740 n1_M5_96060_77820 0.197640
R19298 n1_M5_96060_77820 n1_M5_96060_78900 0.197640
R19299 n1_M5_96060_78900 n1_M5_96060_79980 0.197640
R19300 n1_M5_96060_79980 n1_M5_96060_81060 0.197640
R19301 n1_M5_96060_81060 n1_M5_96060_82140 0.197640
R19302 n1_M5_96060_82140 n1_M5_96060_83220 0.197640
R19303 n1_M5_96060_83220 n1_M5_96060_84060 0.153720
R19304 n1_M5_96060_84300 n1_M5_96060_84060 0.043920
R19305 n1_M5_96060_84300 n1_M5_96060_85380 0.197640
R19306 n1_M5_96060_85380 n1_M5_96060_86460 0.197640
R19307 n1_M5_96060_86460 n1_M5_96060_87540 0.197640
R19308 n1_M5_96060_87540 n1_M5_96060_88620 0.197640
R19309 n1_M5_96060_88620 n1_M5_96060_89700 0.197640
R19310 n1_M5_96060_89700 n1_M5_96060_90780 0.197640
R19311 n1_M5_96060_90780 n1_M5_96060_91860 0.197640
R19312 n1_M5_96060_91860 n1_M5_96060_92940 0.197640
R19313 n1_M5_96060_92940 n1_M5_96060_94020 0.197640
R19314 n1_M5_96060_94020 n1_M5_96060_95100 0.197640
R19315 n1_M5_96060_95100 n1_M5_96060_96060 0.175680
R19316 n1_M5_96060_96180 n1_M5_96060_96060 0.021960
R19317 n1_M5_96060_96180 n1_M5_96060_97260 0.197640
R19318 n1_M5_96060_97260 n1_M5_96060_98340 0.197640
R19319 n1_M5_96060_98340 n1_M5_96060_99420 0.197640
R19320 n1_M5_96060_99420 n1_M5_96060_100500 0.197640
R19321 n1_M5_96060_100500 n1_M5_96060_101580 0.197640
R19322 n1_M5_96060_101580 n1_M5_96060_102660 0.197640
R19323 n1_M5_96060_102660 n1_M5_96060_103740 0.197640
R19324 n1_M5_96060_103740 n1_M5_96060_104820 0.197640
R19325 n1_M5_96060_104820 n1_M5_96060_105900 0.197640
R19326 n1_M5_96060_105900 n1_M5_96060_106980 0.197640
R19327 n1_M5_96060_106980 n1_M5_96060_108060 0.197640
R19328 n1_M5_96060_108060 n1_M5_96060_109140 0.197640
R19329 n1_M5_96060_109140 n1_M5_96060_110220 0.197640
R19330 n1_M5_96060_110220 n1_M5_96060_111300 0.197640
R19331 n1_M5_96060_111300 n1_M5_96060_112380 0.197640
R19332 n1_M5_96060_112380 n1_M5_96060_113460 0.197640
R19333 n1_M5_96060_113460 n1_M5_96060_114540 0.197640
R19334 n1_M5_96060_114540 n1_M5_96060_115620 0.197640
R19335 n1_M5_96060_115620 n1_M5_96060_116700 0.197640
R19336 n1_M5_96060_116700 n1_M5_96060_117780 0.197640
R19337 n1_M5_96060_117780 n1_M5_96060_118860 0.197640
R19338 n1_M5_96060_118860 n1_M5_96060_119940 0.197640
R19339 n1_M5_96060_119940 n1_M5_96060_120060 0.021960
R19340 n1_M5_96060_121020 n1_M5_96060_120060 0.175680
R19341 n1_M5_96060_121020 n1_M5_96060_122100 0.197640
R19342 n1_M5_96060_122100 n1_M5_96060_123180 0.197640
R19343 n1_M5_96060_123180 n1_M5_96060_124260 0.197640
R19344 n1_M5_96060_124260 n1_M5_96060_125340 0.197640
R19345 n1_M5_96060_125340 n1_M5_96060_126420 0.197640
R19346 n1_M5_96060_126420 n1_M5_96060_127500 0.197640
R19347 n1_M5_96060_127500 n1_M5_96060_128580 0.197640
R19348 n1_M5_96060_128580 n1_M5_96060_129660 0.197640
R19349 n1_M5_96060_129660 n1_M5_96060_130740 0.197640
R19350 n1_M5_96060_130740 n1_M5_96060_131820 0.197640
R19351 n1_M5_96060_131820 n1_M5_96060_132060 0.043920
R19352 n1_M5_96060_132900 n1_M5_96060_132060 0.153720
R19353 n1_M5_96060_132900 n1_M5_96060_133980 0.197640
R19354 n1_M5_96060_133980 n1_M5_96060_135060 0.197640
R19355 n1_M5_96060_135060 n1_M5_96060_136140 0.197640
R19356 n1_M5_96060_136140 n1_M5_96060_137220 0.197640
R19357 n1_M5_96060_137220 n1_M5_96060_138300 0.197640
R19358 n1_M5_96060_138300 n1_M5_96060_139380 0.197640
R19359 n1_M5_96060_139380 n1_M5_96060_140460 0.197640
R19360 n1_M5_96060_140460 n1_M5_96060_141540 0.197640
R19361 n1_M5_96060_141540 n1_M5_96060_142620 0.197640
R19362 n1_M5_96060_142620 n1_M5_96060_143700 0.197640
R19363 n1_M5_96060_143700 n1_M5_96060_144060 0.065880
R19364 n1_M5_96060_144780 n1_M5_96060_144060 0.131760
R19365 n1_M5_96060_144780 n1_M5_96060_145860 0.197640
R19366 n1_M5_96060_145860 n1_M5_96060_146940 0.197640
R19367 n1_M5_120060_60 n1_M5_120060_1140 0.197640
R19368 n1_M5_120060_1140 n1_M5_120060_2220 0.197640
R19369 n1_M5_120060_2220 n1_M5_120060_3300 0.197640
R19370 n1_M5_120060_3300 n1_M5_120060_4380 0.197640
R19371 n1_M5_120060_4380 n1_M5_120060_5460 0.197640
R19372 n1_M5_120060_5460 n1_M5_120060_6540 0.197640
R19373 n1_M5_120060_6540 n1_M5_120060_7620 0.197640
R19374 n1_M5_120060_7620 n1_M5_120060_8700 0.197640
R19375 n1_M5_120060_8700 n1_M5_120060_9780 0.197640
R19376 n1_M5_120060_9780 n1_M5_120060_10860 0.197640
R19377 n1_M5_120060_10860 n1_M5_120060_11940 0.197640
R19378 n1_M5_120060_11940 n1_M5_120060_12060 0.021960
R19379 n1_M5_120060_13020 n1_M5_120060_12060 0.175680
R19380 n1_M5_120060_13020 n1_M5_120060_14100 0.197640
R19381 n1_M5_120060_14100 n1_M5_120060_15180 0.197640
R19382 n1_M5_120060_15180 n1_M5_120060_16260 0.197640
R19383 n1_M5_120060_16260 n1_M5_120060_17340 0.197640
R19384 n1_M5_120060_17340 n1_M5_120060_18420 0.197640
R19385 n1_M5_120060_18420 n1_M5_120060_19500 0.197640
R19386 n1_M5_120060_19500 n1_M5_120060_20580 0.197640
R19387 n1_M5_120060_20580 n1_M5_120060_21660 0.197640
R19388 n1_M5_120060_21660 n1_M5_120060_22740 0.197640
R19389 n1_M5_120060_22740 n1_M5_120060_23820 0.197640
R19390 n1_M5_120060_23820 n1_M5_120060_24060 0.043920
R19391 n1_M5_120060_24900 n1_M5_120060_24060 0.153720
R19392 n1_M5_120060_24900 n1_M5_120060_25980 0.197640
R19393 n1_M5_120060_25980 n1_M5_120060_27060 0.197640
R19394 n1_M5_120060_27060 n1_M5_120060_28140 0.197640
R19395 n1_M5_120060_28140 n1_M5_120060_29220 0.197640
R19396 n1_M5_120060_29220 n1_M5_120060_30300 0.197640
R19397 n1_M5_120060_30300 n1_M5_120060_31380 0.197640
R19398 n1_M5_120060_31380 n1_M5_120060_32460 0.197640
R19399 n1_M5_120060_32460 n1_M5_120060_33540 0.197640
R19400 n1_M5_120060_33540 n1_M5_120060_34620 0.197640
R19401 n1_M5_120060_34620 n1_M5_120060_35700 0.197640
R19402 n1_M5_120060_35700 n1_M5_120060_36060 0.065880
R19403 n1_M5_120060_36780 n1_M5_120060_36060 0.131760
R19404 n1_M5_120060_36780 n1_M5_120060_37860 0.197640
R19405 n1_M5_120060_37860 n1_M5_120060_38940 0.197640
R19406 n1_M5_120060_38940 n1_M5_120060_40020 0.197640
R19407 n1_M5_120060_40020 n1_M5_120060_41100 0.197640
R19408 n1_M5_120060_41100 n1_M5_120060_42180 0.197640
R19409 n1_M5_120060_42180 n1_M5_120060_43260 0.197640
R19410 n1_M5_120060_43260 n1_M5_120060_44340 0.197640
R19411 n1_M5_120060_44340 n1_M5_120060_45420 0.197640
R19412 n1_M5_120060_45420 n1_M5_120060_46500 0.197640
R19413 n1_M5_120060_46500 n1_M5_120060_47580 0.197640
R19414 n1_M5_120060_47580 n1_M5_120060_48060 0.087840
R19415 n1_M5_120060_48660 n1_M5_120060_48060 0.109800
R19416 n1_M5_120060_48660 n1_M5_120060_49740 0.197640
R19417 n1_M5_120060_49740 n1_M5_120060_50820 0.197640
R19418 n1_M5_120060_50820 n1_M5_120060_51900 0.197640
R19419 n1_M5_120060_51900 n1_M5_120060_52980 0.197640
R19420 n1_M5_120060_52980 n1_M5_120060_54060 0.197640
R19421 n1_M5_120060_54060 n1_M5_120060_55140 0.197640
R19422 n1_M5_120060_55140 n1_M5_120060_56220 0.197640
R19423 n1_M5_120060_56220 n1_M5_120060_57300 0.197640
R19424 n1_M5_120060_57300 n1_M5_120060_58380 0.197640
R19425 n1_M5_120060_58380 n1_M5_120060_59460 0.197640
R19426 n1_M5_120060_59460 n1_M5_120060_60060 0.109800
R19427 n1_M5_120060_60540 n1_M5_120060_60060 0.087840
R19428 n1_M5_120060_60540 n1_M5_120060_61620 0.197640
R19429 n1_M5_120060_61620 n1_M5_120060_62700 0.197640
R19430 n1_M5_120060_62700 n1_M5_120060_63780 0.197640
R19431 n1_M5_120060_63780 n1_M5_120060_64860 0.197640
R19432 n1_M5_120060_64860 n1_M5_120060_65940 0.197640
R19433 n1_M5_120060_65940 n1_M5_120060_67020 0.197640
R19434 n1_M5_120060_67020 n1_M5_120060_68100 0.197640
R19435 n1_M5_120060_68100 n1_M5_120060_69180 0.197640
R19436 n1_M5_120060_69180 n1_M5_120060_70260 0.197640
R19437 n1_M5_120060_70260 n1_M5_120060_71340 0.197640
R19438 n1_M5_120060_71340 n1_M5_120060_72060 0.131760
R19439 n1_M5_120060_72420 n1_M5_120060_72060 0.065880
R19440 n1_M5_120060_72420 n1_M5_120060_73500 0.197640
R19441 n1_M5_120060_73500 n1_M5_120060_74580 0.197640
R19442 n1_M5_120060_74580 n1_M5_120060_75660 0.197640
R19443 n1_M5_120060_75660 n1_M5_120060_76740 0.197640
R19444 n1_M5_120060_76740 n1_M5_120060_77820 0.197640
R19445 n1_M5_120060_77820 n1_M5_120060_78900 0.197640
R19446 n1_M5_120060_78900 n1_M5_120060_79980 0.197640
R19447 n1_M5_120060_79980 n1_M5_120060_81060 0.197640
R19448 n1_M5_120060_81060 n1_M5_120060_82140 0.197640
R19449 n1_M5_120060_82140 n1_M5_120060_83220 0.197640
R19450 n1_M5_120060_83220 n1_M5_120060_84060 0.153720
R19451 n1_M5_120060_84300 n1_M5_120060_84060 0.043920
R19452 n1_M5_120060_84300 n1_M5_120060_85380 0.197640
R19453 n1_M5_120060_85380 n1_M5_120060_86460 0.197640
R19454 n1_M5_120060_86460 n1_M5_120060_87540 0.197640
R19455 n1_M5_120060_87540 n1_M5_120060_88620 0.197640
R19456 n1_M5_120060_88620 n1_M5_120060_89700 0.197640
R19457 n1_M5_120060_89700 n1_M5_120060_90780 0.197640
R19458 n1_M5_120060_90780 n1_M5_120060_91860 0.197640
R19459 n1_M5_120060_91860 n1_M5_120060_92940 0.197640
R19460 n1_M5_120060_92940 n1_M5_120060_94020 0.197640
R19461 n1_M5_120060_94020 n1_M5_120060_95100 0.197640
R19462 n1_M5_120060_95100 n1_M5_120060_96060 0.175680
R19463 n1_M5_120060_96180 n1_M5_120060_96060 0.021960
R19464 n1_M5_120060_96180 n1_M5_120060_97260 0.197640
R19465 n1_M5_120060_97260 n1_M5_120060_98340 0.197640
R19466 n1_M5_120060_98340 n1_M5_120060_99420 0.197640
R19467 n1_M5_120060_99420 n1_M5_120060_100500 0.197640
R19468 n1_M5_120060_100500 n1_M5_120060_101580 0.197640
R19469 n1_M5_120060_101580 n1_M5_120060_102660 0.197640
R19470 n1_M5_120060_102660 n1_M5_120060_103740 0.197640
R19471 n1_M5_120060_103740 n1_M5_120060_104820 0.197640
R19472 n1_M5_120060_104820 n1_M5_120060_105900 0.197640
R19473 n1_M5_120060_105900 n1_M5_120060_106980 0.197640
R19474 n1_M5_120060_106980 n1_M5_120060_108060 0.197640
R19475 n1_M5_120060_108060 n1_M5_120060_109140 0.197640
R19476 n1_M5_120060_109140 n1_M5_120060_110220 0.197640
R19477 n1_M5_120060_110220 n1_M5_120060_111300 0.197640
R19478 n1_M5_120060_111300 n1_M5_120060_112380 0.197640
R19479 n1_M5_120060_112380 n1_M5_120060_113460 0.197640
R19480 n1_M5_120060_113460 n1_M5_120060_114540 0.197640
R19481 n1_M5_120060_114540 n1_M5_120060_115620 0.197640
R19482 n1_M5_120060_115620 n1_M5_120060_116700 0.197640
R19483 n1_M5_120060_116700 n1_M5_120060_117780 0.197640
R19484 n1_M5_120060_117780 n1_M5_120060_118860 0.197640
R19485 n1_M5_120060_118860 n1_M5_120060_119940 0.197640
R19486 n1_M5_120060_119940 n1_M5_120060_120060 0.021960
R19487 n1_M5_120060_121020 n1_M5_120060_120060 0.175680
R19488 n1_M5_120060_121020 n1_M5_120060_122100 0.197640
R19489 n1_M5_120060_122100 n1_M5_120060_123180 0.197640
R19490 n1_M5_120060_123180 n1_M5_120060_124260 0.197640
R19491 n1_M5_120060_124260 n1_M5_120060_125340 0.197640
R19492 n1_M5_120060_125340 n1_M5_120060_126420 0.197640
R19493 n1_M5_120060_126420 n1_M5_120060_127500 0.197640
R19494 n1_M5_120060_127500 n1_M5_120060_128580 0.197640
R19495 n1_M5_120060_128580 n1_M5_120060_129660 0.197640
R19496 n1_M5_120060_129660 n1_M5_120060_130740 0.197640
R19497 n1_M5_120060_130740 n1_M5_120060_131820 0.197640
R19498 n1_M5_120060_131820 n1_M5_120060_132060 0.043920
R19499 n1_M5_120060_132900 n1_M5_120060_132060 0.153720
R19500 n1_M5_120060_132900 n1_M5_120060_133980 0.197640
R19501 n1_M5_120060_133980 n1_M5_120060_135060 0.197640
R19502 n1_M5_120060_135060 n1_M5_120060_136140 0.197640
R19503 n1_M5_120060_136140 n1_M5_120060_137220 0.197640
R19504 n1_M5_120060_137220 n1_M5_120060_138300 0.197640
R19505 n1_M5_120060_138300 n1_M5_120060_139380 0.197640
R19506 n1_M5_120060_139380 n1_M5_120060_140460 0.197640
R19507 n1_M5_120060_140460 n1_M5_120060_141540 0.197640
R19508 n1_M5_120060_141540 n1_M5_120060_142620 0.197640
R19509 n1_M5_120060_142620 n1_M5_120060_143700 0.197640
R19510 n1_M5_120060_143700 n1_M5_120060_144060 0.065880
R19511 n1_M5_120060_144780 n1_M5_120060_144060 0.131760
R19512 n1_M5_120060_144780 n1_M5_120060_145860 0.197640
R19513 n1_M5_120060_145860 n1_M5_120060_146940 0.197640
R19514 n1_M5_144060_60 n1_M5_144060_1140 0.197640
R19515 n1_M5_144060_1140 n1_M5_144060_2220 0.197640
R19516 n1_M5_144060_2220 n1_M5_144060_3300 0.197640
R19517 n1_M5_144060_3300 n1_M5_144060_4380 0.197640
R19518 n1_M5_144060_4380 n1_M5_144060_5460 0.197640
R19519 n1_M5_144060_5460 n1_M5_144060_6540 0.197640
R19520 n1_M5_144060_6540 n1_M5_144060_7620 0.197640
R19521 n1_M5_144060_7620 n1_M5_144060_8700 0.197640
R19522 n1_M5_144060_8700 n1_M5_144060_9780 0.197640
R19523 n1_M5_144060_9780 n1_M5_144060_10860 0.197640
R19524 n1_M5_144060_10860 n1_M5_144060_11940 0.197640
R19525 n1_M5_144060_11940 n1_M5_144060_12060 0.021960
R19526 n1_M5_144060_13020 n1_M5_144060_12060 0.175680
R19527 n1_M5_144060_13020 n1_M5_144060_14100 0.197640
R19528 n1_M5_144060_14100 n1_M5_144060_15180 0.197640
R19529 n1_M5_144060_15180 n1_M5_144060_16260 0.197640
R19530 n1_M5_144060_16260 n1_M5_144060_17340 0.197640
R19531 n1_M5_144060_17340 n1_M5_144060_18420 0.197640
R19532 n1_M5_144060_18420 n1_M5_144060_19500 0.197640
R19533 n1_M5_144060_19500 n1_M5_144060_20580 0.197640
R19534 n1_M5_144060_20580 n1_M5_144060_21660 0.197640
R19535 n1_M5_144060_21660 n1_M5_144060_22740 0.197640
R19536 n1_M5_144060_22740 n1_M5_144060_23820 0.197640
R19537 n1_M5_144060_23820 n1_M5_144060_24060 0.043920
R19538 n1_M5_144060_24900 n1_M5_144060_24060 0.153720
R19539 n1_M5_144060_24900 n1_M5_144060_25980 0.197640
R19540 n1_M5_144060_25980 n1_M5_144060_27060 0.197640
R19541 n1_M5_144060_27060 n1_M5_144060_28140 0.197640
R19542 n1_M5_144060_28140 n1_M5_144060_29220 0.197640
R19543 n1_M5_144060_29220 n1_M5_144060_30300 0.197640
R19544 n1_M5_144060_30300 n1_M5_144060_31380 0.197640
R19545 n1_M5_144060_31380 n1_M5_144060_32460 0.197640
R19546 n1_M5_144060_32460 n1_M5_144060_33540 0.197640
R19547 n1_M5_144060_33540 n1_M5_144060_34620 0.197640
R19548 n1_M5_144060_34620 n1_M5_144060_35700 0.197640
R19549 n1_M5_144060_35700 n1_M5_144060_36060 0.065880
R19550 n1_M5_144060_36780 n1_M5_144060_36060 0.131760
R19551 n1_M5_144060_36780 n1_M5_144060_37860 0.197640
R19552 n1_M5_144060_37860 n1_M5_144060_38940 0.197640
R19553 n1_M5_144060_38940 n1_M5_144060_40020 0.197640
R19554 n1_M5_144060_40020 n1_M5_144060_41100 0.197640
R19555 n1_M5_144060_41100 n1_M5_144060_42180 0.197640
R19556 n1_M5_144060_42180 n1_M5_144060_43260 0.197640
R19557 n1_M5_144060_43260 n1_M5_144060_44340 0.197640
R19558 n1_M5_144060_44340 n1_M5_144060_45420 0.197640
R19559 n1_M5_144060_45420 n1_M5_144060_46500 0.197640
R19560 n1_M5_144060_46500 n1_M5_144060_47580 0.197640
R19561 n1_M5_144060_47580 n1_M5_144060_48060 0.087840
R19562 n1_M5_144060_48660 n1_M5_144060_48060 0.109800
R19563 n1_M5_144060_48660 n1_M5_144060_49740 0.197640
R19564 n1_M5_144060_49740 n1_M5_144060_50820 0.197640
R19565 n1_M5_144060_50820 n1_M5_144060_51900 0.197640
R19566 n1_M5_144060_51900 n1_M5_144060_52980 0.197640
R19567 n1_M5_144060_52980 n1_M5_144060_54060 0.197640
R19568 n1_M5_144060_54060 n1_M5_144060_55140 0.197640
R19569 n1_M5_144060_55140 n1_M5_144060_56220 0.197640
R19570 n1_M5_144060_56220 n1_M5_144060_57300 0.197640
R19571 n1_M5_144060_57300 n1_M5_144060_58380 0.197640
R19572 n1_M5_144060_58380 n1_M5_144060_59460 0.197640
R19573 n1_M5_144060_59460 n1_M5_144060_60060 0.109800
R19574 n1_M5_144060_60540 n1_M5_144060_60060 0.087840
R19575 n1_M5_144060_60540 n1_M5_144060_61620 0.197640
R19576 n1_M5_144060_61620 n1_M5_144060_62700 0.197640
R19577 n1_M5_144060_62700 n1_M5_144060_63780 0.197640
R19578 n1_M5_144060_63780 n1_M5_144060_64860 0.197640
R19579 n1_M5_144060_64860 n1_M5_144060_65940 0.197640
R19580 n1_M5_144060_65940 n1_M5_144060_67020 0.197640
R19581 n1_M5_144060_67020 n1_M5_144060_68100 0.197640
R19582 n1_M5_144060_68100 n1_M5_144060_69180 0.197640
R19583 n1_M5_144060_69180 n1_M5_144060_70260 0.197640
R19584 n1_M5_144060_70260 n1_M5_144060_71340 0.197640
R19585 n1_M5_144060_71340 n1_M5_144060_72060 0.131760
R19586 n1_M5_144060_72420 n1_M5_144060_72060 0.065880
R19587 n1_M5_144060_72420 n1_M5_144060_73500 0.197640
R19588 n1_M5_144060_73500 n1_M5_144060_74580 0.197640
R19589 n1_M5_144060_74580 n1_M5_144060_75660 0.197640
R19590 n1_M5_144060_75660 n1_M5_144060_76740 0.197640
R19591 n1_M5_144060_76740 n1_M5_144060_77820 0.197640
R19592 n1_M5_144060_77820 n1_M5_144060_78900 0.197640
R19593 n1_M5_144060_78900 n1_M5_144060_79980 0.197640
R19594 n1_M5_144060_79980 n1_M5_144060_81060 0.197640
R19595 n1_M5_144060_81060 n1_M5_144060_82140 0.197640
R19596 n1_M5_144060_82140 n1_M5_144060_83220 0.197640
R19597 n1_M5_144060_83220 n1_M5_144060_84060 0.153720
R19598 n1_M5_144060_84300 n1_M5_144060_84060 0.043920
R19599 n1_M5_144060_84300 n1_M5_144060_85380 0.197640
R19600 n1_M5_144060_85380 n1_M5_144060_86460 0.197640
R19601 n1_M5_144060_86460 n1_M5_144060_87540 0.197640
R19602 n1_M5_144060_87540 n1_M5_144060_88620 0.197640
R19603 n1_M5_144060_88620 n1_M5_144060_89700 0.197640
R19604 n1_M5_144060_89700 n1_M5_144060_90780 0.197640
R19605 n1_M5_144060_90780 n1_M5_144060_91860 0.197640
R19606 n1_M5_144060_91860 n1_M5_144060_92940 0.197640
R19607 n1_M5_144060_92940 n1_M5_144060_94020 0.197640
R19608 n1_M5_144060_94020 n1_M5_144060_95100 0.197640
R19609 n1_M5_144060_95100 n1_M5_144060_96060 0.175680
R19610 n1_M5_144060_96180 n1_M5_144060_96060 0.021960
R19611 n1_M5_144060_96180 n1_M5_144060_97260 0.197640
R19612 n1_M5_144060_97260 n1_M5_144060_98340 0.197640
R19613 n1_M5_144060_98340 n1_M5_144060_99420 0.197640
R19614 n1_M5_144060_99420 n1_M5_144060_100500 0.197640
R19615 n1_M5_144060_100500 n1_M5_144060_101580 0.197640
R19616 n1_M5_144060_101580 n1_M5_144060_102660 0.197640
R19617 n1_M5_144060_102660 n1_M5_144060_103740 0.197640
R19618 n1_M5_144060_103740 n1_M5_144060_104820 0.197640
R19619 n1_M5_144060_104820 n1_M5_144060_105900 0.197640
R19620 n1_M5_144060_105900 n1_M5_144060_106980 0.197640
R19621 n1_M5_144060_106980 n1_M5_144060_108060 0.197640
R19622 n1_M5_144060_108060 n1_M5_144060_109140 0.197640
R19623 n1_M5_144060_109140 n1_M5_144060_110220 0.197640
R19624 n1_M5_144060_110220 n1_M5_144060_111300 0.197640
R19625 n1_M5_144060_111300 n1_M5_144060_112380 0.197640
R19626 n1_M5_144060_112380 n1_M5_144060_113460 0.197640
R19627 n1_M5_144060_113460 n1_M5_144060_114540 0.197640
R19628 n1_M5_144060_114540 n1_M5_144060_115620 0.197640
R19629 n1_M5_144060_115620 n1_M5_144060_116700 0.197640
R19630 n1_M5_144060_116700 n1_M5_144060_117780 0.197640
R19631 n1_M5_144060_117780 n1_M5_144060_118860 0.197640
R19632 n1_M5_144060_118860 n1_M5_144060_119940 0.197640
R19633 n1_M5_144060_119940 n1_M5_144060_120060 0.021960
R19634 n1_M5_144060_121020 n1_M5_144060_120060 0.175680
R19635 n1_M5_144060_121020 n1_M5_144060_122100 0.197640
R19636 n1_M5_144060_122100 n1_M5_144060_123180 0.197640
R19637 n1_M5_144060_123180 n1_M5_144060_124260 0.197640
R19638 n1_M5_144060_124260 n1_M5_144060_125340 0.197640
R19639 n1_M5_144060_125340 n1_M5_144060_126420 0.197640
R19640 n1_M5_144060_126420 n1_M5_144060_127500 0.197640
R19641 n1_M5_144060_127500 n1_M5_144060_128580 0.197640
R19642 n1_M5_144060_128580 n1_M5_144060_129660 0.197640
R19643 n1_M5_144060_129660 n1_M5_144060_130740 0.197640
R19644 n1_M5_144060_130740 n1_M5_144060_131820 0.197640
R19645 n1_M5_144060_131820 n1_M5_144060_132060 0.043920
R19646 n1_M5_144060_132900 n1_M5_144060_132060 0.153720
R19647 n1_M5_144060_132900 n1_M5_144060_133980 0.197640
R19648 n1_M5_144060_133980 n1_M5_144060_135060 0.197640
R19649 n1_M5_144060_135060 n1_M5_144060_136140 0.197640
R19650 n1_M5_144060_136140 n1_M5_144060_137220 0.197640
R19651 n1_M5_144060_137220 n1_M5_144060_138300 0.197640
R19652 n1_M5_144060_138300 n1_M5_144060_139380 0.197640
R19653 n1_M5_144060_139380 n1_M5_144060_140460 0.197640
R19654 n1_M5_144060_140460 n1_M5_144060_141540 0.197640
R19655 n1_M5_144060_141540 n1_M5_144060_142620 0.197640
R19656 n1_M5_144060_142620 n1_M5_144060_143700 0.197640
R19657 n1_M5_144060_143700 n1_M5_144060_144060 0.065880
R19658 n1_M5_144060_144780 n1_M5_144060_144060 0.131760
R19659 n1_M5_144060_144780 n1_M5_144060_145860 0.197640
R19660 n1_M5_144060_145860 n1_M5_144060_146940 0.197640
R19661 n1_M6_60_60 n1_M6_4156_60 0.416427
R19662 n1_M6_6060_60 n1_M6_4156_60 0.193573
R19663 n1_M6_6060_60 n1_M6_8252_60 0.222853
R19664 n1_M6_12060_60 n1_M6_8252_60 0.387147
R19665 n1_M6_12060_60 n1_M6_12348_60 0.029280
R19666 n1_M6_12348_60 n1_M6_16444_60 0.416427
R19667 n1_M6_18060_60 n1_M6_16444_60 0.164293
R19668 n1_M6_18060_60 n1_M6_20540_60 0.252133
R19669 n1_M6_24060_60 n1_M6_20540_60 0.357867
R19670 n1_M6_24060_60 n1_M6_24636_60 0.058560
R19671 n1_M6_24636_60 n1_M6_28732_60 0.416427
R19672 n1_M6_30060_60 n1_M6_28732_60 0.135013
R19673 n1_M6_30060_60 n1_M6_32828_60 0.281413
R19674 n1_M6_36060_60 n1_M6_32828_60 0.328587
R19675 n1_M6_36060_60 n1_M6_36924_60 0.087840
R19676 n1_M6_36924_60 n1_M6_41020_60 0.416427
R19677 n1_M6_42060_60 n1_M6_41020_60 0.105733
R19678 n1_M6_42060_60 n1_M6_45116_60 0.310693
R19679 n1_M6_48060_60 n1_M6_45116_60 0.299307
R19680 n1_M6_48060_60 n1_M6_49212_60 0.117120
R19681 n1_M6_49212_60 n1_M6_53308_60 0.416427
R19682 n1_M6_54060_60 n1_M6_53308_60 0.076453
R19683 n1_M6_54060_60 n1_M6_57404_60 0.339973
R19684 n1_M6_60060_60 n1_M6_57404_60 0.270027
R19685 n1_M6_60060_60 n1_M6_61500_60 0.146400
R19686 n1_M6_61500_60 n1_M6_65596_60 0.416427
R19687 n1_M6_66060_60 n1_M6_65596_60 0.047173
R19688 n1_M6_66060_60 n1_M6_69692_60 0.369253
R19689 n1_M6_72060_60 n1_M6_69692_60 0.240747
R19690 n1_M6_72060_60 n1_M6_73788_60 0.175680
R19691 n1_M6_73788_60 n1_M6_77884_60 0.416427
R19692 n1_M6_78060_60 n1_M6_77884_60 0.017893
R19693 n1_M6_78060_60 n1_M6_81980_60 0.398533
R19694 n1_M6_84060_60 n1_M6_81980_60 0.211467
R19695 n1_M6_84060_60 n1_M6_86076_60 0.204960
R19696 n1_M6_90060_60 n1_M6_86076_60 0.405040
R19697 n1_M6_90060_60 n1_M6_90172_60 0.011387
R19698 n1_M6_90172_60 n1_M6_94268_60 0.416427
R19699 n1_M6_96060_60 n1_M6_94268_60 0.182187
R19700 n1_M6_96060_60 n1_M6_98364_60 0.234240
R19701 n1_M6_102060_60 n1_M6_98364_60 0.375760
R19702 n1_M6_102060_60 n1_M6_102460_60 0.040667
R19703 n1_M6_102460_60 n1_M6_106556_60 0.416427
R19704 n1_M6_108060_60 n1_M6_106556_60 0.152907
R19705 n1_M6_108060_60 n1_M6_110652_60 0.263520
R19706 n1_M6_114060_60 n1_M6_110652_60 0.346480
R19707 n1_M6_114060_60 n1_M6_114748_60 0.069947
R19708 n1_M6_114748_60 n1_M6_118844_60 0.416427
R19709 n1_M6_120060_60 n1_M6_118844_60 0.123627
R19710 n1_M6_120060_60 n1_M6_122940_60 0.292800
R19711 n1_M6_126060_60 n1_M6_122940_60 0.317200
R19712 n1_M6_126060_60 n1_M6_127036_60 0.099227
R19713 n1_M6_127036_60 n1_M6_131132_60 0.416427
R19714 n1_M6_132060_60 n1_M6_131132_60 0.094347
R19715 n1_M6_132060_60 n1_M6_135228_60 0.322080
R19716 n1_M6_138060_60 n1_M6_135228_60 0.287920
R19717 n1_M6_138060_60 n1_M6_139324_60 0.128507
R19718 n1_M6_139324_60 n1_M6_143420_60 0.416427
R19719 n1_M6_144060_60 n1_M6_143420_60 0.065067
R19720 n1_M6_144060_60 n1_M6_147516_60 0.351360
R19721 n1_M6_60_12060 n1_M6_4156_12060 0.416427
R19722 n1_M6_6060_12060 n1_M6_4156_12060 0.193573
R19723 n1_M6_6060_12060 n1_M6_8252_12060 0.222853
R19724 n1_M6_12060_12060 n1_M6_8252_12060 0.387147
R19725 n1_M6_12060_12060 n1_M6_12348_12060 0.029280
R19726 n1_M6_12348_12060 n1_M6_16444_12060 0.416427
R19727 n1_M6_18060_12060 n1_M6_16444_12060 0.164293
R19728 n1_M6_18060_12060 n1_M6_20540_12060 0.252133
R19729 n1_M6_24060_12060 n1_M6_20540_12060 0.357867
R19730 n1_M6_24060_12060 n1_M6_24636_12060 0.058560
R19731 n1_M6_24636_12060 n1_M6_28732_12060 0.416427
R19732 n1_M6_30060_12060 n1_M6_28732_12060 0.135013
R19733 n1_M6_30060_12060 n1_M6_32828_12060 0.281413
R19734 n1_M6_36060_12060 n1_M6_32828_12060 0.328587
R19735 n1_M6_36060_12060 n1_M6_36924_12060 0.087840
R19736 n1_M6_36924_12060 n1_M6_41020_12060 0.416427
R19737 n1_M6_42060_12060 n1_M6_41020_12060 0.105733
R19738 n1_M6_42060_12060 n1_M6_45116_12060 0.310693
R19739 n1_M6_48060_12060 n1_M6_45116_12060 0.299307
R19740 n1_M6_48060_12060 n1_M6_49212_12060 0.117120
R19741 n1_M6_49212_12060 n1_M6_53308_12060 0.416427
R19742 n1_M6_54060_12060 n1_M6_53308_12060 0.076453
R19743 n1_M6_54060_12060 n1_M6_57404_12060 0.339973
R19744 n1_M6_60060_12060 n1_M6_57404_12060 0.270027
R19745 n1_M6_60060_12060 n1_M6_61500_12060 0.146400
R19746 n1_M6_61500_12060 n1_M6_65596_12060 0.416427
R19747 n1_M6_66060_12060 n1_M6_65596_12060 0.047173
R19748 n1_M6_66060_12060 n1_M6_69692_12060 0.369253
R19749 n1_M6_72060_12060 n1_M6_69692_12060 0.240747
R19750 n1_M6_72060_12060 n1_M6_73788_12060 0.175680
R19751 n1_M6_73788_12060 n1_M6_77884_12060 0.416427
R19752 n1_M6_78060_12060 n1_M6_77884_12060 0.017893
R19753 n1_M6_78060_12060 n1_M6_81980_12060 0.398533
R19754 n1_M6_84060_12060 n1_M6_81980_12060 0.211467
R19755 n1_M6_84060_12060 n1_M6_86076_12060 0.204960
R19756 n1_M6_90060_12060 n1_M6_86076_12060 0.405040
R19757 n1_M6_90060_12060 n1_M6_90172_12060 0.011387
R19758 n1_M6_90172_12060 n1_M6_94268_12060 0.416427
R19759 n1_M6_96060_12060 n1_M6_94268_12060 0.182187
R19760 n1_M6_96060_12060 n1_M6_98364_12060 0.234240
R19761 n1_M6_102060_12060 n1_M6_98364_12060 0.375760
R19762 n1_M6_102060_12060 n1_M6_102460_12060 0.040667
R19763 n1_M6_102460_12060 n1_M6_106556_12060 0.416427
R19764 n1_M6_108060_12060 n1_M6_106556_12060 0.152907
R19765 n1_M6_108060_12060 n1_M6_110652_12060 0.263520
R19766 n1_M6_114060_12060 n1_M6_110652_12060 0.346480
R19767 n1_M6_114060_12060 n1_M6_114748_12060 0.069947
R19768 n1_M6_114748_12060 n1_M6_118844_12060 0.416427
R19769 n1_M6_120060_12060 n1_M6_118844_12060 0.123627
R19770 n1_M6_120060_12060 n1_M6_122940_12060 0.292800
R19771 n1_M6_126060_12060 n1_M6_122940_12060 0.317200
R19772 n1_M6_126060_12060 n1_M6_127036_12060 0.099227
R19773 n1_M6_127036_12060 n1_M6_131132_12060 0.416427
R19774 n1_M6_132060_12060 n1_M6_131132_12060 0.094347
R19775 n1_M6_132060_12060 n1_M6_135228_12060 0.322080
R19776 n1_M6_138060_12060 n1_M6_135228_12060 0.287920
R19777 n1_M6_138060_12060 n1_M6_139324_12060 0.128507
R19778 n1_M6_139324_12060 n1_M6_143420_12060 0.416427
R19779 n1_M6_144060_12060 n1_M6_143420_12060 0.065067
R19780 n1_M6_144060_12060 n1_M6_147516_12060 0.351360
R19781 n1_M6_60_24060 n1_M6_4156_24060 0.416427
R19782 n1_M6_6060_24060 n1_M6_4156_24060 0.193573
R19783 n1_M6_6060_24060 n1_M6_8252_24060 0.222853
R19784 n1_M6_12060_24060 n1_M6_8252_24060 0.387147
R19785 n1_M6_12060_24060 n1_M6_12348_24060 0.029280
R19786 n1_M6_12348_24060 n1_M6_16444_24060 0.416427
R19787 n1_M6_18060_24060 n1_M6_16444_24060 0.164293
R19788 n1_M6_18060_24060 n1_M6_20540_24060 0.252133
R19789 n1_M6_24060_24060 n1_M6_20540_24060 0.357867
R19790 n1_M6_24060_24060 n1_M6_24636_24060 0.058560
R19791 n1_M6_24636_24060 n1_M6_28732_24060 0.416427
R19792 n1_M6_30060_24060 n1_M6_28732_24060 0.135013
R19793 n1_M6_30060_24060 n1_M6_32828_24060 0.281413
R19794 n1_M6_36060_24060 n1_M6_32828_24060 0.328587
R19795 n1_M6_36060_24060 n1_M6_36924_24060 0.087840
R19796 n1_M6_36924_24060 n1_M6_41020_24060 0.416427
R19797 n1_M6_42060_24060 n1_M6_41020_24060 0.105733
R19798 n1_M6_42060_24060 n1_M6_45116_24060 0.310693
R19799 n1_M6_48060_24060 n1_M6_45116_24060 0.299307
R19800 n1_M6_48060_24060 n1_M6_49212_24060 0.117120
R19801 n1_M6_49212_24060 n1_M6_53308_24060 0.416427
R19802 n1_M6_54060_24060 n1_M6_53308_24060 0.076453
R19803 n1_M6_54060_24060 n1_M6_57404_24060 0.339973
R19804 n1_M6_60060_24060 n1_M6_57404_24060 0.270027
R19805 n1_M6_60060_24060 n1_M6_61500_24060 0.146400
R19806 n1_M6_61500_24060 n1_M6_65596_24060 0.416427
R19807 n1_M6_66060_24060 n1_M6_65596_24060 0.047173
R19808 n1_M6_66060_24060 n1_M6_69692_24060 0.369253
R19809 n1_M6_72060_24060 n1_M6_69692_24060 0.240747
R19810 n1_M6_72060_24060 n1_M6_73788_24060 0.175680
R19811 n1_M6_73788_24060 n1_M6_77884_24060 0.416427
R19812 n1_M6_78060_24060 n1_M6_77884_24060 0.017893
R19813 n1_M6_78060_24060 n1_M6_81980_24060 0.398533
R19814 n1_M6_84060_24060 n1_M6_81980_24060 0.211467
R19815 n1_M6_84060_24060 n1_M6_86076_24060 0.204960
R19816 n1_M6_90060_24060 n1_M6_86076_24060 0.405040
R19817 n1_M6_90060_24060 n1_M6_90172_24060 0.011387
R19818 n1_M6_90172_24060 n1_M6_94268_24060 0.416427
R19819 n1_M6_96060_24060 n1_M6_94268_24060 0.182187
R19820 n1_M6_96060_24060 n1_M6_98364_24060 0.234240
R19821 n1_M6_102060_24060 n1_M6_98364_24060 0.375760
R19822 n1_M6_102060_24060 n1_M6_102460_24060 0.040667
R19823 n1_M6_102460_24060 n1_M6_106556_24060 0.416427
R19824 n1_M6_108060_24060 n1_M6_106556_24060 0.152907
R19825 n1_M6_108060_24060 n1_M6_110652_24060 0.263520
R19826 n1_M6_114060_24060 n1_M6_110652_24060 0.346480
R19827 n1_M6_114060_24060 n1_M6_114748_24060 0.069947
R19828 n1_M6_114748_24060 n1_M6_118844_24060 0.416427
R19829 n1_M6_120060_24060 n1_M6_118844_24060 0.123627
R19830 n1_M6_120060_24060 n1_M6_122940_24060 0.292800
R19831 n1_M6_126060_24060 n1_M6_122940_24060 0.317200
R19832 n1_M6_126060_24060 n1_M6_127036_24060 0.099227
R19833 n1_M6_127036_24060 n1_M6_131132_24060 0.416427
R19834 n1_M6_132060_24060 n1_M6_131132_24060 0.094347
R19835 n1_M6_132060_24060 n1_M6_135228_24060 0.322080
R19836 n1_M6_138060_24060 n1_M6_135228_24060 0.287920
R19837 n1_M6_138060_24060 n1_M6_139324_24060 0.128507
R19838 n1_M6_139324_24060 n1_M6_143420_24060 0.416427
R19839 n1_M6_144060_24060 n1_M6_143420_24060 0.065067
R19840 n1_M6_144060_24060 n1_M6_147516_24060 0.351360
R19841 n1_M6_60_36060 n1_M6_4156_36060 0.416427
R19842 n1_M6_6060_36060 n1_M6_4156_36060 0.193573
R19843 n1_M6_6060_36060 n1_M6_8252_36060 0.222853
R19844 n1_M6_12060_36060 n1_M6_8252_36060 0.387147
R19845 n1_M6_12060_36060 n1_M6_12348_36060 0.029280
R19846 n1_M6_12348_36060 n1_M6_16444_36060 0.416427
R19847 n1_M6_18060_36060 n1_M6_16444_36060 0.164293
R19848 n1_M6_18060_36060 n1_M6_20540_36060 0.252133
R19849 n1_M6_24060_36060 n1_M6_20540_36060 0.357867
R19850 n1_M6_24060_36060 n1_M6_24636_36060 0.058560
R19851 n1_M6_24636_36060 n1_M6_28732_36060 0.416427
R19852 n1_M6_30060_36060 n1_M6_28732_36060 0.135013
R19853 n1_M6_30060_36060 n1_M6_32828_36060 0.281413
R19854 n1_M6_36060_36060 n1_M6_32828_36060 0.328587
R19855 n1_M6_36060_36060 n1_M6_36924_36060 0.087840
R19856 n1_M6_36924_36060 n1_M6_41020_36060 0.416427
R19857 n1_M6_42060_36060 n1_M6_41020_36060 0.105733
R19858 n1_M6_42060_36060 n1_M6_45116_36060 0.310693
R19859 n1_M6_48060_36060 n1_M6_45116_36060 0.299307
R19860 n1_M6_48060_36060 n1_M6_49212_36060 0.117120
R19861 n1_M6_49212_36060 n1_M6_53308_36060 0.416427
R19862 n1_M6_54060_36060 n1_M6_53308_36060 0.076453
R19863 n1_M6_54060_36060 n1_M6_57404_36060 0.339973
R19864 n1_M6_60060_36060 n1_M6_57404_36060 0.270027
R19865 n1_M6_60060_36060 n1_M6_61500_36060 0.146400
R19866 n1_M6_61500_36060 n1_M6_65596_36060 0.416427
R19867 n1_M6_66060_36060 n1_M6_65596_36060 0.047173
R19868 n1_M6_66060_36060 n1_M6_69692_36060 0.369253
R19869 n1_M6_72060_36060 n1_M6_69692_36060 0.240747
R19870 n1_M6_72060_36060 n1_M6_73788_36060 0.175680
R19871 n1_M6_73788_36060 n1_M6_77884_36060 0.416427
R19872 n1_M6_78060_36060 n1_M6_77884_36060 0.017893
R19873 n1_M6_78060_36060 n1_M6_81980_36060 0.398533
R19874 n1_M6_84060_36060 n1_M6_81980_36060 0.211467
R19875 n1_M6_84060_36060 n1_M6_86076_36060 0.204960
R19876 n1_M6_90060_36060 n1_M6_86076_36060 0.405040
R19877 n1_M6_90060_36060 n1_M6_90172_36060 0.011387
R19878 n1_M6_90172_36060 n1_M6_94268_36060 0.416427
R19879 n1_M6_96060_36060 n1_M6_94268_36060 0.182187
R19880 n1_M6_96060_36060 n1_M6_98364_36060 0.234240
R19881 n1_M6_102060_36060 n1_M6_98364_36060 0.375760
R19882 n1_M6_102060_36060 n1_M6_102460_36060 0.040667
R19883 n1_M6_102460_36060 n1_M6_106556_36060 0.416427
R19884 n1_M6_108060_36060 n1_M6_106556_36060 0.152907
R19885 n1_M6_108060_36060 n1_M6_110652_36060 0.263520
R19886 n1_M6_114060_36060 n1_M6_110652_36060 0.346480
R19887 n1_M6_114060_36060 n1_M6_114748_36060 0.069947
R19888 n1_M6_114748_36060 n1_M6_118844_36060 0.416427
R19889 n1_M6_120060_36060 n1_M6_118844_36060 0.123627
R19890 n1_M6_120060_36060 n1_M6_122940_36060 0.292800
R19891 n1_M6_126060_36060 n1_M6_122940_36060 0.317200
R19892 n1_M6_126060_36060 n1_M6_127036_36060 0.099227
R19893 n1_M6_127036_36060 n1_M6_131132_36060 0.416427
R19894 n1_M6_132060_36060 n1_M6_131132_36060 0.094347
R19895 n1_M6_132060_36060 n1_M6_135228_36060 0.322080
R19896 n1_M6_138060_36060 n1_M6_135228_36060 0.287920
R19897 n1_M6_138060_36060 n1_M6_139324_36060 0.128507
R19898 n1_M6_139324_36060 n1_M6_143420_36060 0.416427
R19899 n1_M6_144060_36060 n1_M6_143420_36060 0.065067
R19900 n1_M6_144060_36060 n1_M6_147516_36060 0.351360
R19901 n1_M6_60_48060 n1_M6_4156_48060 0.416427
R19902 n1_M6_6060_48060 n1_M6_4156_48060 0.193573
R19903 n1_M6_6060_48060 n1_M6_8252_48060 0.222853
R19904 n1_M6_12060_48060 n1_M6_8252_48060 0.387147
R19905 n1_M6_12060_48060 n1_M6_12348_48060 0.029280
R19906 n1_M6_12348_48060 n1_M6_16444_48060 0.416427
R19907 n1_M6_18060_48060 n1_M6_16444_48060 0.164293
R19908 n1_M6_18060_48060 n1_M6_20540_48060 0.252133
R19909 n1_M6_24060_48060 n1_M6_20540_48060 0.357867
R19910 n1_M6_24060_48060 n1_M6_24636_48060 0.058560
R19911 n1_M6_24636_48060 n1_M6_28732_48060 0.416427
R19912 n1_M6_30060_48060 n1_M6_28732_48060 0.135013
R19913 n1_M6_30060_48060 n1_M6_32828_48060 0.281413
R19914 n1_M6_36060_48060 n1_M6_32828_48060 0.328587
R19915 n1_M6_36060_48060 n1_M6_36924_48060 0.087840
R19916 n1_M6_36924_48060 n1_M6_41020_48060 0.416427
R19917 n1_M6_42060_48060 n1_M6_41020_48060 0.105733
R19918 n1_M6_42060_48060 n1_M6_45116_48060 0.310693
R19919 n1_M6_48060_48060 n1_M6_45116_48060 0.299307
R19920 n1_M6_48060_48060 n1_M6_49212_48060 0.117120
R19921 n1_M6_49212_48060 n1_M6_53308_48060 0.416427
R19922 n1_M6_54060_48060 n1_M6_53308_48060 0.076453
R19923 n1_M6_54060_48060 n1_M6_57404_48060 0.339973
R19924 n1_M6_60060_48060 n1_M6_57404_48060 0.270027
R19925 n1_M6_60060_48060 n1_M6_61500_48060 0.146400
R19926 n1_M6_61500_48060 n1_M6_65596_48060 0.416427
R19927 n1_M6_66060_48060 n1_M6_65596_48060 0.047173
R19928 n1_M6_66060_48060 n1_M6_69692_48060 0.369253
R19929 n1_M6_72060_48060 n1_M6_69692_48060 0.240747
R19930 n1_M6_72060_48060 n1_M6_73788_48060 0.175680
R19931 n1_M6_73788_48060 n1_M6_77884_48060 0.416427
R19932 n1_M6_78060_48060 n1_M6_77884_48060 0.017893
R19933 n1_M6_78060_48060 n1_M6_81980_48060 0.398533
R19934 n1_M6_84060_48060 n1_M6_81980_48060 0.211467
R19935 n1_M6_84060_48060 n1_M6_86076_48060 0.204960
R19936 n1_M6_90060_48060 n1_M6_86076_48060 0.405040
R19937 n1_M6_90060_48060 n1_M6_90172_48060 0.011387
R19938 n1_M6_90172_48060 n1_M6_94268_48060 0.416427
R19939 n1_M6_96060_48060 n1_M6_94268_48060 0.182187
R19940 n1_M6_96060_48060 n1_M6_98364_48060 0.234240
R19941 n1_M6_102060_48060 n1_M6_98364_48060 0.375760
R19942 n1_M6_102060_48060 n1_M6_102460_48060 0.040667
R19943 n1_M6_102460_48060 n1_M6_106556_48060 0.416427
R19944 n1_M6_108060_48060 n1_M6_106556_48060 0.152907
R19945 n1_M6_108060_48060 n1_M6_110652_48060 0.263520
R19946 n1_M6_114060_48060 n1_M6_110652_48060 0.346480
R19947 n1_M6_114060_48060 n1_M6_114748_48060 0.069947
R19948 n1_M6_114748_48060 n1_M6_118844_48060 0.416427
R19949 n1_M6_120060_48060 n1_M6_118844_48060 0.123627
R19950 n1_M6_120060_48060 n1_M6_122940_48060 0.292800
R19951 n1_M6_126060_48060 n1_M6_122940_48060 0.317200
R19952 n1_M6_126060_48060 n1_M6_127036_48060 0.099227
R19953 n1_M6_127036_48060 n1_M6_131132_48060 0.416427
R19954 n1_M6_132060_48060 n1_M6_131132_48060 0.094347
R19955 n1_M6_132060_48060 n1_M6_135228_48060 0.322080
R19956 n1_M6_138060_48060 n1_M6_135228_48060 0.287920
R19957 n1_M6_138060_48060 n1_M6_139324_48060 0.128507
R19958 n1_M6_139324_48060 n1_M6_143420_48060 0.416427
R19959 n1_M6_144060_48060 n1_M6_143420_48060 0.065067
R19960 n1_M6_144060_48060 n1_M6_147516_48060 0.351360
R19961 n1_M6_60_60060 n1_M6_4156_60060 0.416427
R19962 n1_M6_6060_60060 n1_M6_4156_60060 0.193573
R19963 n1_M6_6060_60060 n1_M6_8252_60060 0.222853
R19964 n1_M6_12060_60060 n1_M6_8252_60060 0.387147
R19965 n1_M6_12060_60060 n1_M6_12348_60060 0.029280
R19966 n1_M6_12348_60060 n1_M6_16444_60060 0.416427
R19967 n1_M6_18060_60060 n1_M6_16444_60060 0.164293
R19968 n1_M6_18060_60060 n1_M6_20540_60060 0.252133
R19969 n1_M6_24060_60060 n1_M6_20540_60060 0.357867
R19970 n1_M6_24060_60060 n1_M6_24636_60060 0.058560
R19971 n1_M6_24636_60060 n1_M6_28732_60060 0.416427
R19972 n1_M6_30060_60060 n1_M6_28732_60060 0.135013
R19973 n1_M6_30060_60060 n1_M6_32828_60060 0.281413
R19974 n1_M6_36060_60060 n1_M6_32828_60060 0.328587
R19975 n1_M6_36060_60060 n1_M6_36924_60060 0.087840
R19976 n1_M6_36924_60060 n1_M6_41020_60060 0.416427
R19977 n1_M6_42060_60060 n1_M6_41020_60060 0.105733
R19978 n1_M6_42060_60060 n1_M6_45116_60060 0.310693
R19979 n1_M6_48060_60060 n1_M6_45116_60060 0.299307
R19980 n1_M6_48060_60060 n1_M6_49212_60060 0.117120
R19981 n1_M6_49212_60060 n1_M6_53308_60060 0.416427
R19982 n1_M6_54060_60060 n1_M6_53308_60060 0.076453
R19983 n1_M6_54060_60060 n1_M6_57404_60060 0.339973
R19984 n1_M6_60060_60060 n1_M6_57404_60060 0.270027
R19985 n1_M6_60060_60060 n1_M6_61500_60060 0.146400
R19986 n1_M6_61500_60060 n1_M6_65596_60060 0.416427
R19987 n1_M6_66060_60060 n1_M6_65596_60060 0.047173
R19988 n1_M6_66060_60060 n1_M6_69692_60060 0.369253
R19989 n1_M6_72060_60060 n1_M6_69692_60060 0.240747
R19990 n1_M6_72060_60060 n1_M6_73788_60060 0.175680
R19991 n1_M6_73788_60060 n1_M6_77884_60060 0.416427
R19992 n1_M6_78060_60060 n1_M6_77884_60060 0.017893
R19993 n1_M6_78060_60060 n1_M6_81980_60060 0.398533
R19994 n1_M6_84060_60060 n1_M6_81980_60060 0.211467
R19995 n1_M6_84060_60060 n1_M6_86076_60060 0.204960
R19996 n1_M6_90060_60060 n1_M6_86076_60060 0.405040
R19997 n1_M6_90060_60060 n1_M6_90172_60060 0.011387
R19998 n1_M6_90172_60060 n1_M6_94268_60060 0.416427
R19999 n1_M6_96060_60060 n1_M6_94268_60060 0.182187
R20000 n1_M6_96060_60060 n1_M6_98364_60060 0.234240
R20001 n1_M6_102060_60060 n1_M6_98364_60060 0.375760
R20002 n1_M6_102060_60060 n1_M6_102460_60060 0.040667
R20003 n1_M6_102460_60060 n1_M6_106556_60060 0.416427
R20004 n1_M6_108060_60060 n1_M6_106556_60060 0.152907
R20005 n1_M6_108060_60060 n1_M6_110652_60060 0.263520
R20006 n1_M6_114060_60060 n1_M6_110652_60060 0.346480
R20007 n1_M6_114060_60060 n1_M6_114748_60060 0.069947
R20008 n1_M6_114748_60060 n1_M6_118844_60060 0.416427
R20009 n1_M6_120060_60060 n1_M6_118844_60060 0.123627
R20010 n1_M6_120060_60060 n1_M6_122940_60060 0.292800
R20011 n1_M6_126060_60060 n1_M6_122940_60060 0.317200
R20012 n1_M6_126060_60060 n1_M6_127036_60060 0.099227
R20013 n1_M6_127036_60060 n1_M6_131132_60060 0.416427
R20014 n1_M6_132060_60060 n1_M6_131132_60060 0.094347
R20015 n1_M6_132060_60060 n1_M6_135228_60060 0.322080
R20016 n1_M6_138060_60060 n1_M6_135228_60060 0.287920
R20017 n1_M6_138060_60060 n1_M6_139324_60060 0.128507
R20018 n1_M6_139324_60060 n1_M6_143420_60060 0.416427
R20019 n1_M6_144060_60060 n1_M6_143420_60060 0.065067
R20020 n1_M6_144060_60060 n1_M6_147516_60060 0.351360
R20021 n1_M6_60_72060 n1_M6_4156_72060 0.416427
R20022 n1_M6_6060_72060 n1_M6_4156_72060 0.193573
R20023 n1_M6_6060_72060 n1_M6_8252_72060 0.222853
R20024 n1_M6_12060_72060 n1_M6_8252_72060 0.387147
R20025 n1_M6_12060_72060 n1_M6_12348_72060 0.029280
R20026 n1_M6_12348_72060 n1_M6_16444_72060 0.416427
R20027 n1_M6_18060_72060 n1_M6_16444_72060 0.164293
R20028 n1_M6_18060_72060 n1_M6_20540_72060 0.252133
R20029 n1_M6_24060_72060 n1_M6_20540_72060 0.357867
R20030 n1_M6_24060_72060 n1_M6_24636_72060 0.058560
R20031 n1_M6_24636_72060 n1_M6_28732_72060 0.416427
R20032 n1_M6_30060_72060 n1_M6_28732_72060 0.135013
R20033 n1_M6_30060_72060 n1_M6_32828_72060 0.281413
R20034 n1_M6_36060_72060 n1_M6_32828_72060 0.328587
R20035 n1_M6_36060_72060 n1_M6_36924_72060 0.087840
R20036 n1_M6_36924_72060 n1_M6_41020_72060 0.416427
R20037 n1_M6_42060_72060 n1_M6_41020_72060 0.105733
R20038 n1_M6_42060_72060 n1_M6_45116_72060 0.310693
R20039 n1_M6_48060_72060 n1_M6_45116_72060 0.299307
R20040 n1_M6_48060_72060 n1_M6_49212_72060 0.117120
R20041 n1_M6_49212_72060 n1_M6_53308_72060 0.416427
R20042 n1_M6_54060_72060 n1_M6_53308_72060 0.076453
R20043 n1_M6_54060_72060 n1_M6_57404_72060 0.339973
R20044 n1_M6_60060_72060 n1_M6_57404_72060 0.270027
R20045 n1_M6_60060_72060 n1_M6_61500_72060 0.146400
R20046 n1_M6_61500_72060 n1_M6_65596_72060 0.416427
R20047 n1_M6_66060_72060 n1_M6_65596_72060 0.047173
R20048 n1_M6_66060_72060 n1_M6_69692_72060 0.369253
R20049 n1_M6_72060_72060 n1_M6_69692_72060 0.240747
R20050 n1_M6_72060_72060 n1_M6_73788_72060 0.175680
R20051 n1_M6_73788_72060 n1_M6_77884_72060 0.416427
R20052 n1_M6_78060_72060 n1_M6_77884_72060 0.017893
R20053 n1_M6_78060_72060 n1_M6_81980_72060 0.398533
R20054 n1_M6_84060_72060 n1_M6_81980_72060 0.211467
R20055 n1_M6_84060_72060 n1_M6_86076_72060 0.204960
R20056 n1_M6_90060_72060 n1_M6_86076_72060 0.405040
R20057 n1_M6_90060_72060 n1_M6_90172_72060 0.011387
R20058 n1_M6_90172_72060 n1_M6_94268_72060 0.416427
R20059 n1_M6_96060_72060 n1_M6_94268_72060 0.182187
R20060 n1_M6_96060_72060 n1_M6_98364_72060 0.234240
R20061 n1_M6_102060_72060 n1_M6_98364_72060 0.375760
R20062 n1_M6_102060_72060 n1_M6_102460_72060 0.040667
R20063 n1_M6_102460_72060 n1_M6_106556_72060 0.416427
R20064 n1_M6_108060_72060 n1_M6_106556_72060 0.152907
R20065 n1_M6_108060_72060 n1_M6_110652_72060 0.263520
R20066 n1_M6_114060_72060 n1_M6_110652_72060 0.346480
R20067 n1_M6_114060_72060 n1_M6_114748_72060 0.069947
R20068 n1_M6_114748_72060 n1_M6_118844_72060 0.416427
R20069 n1_M6_120060_72060 n1_M6_118844_72060 0.123627
R20070 n1_M6_120060_72060 n1_M6_122940_72060 0.292800
R20071 n1_M6_126060_72060 n1_M6_122940_72060 0.317200
R20072 n1_M6_126060_72060 n1_M6_127036_72060 0.099227
R20073 n1_M6_127036_72060 n1_M6_131132_72060 0.416427
R20074 n1_M6_132060_72060 n1_M6_131132_72060 0.094347
R20075 n1_M6_132060_72060 n1_M6_135228_72060 0.322080
R20076 n1_M6_138060_72060 n1_M6_135228_72060 0.287920
R20077 n1_M6_138060_72060 n1_M6_139324_72060 0.128507
R20078 n1_M6_139324_72060 n1_M6_143420_72060 0.416427
R20079 n1_M6_144060_72060 n1_M6_143420_72060 0.065067
R20080 n1_M6_144060_72060 n1_M6_147516_72060 0.351360
R20081 n1_M6_60_84060 n1_M6_4156_84060 0.416427
R20082 n1_M6_6060_84060 n1_M6_4156_84060 0.193573
R20083 n1_M6_6060_84060 n1_M6_8252_84060 0.222853
R20084 n1_M6_12060_84060 n1_M6_8252_84060 0.387147
R20085 n1_M6_12060_84060 n1_M6_12348_84060 0.029280
R20086 n1_M6_12348_84060 n1_M6_16444_84060 0.416427
R20087 n1_M6_18060_84060 n1_M6_16444_84060 0.164293
R20088 n1_M6_18060_84060 n1_M6_20540_84060 0.252133
R20089 n1_M6_24060_84060 n1_M6_20540_84060 0.357867
R20090 n1_M6_24060_84060 n1_M6_24636_84060 0.058560
R20091 n1_M6_24636_84060 n1_M6_28732_84060 0.416427
R20092 n1_M6_30060_84060 n1_M6_28732_84060 0.135013
R20093 n1_M6_30060_84060 n1_M6_32828_84060 0.281413
R20094 n1_M6_36060_84060 n1_M6_32828_84060 0.328587
R20095 n1_M6_36060_84060 n1_M6_36924_84060 0.087840
R20096 n1_M6_36924_84060 n1_M6_41020_84060 0.416427
R20097 n1_M6_42060_84060 n1_M6_41020_84060 0.105733
R20098 n1_M6_42060_84060 n1_M6_45116_84060 0.310693
R20099 n1_M6_48060_84060 n1_M6_45116_84060 0.299307
R20100 n1_M6_48060_84060 n1_M6_49212_84060 0.117120
R20101 n1_M6_49212_84060 n1_M6_53308_84060 0.416427
R20102 n1_M6_54060_84060 n1_M6_53308_84060 0.076453
R20103 n1_M6_54060_84060 n1_M6_57404_84060 0.339973
R20104 n1_M6_60060_84060 n1_M6_57404_84060 0.270027
R20105 n1_M6_60060_84060 n1_M6_61500_84060 0.146400
R20106 n1_M6_61500_84060 n1_M6_65596_84060 0.416427
R20107 n1_M6_66060_84060 n1_M6_65596_84060 0.047173
R20108 n1_M6_66060_84060 n1_M6_69692_84060 0.369253
R20109 n1_M6_72060_84060 n1_M6_69692_84060 0.240747
R20110 n1_M6_72060_84060 n1_M6_73788_84060 0.175680
R20111 n1_M6_73788_84060 n1_M6_77884_84060 0.416427
R20112 n1_M6_78060_84060 n1_M6_77884_84060 0.017893
R20113 n1_M6_78060_84060 n1_M6_81980_84060 0.398533
R20114 n1_M6_84060_84060 n1_M6_81980_84060 0.211467
R20115 n1_M6_84060_84060 n1_M6_86076_84060 0.204960
R20116 n1_M6_90060_84060 n1_M6_86076_84060 0.405040
R20117 n1_M6_90060_84060 n1_M6_90172_84060 0.011387
R20118 n1_M6_90172_84060 n1_M6_94268_84060 0.416427
R20119 n1_M6_96060_84060 n1_M6_94268_84060 0.182187
R20120 n1_M6_96060_84060 n1_M6_98364_84060 0.234240
R20121 n1_M6_102060_84060 n1_M6_98364_84060 0.375760
R20122 n1_M6_102060_84060 n1_M6_102460_84060 0.040667
R20123 n1_M6_102460_84060 n1_M6_106556_84060 0.416427
R20124 n1_M6_108060_84060 n1_M6_106556_84060 0.152907
R20125 n1_M6_108060_84060 n1_M6_110652_84060 0.263520
R20126 n1_M6_114060_84060 n1_M6_110652_84060 0.346480
R20127 n1_M6_114060_84060 n1_M6_114748_84060 0.069947
R20128 n1_M6_114748_84060 n1_M6_118844_84060 0.416427
R20129 n1_M6_120060_84060 n1_M6_118844_84060 0.123627
R20130 n1_M6_120060_84060 n1_M6_122940_84060 0.292800
R20131 n1_M6_126060_84060 n1_M6_122940_84060 0.317200
R20132 n1_M6_126060_84060 n1_M6_127036_84060 0.099227
R20133 n1_M6_127036_84060 n1_M6_131132_84060 0.416427
R20134 n1_M6_132060_84060 n1_M6_131132_84060 0.094347
R20135 n1_M6_132060_84060 n1_M6_135228_84060 0.322080
R20136 n1_M6_138060_84060 n1_M6_135228_84060 0.287920
R20137 n1_M6_138060_84060 n1_M6_139324_84060 0.128507
R20138 n1_M6_139324_84060 n1_M6_143420_84060 0.416427
R20139 n1_M6_144060_84060 n1_M6_143420_84060 0.065067
R20140 n1_M6_144060_84060 n1_M6_147516_84060 0.351360
R20141 n1_M6_60_96060 n1_M6_4156_96060 0.416427
R20142 n1_M6_6060_96060 n1_M6_4156_96060 0.193573
R20143 n1_M6_6060_96060 n1_M6_8252_96060 0.222853
R20144 n1_M6_12060_96060 n1_M6_8252_96060 0.387147
R20145 n1_M6_12060_96060 n1_M6_12348_96060 0.029280
R20146 n1_M6_12348_96060 n1_M6_16444_96060 0.416427
R20147 n1_M6_18060_96060 n1_M6_16444_96060 0.164293
R20148 n1_M6_18060_96060 n1_M6_20540_96060 0.252133
R20149 n1_M6_24060_96060 n1_M6_20540_96060 0.357867
R20150 n1_M6_24060_96060 n1_M6_24636_96060 0.058560
R20151 n1_M6_24636_96060 n1_M6_28732_96060 0.416427
R20152 n1_M6_30060_96060 n1_M6_28732_96060 0.135013
R20153 n1_M6_30060_96060 n1_M6_32828_96060 0.281413
R20154 n1_M6_36060_96060 n1_M6_32828_96060 0.328587
R20155 n1_M6_36060_96060 n1_M6_36924_96060 0.087840
R20156 n1_M6_36924_96060 n1_M6_41020_96060 0.416427
R20157 n1_M6_42060_96060 n1_M6_41020_96060 0.105733
R20158 n1_M6_42060_96060 n1_M6_45116_96060 0.310693
R20159 n1_M6_48060_96060 n1_M6_45116_96060 0.299307
R20160 n1_M6_48060_96060 n1_M6_49212_96060 0.117120
R20161 n1_M6_49212_96060 n1_M6_53308_96060 0.416427
R20162 n1_M6_54060_96060 n1_M6_53308_96060 0.076453
R20163 n1_M6_54060_96060 n1_M6_57404_96060 0.339973
R20164 n1_M6_60060_96060 n1_M6_57404_96060 0.270027
R20165 n1_M6_60060_96060 n1_M6_61500_96060 0.146400
R20166 n1_M6_61500_96060 n1_M6_65596_96060 0.416427
R20167 n1_M6_66060_96060 n1_M6_65596_96060 0.047173
R20168 n1_M6_66060_96060 n1_M6_69692_96060 0.369253
R20169 n1_M6_72060_96060 n1_M6_69692_96060 0.240747
R20170 n1_M6_72060_96060 n1_M6_73788_96060 0.175680
R20171 n1_M6_73788_96060 n1_M6_77884_96060 0.416427
R20172 n1_M6_78060_96060 n1_M6_77884_96060 0.017893
R20173 n1_M6_78060_96060 n1_M6_81980_96060 0.398533
R20174 n1_M6_84060_96060 n1_M6_81980_96060 0.211467
R20175 n1_M6_84060_96060 n1_M6_86076_96060 0.204960
R20176 n1_M6_90060_96060 n1_M6_86076_96060 0.405040
R20177 n1_M6_90060_96060 n1_M6_90172_96060 0.011387
R20178 n1_M6_90172_96060 n1_M6_94268_96060 0.416427
R20179 n1_M6_96060_96060 n1_M6_94268_96060 0.182187
R20180 n1_M6_96060_96060 n1_M6_98364_96060 0.234240
R20181 n1_M6_102060_96060 n1_M6_98364_96060 0.375760
R20182 n1_M6_102060_96060 n1_M6_102460_96060 0.040667
R20183 n1_M6_102460_96060 n1_M6_106556_96060 0.416427
R20184 n1_M6_108060_96060 n1_M6_106556_96060 0.152907
R20185 n1_M6_108060_96060 n1_M6_110652_96060 0.263520
R20186 n1_M6_114060_96060 n1_M6_110652_96060 0.346480
R20187 n1_M6_114060_96060 n1_M6_114748_96060 0.069947
R20188 n1_M6_114748_96060 n1_M6_118844_96060 0.416427
R20189 n1_M6_120060_96060 n1_M6_118844_96060 0.123627
R20190 n1_M6_120060_96060 n1_M6_122940_96060 0.292800
R20191 n1_M6_126060_96060 n1_M6_122940_96060 0.317200
R20192 n1_M6_126060_96060 n1_M6_127036_96060 0.099227
R20193 n1_M6_127036_96060 n1_M6_131132_96060 0.416427
R20194 n1_M6_132060_96060 n1_M6_131132_96060 0.094347
R20195 n1_M6_132060_96060 n1_M6_135228_96060 0.322080
R20196 n1_M6_138060_96060 n1_M6_135228_96060 0.287920
R20197 n1_M6_138060_96060 n1_M6_139324_96060 0.128507
R20198 n1_M6_139324_96060 n1_M6_143420_96060 0.416427
R20199 n1_M6_144060_96060 n1_M6_143420_96060 0.065067
R20200 n1_M6_144060_96060 n1_M6_147516_96060 0.351360
R20201 n1_M6_60_108060 n1_M6_4156_108060 0.416427
R20202 n1_M6_6060_108060 n1_M6_4156_108060 0.193573
R20203 n1_M6_6060_108060 n1_M6_8252_108060 0.222853
R20204 n1_M6_12060_108060 n1_M6_8252_108060 0.387147
R20205 n1_M6_12060_108060 n1_M6_12348_108060 0.029280
R20206 n1_M6_12348_108060 n1_M6_16444_108060 0.416427
R20207 n1_M6_18060_108060 n1_M6_16444_108060 0.164293
R20208 n1_M6_18060_108060 n1_M6_20540_108060 0.252133
R20209 n1_M6_24060_108060 n1_M6_20540_108060 0.357867
R20210 n1_M6_24060_108060 n1_M6_24636_108060 0.058560
R20211 n1_M6_24636_108060 n1_M6_28732_108060 0.416427
R20212 n1_M6_30060_108060 n1_M6_28732_108060 0.135013
R20213 n1_M6_30060_108060 n1_M6_32828_108060 0.281413
R20214 n1_M6_36060_108060 n1_M6_32828_108060 0.328587
R20215 n1_M6_36060_108060 n1_M6_36924_108060 0.087840
R20216 n1_M6_36924_108060 n1_M6_41020_108060 0.416427
R20217 n1_M6_42060_108060 n1_M6_41020_108060 0.105733
R20218 n1_M6_42060_108060 n1_M6_45116_108060 0.310693
R20219 n1_M6_48060_108060 n1_M6_45116_108060 0.299307
R20220 n1_M6_48060_108060 n1_M6_49212_108060 0.117120
R20221 n1_M6_49212_108060 n1_M6_53308_108060 0.416427
R20222 n1_M6_54060_108060 n1_M6_53308_108060 0.076453
R20223 n1_M6_54060_108060 n1_M6_57404_108060 0.339973
R20224 n1_M6_60060_108060 n1_M6_57404_108060 0.270027
R20225 n1_M6_60060_108060 n1_M6_61500_108060 0.146400
R20226 n1_M6_61500_108060 n1_M6_65596_108060 0.416427
R20227 n1_M6_66060_108060 n1_M6_65596_108060 0.047173
R20228 n1_M6_66060_108060 n1_M6_69692_108060 0.369253
R20229 n1_M6_72060_108060 n1_M6_69692_108060 0.240747
R20230 n1_M6_72060_108060 n1_M6_73788_108060 0.175680
R20231 n1_M6_73788_108060 n1_M6_77884_108060 0.416427
R20232 n1_M6_78060_108060 n1_M6_77884_108060 0.017893
R20233 n1_M6_78060_108060 n1_M6_81980_108060 0.398533
R20234 n1_M6_84060_108060 n1_M6_81980_108060 0.211467
R20235 n1_M6_84060_108060 n1_M6_86076_108060 0.204960
R20236 n1_M6_90060_108060 n1_M6_86076_108060 0.405040
R20237 n1_M6_90060_108060 n1_M6_90172_108060 0.011387
R20238 n1_M6_90172_108060 n1_M6_94268_108060 0.416427
R20239 n1_M6_96060_108060 n1_M6_94268_108060 0.182187
R20240 n1_M6_96060_108060 n1_M6_98364_108060 0.234240
R20241 n1_M6_102060_108060 n1_M6_98364_108060 0.375760
R20242 n1_M6_102060_108060 n1_M6_102460_108060 0.040667
R20243 n1_M6_102460_108060 n1_M6_106556_108060 0.416427
R20244 n1_M6_108060_108060 n1_M6_106556_108060 0.152907
R20245 n1_M6_108060_108060 n1_M6_110652_108060 0.263520
R20246 n1_M6_114060_108060 n1_M6_110652_108060 0.346480
R20247 n1_M6_114060_108060 n1_M6_114748_108060 0.069947
R20248 n1_M6_114748_108060 n1_M6_118844_108060 0.416427
R20249 n1_M6_120060_108060 n1_M6_118844_108060 0.123627
R20250 n1_M6_120060_108060 n1_M6_122940_108060 0.292800
R20251 n1_M6_126060_108060 n1_M6_122940_108060 0.317200
R20252 n1_M6_126060_108060 n1_M6_127036_108060 0.099227
R20253 n1_M6_127036_108060 n1_M6_131132_108060 0.416427
R20254 n1_M6_132060_108060 n1_M6_131132_108060 0.094347
R20255 n1_M6_132060_108060 n1_M6_135228_108060 0.322080
R20256 n1_M6_138060_108060 n1_M6_135228_108060 0.287920
R20257 n1_M6_138060_108060 n1_M6_139324_108060 0.128507
R20258 n1_M6_139324_108060 n1_M6_143420_108060 0.416427
R20259 n1_M6_144060_108060 n1_M6_143420_108060 0.065067
R20260 n1_M6_144060_108060 n1_M6_147516_108060 0.351360
R20261 n1_M6_60_120060 n1_M6_4156_120060 0.416427
R20262 n1_M6_6060_120060 n1_M6_4156_120060 0.193573
R20263 n1_M6_6060_120060 n1_M6_8252_120060 0.222853
R20264 n1_M6_12060_120060 n1_M6_8252_120060 0.387147
R20265 n1_M6_12060_120060 n1_M6_12348_120060 0.029280
R20266 n1_M6_12348_120060 n1_M6_16444_120060 0.416427
R20267 n1_M6_18060_120060 n1_M6_16444_120060 0.164293
R20268 n1_M6_18060_120060 n1_M6_20540_120060 0.252133
R20269 n1_M6_24060_120060 n1_M6_20540_120060 0.357867
R20270 n1_M6_24060_120060 n1_M6_24636_120060 0.058560
R20271 n1_M6_24636_120060 n1_M6_28732_120060 0.416427
R20272 n1_M6_30060_120060 n1_M6_28732_120060 0.135013
R20273 n1_M6_30060_120060 n1_M6_32828_120060 0.281413
R20274 n1_M6_36060_120060 n1_M6_32828_120060 0.328587
R20275 n1_M6_36060_120060 n1_M6_36924_120060 0.087840
R20276 n1_M6_36924_120060 n1_M6_41020_120060 0.416427
R20277 n1_M6_42060_120060 n1_M6_41020_120060 0.105733
R20278 n1_M6_42060_120060 n1_M6_45116_120060 0.310693
R20279 n1_M6_48060_120060 n1_M6_45116_120060 0.299307
R20280 n1_M6_48060_120060 n1_M6_49212_120060 0.117120
R20281 n1_M6_49212_120060 n1_M6_53308_120060 0.416427
R20282 n1_M6_54060_120060 n1_M6_53308_120060 0.076453
R20283 n1_M6_54060_120060 n1_M6_57404_120060 0.339973
R20284 n1_M6_60060_120060 n1_M6_57404_120060 0.270027
R20285 n1_M6_60060_120060 n1_M6_61500_120060 0.146400
R20286 n1_M6_61500_120060 n1_M6_65596_120060 0.416427
R20287 n1_M6_66060_120060 n1_M6_65596_120060 0.047173
R20288 n1_M6_66060_120060 n1_M6_69692_120060 0.369253
R20289 n1_M6_72060_120060 n1_M6_69692_120060 0.240747
R20290 n1_M6_72060_120060 n1_M6_73788_120060 0.175680
R20291 n1_M6_73788_120060 n1_M6_77884_120060 0.416427
R20292 n1_M6_78060_120060 n1_M6_77884_120060 0.017893
R20293 n1_M6_78060_120060 n1_M6_81980_120060 0.398533
R20294 n1_M6_84060_120060 n1_M6_81980_120060 0.211467
R20295 n1_M6_84060_120060 n1_M6_86076_120060 0.204960
R20296 n1_M6_90060_120060 n1_M6_86076_120060 0.405040
R20297 n1_M6_90060_120060 n1_M6_90172_120060 0.011387
R20298 n1_M6_90172_120060 n1_M6_94268_120060 0.416427
R20299 n1_M6_96060_120060 n1_M6_94268_120060 0.182187
R20300 n1_M6_96060_120060 n1_M6_98364_120060 0.234240
R20301 n1_M6_102060_120060 n1_M6_98364_120060 0.375760
R20302 n1_M6_102060_120060 n1_M6_102460_120060 0.040667
R20303 n1_M6_102460_120060 n1_M6_106556_120060 0.416427
R20304 n1_M6_108060_120060 n1_M6_106556_120060 0.152907
R20305 n1_M6_108060_120060 n1_M6_110652_120060 0.263520
R20306 n1_M6_114060_120060 n1_M6_110652_120060 0.346480
R20307 n1_M6_114060_120060 n1_M6_114748_120060 0.069947
R20308 n1_M6_114748_120060 n1_M6_118844_120060 0.416427
R20309 n1_M6_120060_120060 n1_M6_118844_120060 0.123627
R20310 n1_M6_120060_120060 n1_M6_122940_120060 0.292800
R20311 n1_M6_126060_120060 n1_M6_122940_120060 0.317200
R20312 n1_M6_126060_120060 n1_M6_127036_120060 0.099227
R20313 n1_M6_127036_120060 n1_M6_131132_120060 0.416427
R20314 n1_M6_132060_120060 n1_M6_131132_120060 0.094347
R20315 n1_M6_132060_120060 n1_M6_135228_120060 0.322080
R20316 n1_M6_138060_120060 n1_M6_135228_120060 0.287920
R20317 n1_M6_138060_120060 n1_M6_139324_120060 0.128507
R20318 n1_M6_139324_120060 n1_M6_143420_120060 0.416427
R20319 n1_M6_144060_120060 n1_M6_143420_120060 0.065067
R20320 n1_M6_144060_120060 n1_M6_147516_120060 0.351360
R20321 n1_M6_60_132060 n1_M6_4156_132060 0.416427
R20322 n1_M6_6060_132060 n1_M6_4156_132060 0.193573
R20323 n1_M6_6060_132060 n1_M6_8252_132060 0.222853
R20324 n1_M6_12060_132060 n1_M6_8252_132060 0.387147
R20325 n1_M6_12060_132060 n1_M6_12348_132060 0.029280
R20326 n1_M6_12348_132060 n1_M6_16444_132060 0.416427
R20327 n1_M6_18060_132060 n1_M6_16444_132060 0.164293
R20328 n1_M6_18060_132060 n1_M6_20540_132060 0.252133
R20329 n1_M6_24060_132060 n1_M6_20540_132060 0.357867
R20330 n1_M6_24060_132060 n1_M6_24636_132060 0.058560
R20331 n1_M6_24636_132060 n1_M6_28732_132060 0.416427
R20332 n1_M6_30060_132060 n1_M6_28732_132060 0.135013
R20333 n1_M6_30060_132060 n1_M6_32828_132060 0.281413
R20334 n1_M6_36060_132060 n1_M6_32828_132060 0.328587
R20335 n1_M6_36060_132060 n1_M6_36924_132060 0.087840
R20336 n1_M6_36924_132060 n1_M6_41020_132060 0.416427
R20337 n1_M6_42060_132060 n1_M6_41020_132060 0.105733
R20338 n1_M6_42060_132060 n1_M6_45116_132060 0.310693
R20339 n1_M6_48060_132060 n1_M6_45116_132060 0.299307
R20340 n1_M6_48060_132060 n1_M6_49212_132060 0.117120
R20341 n1_M6_49212_132060 n1_M6_53308_132060 0.416427
R20342 n1_M6_54060_132060 n1_M6_53308_132060 0.076453
R20343 n1_M6_54060_132060 n1_M6_57404_132060 0.339973
R20344 n1_M6_60060_132060 n1_M6_57404_132060 0.270027
R20345 n1_M6_60060_132060 n1_M6_61500_132060 0.146400
R20346 n1_M6_61500_132060 n1_M6_65596_132060 0.416427
R20347 n1_M6_66060_132060 n1_M6_65596_132060 0.047173
R20348 n1_M6_66060_132060 n1_M6_69692_132060 0.369253
R20349 n1_M6_72060_132060 n1_M6_69692_132060 0.240747
R20350 n1_M6_72060_132060 n1_M6_73788_132060 0.175680
R20351 n1_M6_73788_132060 n1_M6_77884_132060 0.416427
R20352 n1_M6_78060_132060 n1_M6_77884_132060 0.017893
R20353 n1_M6_78060_132060 n1_M6_81980_132060 0.398533
R20354 n1_M6_84060_132060 n1_M6_81980_132060 0.211467
R20355 n1_M6_84060_132060 n1_M6_86076_132060 0.204960
R20356 n1_M6_90060_132060 n1_M6_86076_132060 0.405040
R20357 n1_M6_90060_132060 n1_M6_90172_132060 0.011387
R20358 n1_M6_90172_132060 n1_M6_94268_132060 0.416427
R20359 n1_M6_96060_132060 n1_M6_94268_132060 0.182187
R20360 n1_M6_96060_132060 n1_M6_98364_132060 0.234240
R20361 n1_M6_102060_132060 n1_M6_98364_132060 0.375760
R20362 n1_M6_102060_132060 n1_M6_102460_132060 0.040667
R20363 n1_M6_102460_132060 n1_M6_106556_132060 0.416427
R20364 n1_M6_108060_132060 n1_M6_106556_132060 0.152907
R20365 n1_M6_108060_132060 n1_M6_110652_132060 0.263520
R20366 n1_M6_114060_132060 n1_M6_110652_132060 0.346480
R20367 n1_M6_114060_132060 n1_M6_114748_132060 0.069947
R20368 n1_M6_114748_132060 n1_M6_118844_132060 0.416427
R20369 n1_M6_120060_132060 n1_M6_118844_132060 0.123627
R20370 n1_M6_120060_132060 n1_M6_122940_132060 0.292800
R20371 n1_M6_126060_132060 n1_M6_122940_132060 0.317200
R20372 n1_M6_126060_132060 n1_M6_127036_132060 0.099227
R20373 n1_M6_127036_132060 n1_M6_131132_132060 0.416427
R20374 n1_M6_132060_132060 n1_M6_131132_132060 0.094347
R20375 n1_M6_132060_132060 n1_M6_135228_132060 0.322080
R20376 n1_M6_138060_132060 n1_M6_135228_132060 0.287920
R20377 n1_M6_138060_132060 n1_M6_139324_132060 0.128507
R20378 n1_M6_139324_132060 n1_M6_143420_132060 0.416427
R20379 n1_M6_144060_132060 n1_M6_143420_132060 0.065067
R20380 n1_M6_144060_132060 n1_M6_147516_132060 0.351360
R20381 n1_M6_60_144060 n1_M6_4156_144060 0.416427
R20382 n1_M6_6060_144060 n1_M6_4156_144060 0.193573
R20383 n1_M6_6060_144060 n1_M6_8252_144060 0.222853
R20384 n1_M6_12060_144060 n1_M6_8252_144060 0.387147
R20385 n1_M6_12060_144060 n1_M6_12348_144060 0.029280
R20386 n1_M6_12348_144060 n1_M6_16444_144060 0.416427
R20387 n1_M6_18060_144060 n1_M6_16444_144060 0.164293
R20388 n1_M6_18060_144060 n1_M6_20540_144060 0.252133
R20389 n1_M6_24060_144060 n1_M6_20540_144060 0.357867
R20390 n1_M6_24060_144060 n1_M6_24636_144060 0.058560
R20391 n1_M6_24636_144060 n1_M6_28732_144060 0.416427
R20392 n1_M6_30060_144060 n1_M6_28732_144060 0.135013
R20393 n1_M6_30060_144060 n1_M6_32828_144060 0.281413
R20394 n1_M6_36060_144060 n1_M6_32828_144060 0.328587
R20395 n1_M6_36060_144060 n1_M6_36924_144060 0.087840
R20396 n1_M6_36924_144060 n1_M6_41020_144060 0.416427
R20397 n1_M6_42060_144060 n1_M6_41020_144060 0.105733
R20398 n1_M6_42060_144060 n1_M6_45116_144060 0.310693
R20399 n1_M6_48060_144060 n1_M6_45116_144060 0.299307
R20400 n1_M6_48060_144060 n1_M6_49212_144060 0.117120
R20401 n1_M6_49212_144060 n1_M6_53308_144060 0.416427
R20402 n1_M6_54060_144060 n1_M6_53308_144060 0.076453
R20403 n1_M6_54060_144060 n1_M6_57404_144060 0.339973
R20404 n1_M6_60060_144060 n1_M6_57404_144060 0.270027
R20405 n1_M6_60060_144060 n1_M6_61500_144060 0.146400
R20406 n1_M6_61500_144060 n1_M6_65596_144060 0.416427
R20407 n1_M6_66060_144060 n1_M6_65596_144060 0.047173
R20408 n1_M6_66060_144060 n1_M6_69692_144060 0.369253
R20409 n1_M6_72060_144060 n1_M6_69692_144060 0.240747
R20410 n1_M6_72060_144060 n1_M6_73788_144060 0.175680
R20411 n1_M6_73788_144060 n1_M6_77884_144060 0.416427
R20412 n1_M6_78060_144060 n1_M6_77884_144060 0.017893
R20413 n1_M6_78060_144060 n1_M6_81980_144060 0.398533
R20414 n1_M6_84060_144060 n1_M6_81980_144060 0.211467
R20415 n1_M6_84060_144060 n1_M6_86076_144060 0.204960
R20416 n1_M6_90060_144060 n1_M6_86076_144060 0.405040
R20417 n1_M6_90060_144060 n1_M6_90172_144060 0.011387
R20418 n1_M6_90172_144060 n1_M6_94268_144060 0.416427
R20419 n1_M6_96060_144060 n1_M6_94268_144060 0.182187
R20420 n1_M6_96060_144060 n1_M6_98364_144060 0.234240
R20421 n1_M6_102060_144060 n1_M6_98364_144060 0.375760
R20422 n1_M6_102060_144060 n1_M6_102460_144060 0.040667
R20423 n1_M6_102460_144060 n1_M6_106556_144060 0.416427
R20424 n1_M6_108060_144060 n1_M6_106556_144060 0.152907
R20425 n1_M6_108060_144060 n1_M6_110652_144060 0.263520
R20426 n1_M6_114060_144060 n1_M6_110652_144060 0.346480
R20427 n1_M6_114060_144060 n1_M6_114748_144060 0.069947
R20428 n1_M6_114748_144060 n1_M6_118844_144060 0.416427
R20429 n1_M6_120060_144060 n1_M6_118844_144060 0.123627
R20430 n1_M6_120060_144060 n1_M6_122940_144060 0.292800
R20431 n1_M6_126060_144060 n1_M6_122940_144060 0.317200
R20432 n1_M6_126060_144060 n1_M6_127036_144060 0.099227
R20433 n1_M6_127036_144060 n1_M6_131132_144060 0.416427
R20434 n1_M6_132060_144060 n1_M6_131132_144060 0.094347
R20435 n1_M6_132060_144060 n1_M6_135228_144060 0.322080
R20436 n1_M6_138060_144060 n1_M6_135228_144060 0.287920
R20437 n1_M6_138060_144060 n1_M6_139324_144060 0.128507
R20438 n1_M6_139324_144060 n1_M6_143420_144060 0.416427
R20439 n1_M6_144060_144060 n1_M6_143420_144060 0.065067
R20440 n1_M6_144060_144060 n1_M6_147516_144060 0.351360
R20441 n1_M7_60_60 n1_M7_60_6460 0.366000
R20442 n1_M7_60_12060 n1_M7_60_6460 0.320250
R20443 n1_M7_60_12060 n1_M7_60_12860 0.045750
R20444 n1_M7_60_12860 n1_M7_60_19260 0.366000
R20445 n1_M7_60_24060 n1_M7_60_19260 0.274500
R20446 n1_M7_60_24060 n1_M7_60_25660 0.091500
R20447 n1_M7_60_25660 n1_M7_60_32060 0.366000
R20448 n1_M7_60_36060 n1_M7_60_32060 0.228750
R20449 n1_M7_60_36060 n1_M7_60_38460 0.137250
R20450 n1_M7_60_38460 n1_M7_60_44860 0.366000
R20451 n1_M7_60_48060 n1_M7_60_44860 0.183000
R20452 n1_M7_60_48060 n1_M7_60_51260 0.183000
R20453 n1_M7_60_51260 n1_M7_60_57660 0.366000
R20454 n1_M7_60_60060 n1_M7_60_57660 0.137250
R20455 n1_M7_60_60060 n1_M7_60_64060 0.228750
R20456 n1_M7_60_64060 n1_M7_60_70460 0.366000
R20457 n1_M7_60_72060 n1_M7_60_70460 0.091500
R20458 n1_M7_60_72060 n1_M7_60_76860 0.274500
R20459 n1_M7_60_76860 n1_M7_60_83260 0.366000
R20460 n1_M7_60_84060 n1_M7_60_83260 0.045750
R20461 n1_M7_60_84060 n1_M7_60_89660 0.320250
R20462 n1_M7_60_96060 n1_M7_60_89660 0.366000
R20463 n1_M7_60_96060 n1_M7_60_102460 0.366000
R20464 n1_M7_60_108060 n1_M7_60_102460 0.320250
R20465 n1_M7_60_108060 n1_M7_60_108860 0.045750
R20466 n1_M7_60_108860 n1_M7_60_115260 0.366000
R20467 n1_M7_60_120060 n1_M7_60_115260 0.274500
R20468 n1_M7_60_120060 n1_M7_60_121660 0.091500
R20469 n1_M7_60_121660 n1_M7_60_128060 0.366000
R20470 n1_M7_60_132060 n1_M7_60_128060 0.228750
R20471 n1_M7_60_132060 n1_M7_60_134460 0.137250
R20472 n1_M7_60_134460 n1_M7_60_140860 0.366000
R20473 n1_M7_60_144060 n1_M7_60_140860 0.183000
R20474 n1_M7_60_144060 n1_M7_60_147260 0.183000
R20475 n1_M7_4156_60 n1_M7_4156_6460 0.366000
R20476 n1_M7_4156_12060 n1_M7_4156_6460 0.320250
R20477 n1_M7_4156_12060 n1_M7_4156_12860 0.045750
R20478 n1_M7_4156_12860 n1_M7_4156_19260 0.366000
R20479 n1_M7_4156_24060 n1_M7_4156_19260 0.274500
R20480 n1_M7_4156_24060 n1_M7_4156_25660 0.091500
R20481 n1_M7_4156_25660 n1_M7_4156_32060 0.366000
R20482 n1_M7_4156_36060 n1_M7_4156_32060 0.228750
R20483 n1_M7_4156_36060 n1_M7_4156_38460 0.137250
R20484 n1_M7_4156_38460 n1_M7_4156_44860 0.366000
R20485 n1_M7_4156_48060 n1_M7_4156_44860 0.183000
R20486 n1_M7_4156_48060 n1_M7_4156_51260 0.183000
R20487 n1_M7_4156_51260 n1_M7_4156_57660 0.366000
R20488 n1_M7_4156_60060 n1_M7_4156_57660 0.137250
R20489 n1_M7_4156_60060 n1_M7_4156_64060 0.228750
R20490 n1_M7_4156_64060 n1_M7_4156_70460 0.366000
R20491 n1_M7_4156_72060 n1_M7_4156_70460 0.091500
R20492 n1_M7_4156_72060 n1_M7_4156_76860 0.274500
R20493 n1_M7_4156_76860 n1_M7_4156_83260 0.366000
R20494 n1_M7_4156_84060 n1_M7_4156_83260 0.045750
R20495 n1_M7_4156_84060 n1_M7_4156_89660 0.320250
R20496 n1_M7_4156_96060 n1_M7_4156_89660 0.366000
R20497 n1_M7_4156_96060 n1_M7_4156_102460 0.366000
R20498 n1_M7_4156_108060 n1_M7_4156_102460 0.320250
R20499 n1_M7_4156_108060 n1_M7_4156_108860 0.045750
R20500 n1_M7_4156_108860 n1_M7_4156_115260 0.366000
R20501 n1_M7_4156_120060 n1_M7_4156_115260 0.274500
R20502 n1_M7_4156_120060 n1_M7_4156_121660 0.091500
R20503 n1_M7_4156_121660 n1_M7_4156_128060 0.366000
R20504 n1_M7_4156_132060 n1_M7_4156_128060 0.228750
R20505 n1_M7_4156_132060 n1_M7_4156_134460 0.137250
R20506 n1_M7_4156_134460 n1_M7_4156_140860 0.366000
R20507 n1_M7_4156_144060 n1_M7_4156_140860 0.183000
R20508 n1_M7_4156_144060 n1_M7_4156_147260 0.183000
R20509 n1_M7_8252_60 n1_M7_8252_6460 0.366000
R20510 n1_M7_8252_12060 n1_M7_8252_6460 0.320250
R20511 n1_M7_8252_12060 n1_M7_8252_12860 0.045750
R20512 n1_M7_8252_12860 n1_M7_8252_19260 0.366000
R20513 n1_M7_8252_24060 n1_M7_8252_19260 0.274500
R20514 n1_M7_8252_24060 n1_M7_8252_25660 0.091500
R20515 n1_M7_8252_25660 n1_M7_8252_32060 0.366000
R20516 n1_M7_8252_36060 n1_M7_8252_32060 0.228750
R20517 n1_M7_8252_36060 n1_M7_8252_38460 0.137250
R20518 n1_M7_8252_38460 n1_M7_8252_44860 0.366000
R20519 n1_M7_8252_48060 n1_M7_8252_44860 0.183000
R20520 n1_M7_8252_48060 n1_M7_8252_51260 0.183000
R20521 n1_M7_8252_51260 n1_M7_8252_57660 0.366000
R20522 n1_M7_8252_60060 n1_M7_8252_57660 0.137250
R20523 n1_M7_8252_60060 n1_M7_8252_64060 0.228750
R20524 n1_M7_8252_64060 n1_M7_8252_70460 0.366000
R20525 n1_M7_8252_72060 n1_M7_8252_70460 0.091500
R20526 n1_M7_8252_72060 n1_M7_8252_76860 0.274500
R20527 n1_M7_8252_76860 n1_M7_8252_83260 0.366000
R20528 n1_M7_8252_84060 n1_M7_8252_83260 0.045750
R20529 n1_M7_8252_84060 n1_M7_8252_89660 0.320250
R20530 n1_M7_8252_96060 n1_M7_8252_89660 0.366000
R20531 n1_M7_8252_96060 n1_M7_8252_102460 0.366000
R20532 n1_M7_8252_108060 n1_M7_8252_102460 0.320250
R20533 n1_M7_8252_108060 n1_M7_8252_108860 0.045750
R20534 n1_M7_8252_108860 n1_M7_8252_115260 0.366000
R20535 n1_M7_8252_120060 n1_M7_8252_115260 0.274500
R20536 n1_M7_8252_120060 n1_M7_8252_121660 0.091500
R20537 n1_M7_8252_121660 n1_M7_8252_128060 0.366000
R20538 n1_M7_8252_132060 n1_M7_8252_128060 0.228750
R20539 n1_M7_8252_132060 n1_M7_8252_134460 0.137250
R20540 n1_M7_8252_134460 n1_M7_8252_140860 0.366000
R20541 n1_M7_8252_144060 n1_M7_8252_140860 0.183000
R20542 n1_M7_8252_144060 n1_M7_8252_147260 0.183000
R20543 n1_M7_12348_60 n1_M7_12348_6460 0.366000
R20544 n1_M7_12348_12060 n1_M7_12348_6460 0.320250
R20545 n1_M7_12348_12060 n1_M7_12348_12860 0.045750
R20546 n1_M7_12348_12860 n1_M7_12348_19260 0.366000
R20547 n1_M7_12348_24060 n1_M7_12348_19260 0.274500
R20548 n1_M7_12348_24060 n1_M7_12348_25660 0.091500
R20549 n1_M7_12348_25660 n1_M7_12348_32060 0.366000
R20550 n1_M7_12348_36060 n1_M7_12348_32060 0.228750
R20551 n1_M7_12348_36060 n1_M7_12348_38460 0.137250
R20552 n1_M7_12348_38460 n1_M7_12348_44860 0.366000
R20553 n1_M7_12348_48060 n1_M7_12348_44860 0.183000
R20554 n1_M7_12348_48060 n1_M7_12348_51260 0.183000
R20555 n1_M7_12348_51260 n1_M7_12348_57660 0.366000
R20556 n1_M7_12348_60060 n1_M7_12348_57660 0.137250
R20557 n1_M7_12348_60060 n1_M7_12348_64060 0.228750
R20558 n1_M7_12348_64060 n1_M7_12348_70460 0.366000
R20559 n1_M7_12348_72060 n1_M7_12348_70460 0.091500
R20560 n1_M7_12348_72060 n1_M7_12348_76860 0.274500
R20561 n1_M7_12348_76860 n1_M7_12348_83260 0.366000
R20562 n1_M7_12348_84060 n1_M7_12348_83260 0.045750
R20563 n1_M7_12348_84060 n1_M7_12348_89660 0.320250
R20564 n1_M7_12348_96060 n1_M7_12348_89660 0.366000
R20565 n1_M7_12348_96060 n1_M7_12348_102460 0.366000
R20566 n1_M7_12348_108060 n1_M7_12348_102460 0.320250
R20567 n1_M7_12348_108060 n1_M7_12348_108860 0.045750
R20568 n1_M7_12348_108860 n1_M7_12348_115260 0.366000
R20569 n1_M7_12348_120060 n1_M7_12348_115260 0.274500
R20570 n1_M7_12348_120060 n1_M7_12348_121660 0.091500
R20571 n1_M7_12348_121660 n1_M7_12348_128060 0.366000
R20572 n1_M7_12348_132060 n1_M7_12348_128060 0.228750
R20573 n1_M7_12348_132060 n1_M7_12348_134460 0.137250
R20574 n1_M7_12348_134460 n1_M7_12348_140860 0.366000
R20575 n1_M7_12348_144060 n1_M7_12348_140860 0.183000
R20576 n1_M7_12348_144060 n1_M7_12348_147260 0.183000
R20577 n1_M7_16444_60 n1_M7_16444_6460 0.366000
R20578 n1_M7_16444_12060 n1_M7_16444_6460 0.320250
R20579 n1_M7_16444_12060 n1_M7_16444_12860 0.045750
R20580 n1_M7_16444_12860 n1_M7_16444_19260 0.366000
R20581 n1_M7_16444_24060 n1_M7_16444_19260 0.274500
R20582 n1_M7_16444_24060 n1_M7_16444_25660 0.091500
R20583 n1_M7_16444_25660 n1_M7_16444_32060 0.366000
R20584 n1_M7_16444_36060 n1_M7_16444_32060 0.228750
R20585 n1_M7_16444_36060 n1_M7_16444_38460 0.137250
R20586 n1_M7_16444_38460 n1_M7_16444_44860 0.366000
R20587 n1_M7_16444_48060 n1_M7_16444_44860 0.183000
R20588 n1_M7_16444_48060 n1_M7_16444_51260 0.183000
R20589 n1_M7_16444_51260 n1_M7_16444_57660 0.366000
R20590 n1_M7_16444_60060 n1_M7_16444_57660 0.137250
R20591 n1_M7_16444_60060 n1_M7_16444_64060 0.228750
R20592 n1_M7_16444_64060 n1_M7_16444_70460 0.366000
R20593 n1_M7_16444_72060 n1_M7_16444_70460 0.091500
R20594 n1_M7_16444_72060 n1_M7_16444_76860 0.274500
R20595 n1_M7_16444_76860 n1_M7_16444_83260 0.366000
R20596 n1_M7_16444_84060 n1_M7_16444_83260 0.045750
R20597 n1_M7_16444_84060 n1_M7_16444_89660 0.320250
R20598 n1_M7_16444_96060 n1_M7_16444_89660 0.366000
R20599 n1_M7_16444_96060 n1_M7_16444_102460 0.366000
R20600 n1_M7_16444_108060 n1_M7_16444_102460 0.320250
R20601 n1_M7_16444_108060 n1_M7_16444_108860 0.045750
R20602 n1_M7_16444_108860 n1_M7_16444_115260 0.366000
R20603 n1_M7_16444_120060 n1_M7_16444_115260 0.274500
R20604 n1_M7_16444_120060 n1_M7_16444_121660 0.091500
R20605 n1_M7_16444_121660 n1_M7_16444_128060 0.366000
R20606 n1_M7_16444_132060 n1_M7_16444_128060 0.228750
R20607 n1_M7_16444_132060 n1_M7_16444_134460 0.137250
R20608 n1_M7_16444_134460 n1_M7_16444_140860 0.366000
R20609 n1_M7_16444_144060 n1_M7_16444_140860 0.183000
R20610 n1_M7_16444_144060 n1_M7_16444_147260 0.183000
R20611 n1_M7_20540_60 n1_M7_20540_6460 0.366000
R20612 n1_M7_20540_12060 n1_M7_20540_6460 0.320250
R20613 n1_M7_20540_12060 n1_M7_20540_12860 0.045750
R20614 n1_M7_20540_12860 n1_M7_20540_19260 0.366000
R20615 n1_M7_20540_24060 n1_M7_20540_19260 0.274500
R20616 n1_M7_20540_24060 n1_M7_20540_25660 0.091500
R20617 n1_M7_20540_25660 n1_M7_20540_32060 0.366000
R20618 n1_M7_20540_36060 n1_M7_20540_32060 0.228750
R20619 n1_M7_20540_36060 n1_M7_20540_38460 0.137250
R20620 n1_M7_20540_38460 n1_M7_20540_44860 0.366000
R20621 n1_M7_20540_48060 n1_M7_20540_44860 0.183000
R20622 n1_M7_20540_48060 n1_M7_20540_51260 0.183000
R20623 n1_M7_20540_51260 n1_M7_20540_57660 0.366000
R20624 n1_M7_20540_60060 n1_M7_20540_57660 0.137250
R20625 n1_M7_20540_60060 n1_M7_20540_64060 0.228750
R20626 n1_M7_20540_64060 n1_M7_20540_70460 0.366000
R20627 n1_M7_20540_72060 n1_M7_20540_70460 0.091500
R20628 n1_M7_20540_72060 n1_M7_20540_76860 0.274500
R20629 n1_M7_20540_76860 n1_M7_20540_83260 0.366000
R20630 n1_M7_20540_84060 n1_M7_20540_83260 0.045750
R20631 n1_M7_20540_84060 n1_M7_20540_89660 0.320250
R20632 n1_M7_20540_96060 n1_M7_20540_89660 0.366000
R20633 n1_M7_20540_96060 n1_M7_20540_102460 0.366000
R20634 n1_M7_20540_108060 n1_M7_20540_102460 0.320250
R20635 n1_M7_20540_108060 n1_M7_20540_108860 0.045750
R20636 n1_M7_20540_108860 n1_M7_20540_115260 0.366000
R20637 n1_M7_20540_120060 n1_M7_20540_115260 0.274500
R20638 n1_M7_20540_120060 n1_M7_20540_121660 0.091500
R20639 n1_M7_20540_121660 n1_M7_20540_128060 0.366000
R20640 n1_M7_20540_132060 n1_M7_20540_128060 0.228750
R20641 n1_M7_20540_132060 n1_M7_20540_134460 0.137250
R20642 n1_M7_20540_134460 n1_M7_20540_140860 0.366000
R20643 n1_M7_20540_144060 n1_M7_20540_140860 0.183000
R20644 n1_M7_20540_144060 n1_M7_20540_147260 0.183000
R20645 n1_M7_24636_60 n1_M7_24636_6460 0.366000
R20646 n1_M7_24636_12060 n1_M7_24636_6460 0.320250
R20647 n1_M7_24636_12060 n1_M7_24636_12860 0.045750
R20648 n1_M7_24636_12860 n1_M7_24636_19260 0.366000
R20649 n1_M7_24636_24060 n1_M7_24636_19260 0.274500
R20650 n1_M7_24636_24060 n1_M7_24636_25660 0.091500
R20651 n1_M7_24636_25660 n1_M7_24636_32060 0.366000
R20652 n1_M7_24636_36060 n1_M7_24636_32060 0.228750
R20653 n1_M7_24636_36060 n1_M7_24636_38460 0.137250
R20654 n1_M7_24636_38460 n1_M7_24636_44860 0.366000
R20655 n1_M7_24636_48060 n1_M7_24636_44860 0.183000
R20656 n1_M7_24636_48060 n1_M7_24636_51260 0.183000
R20657 n1_M7_24636_51260 n1_M7_24636_57660 0.366000
R20658 n1_M7_24636_60060 n1_M7_24636_57660 0.137250
R20659 n1_M7_24636_60060 n1_M7_24636_64060 0.228750
R20660 n1_M7_24636_64060 n1_M7_24636_70460 0.366000
R20661 n1_M7_24636_72060 n1_M7_24636_70460 0.091500
R20662 n1_M7_24636_72060 n1_M7_24636_76860 0.274500
R20663 n1_M7_24636_76860 n1_M7_24636_83260 0.366000
R20664 n1_M7_24636_84060 n1_M7_24636_83260 0.045750
R20665 n1_M7_24636_84060 n1_M7_24636_89660 0.320250
R20666 n1_M7_24636_96060 n1_M7_24636_89660 0.366000
R20667 n1_M7_24636_96060 n1_M7_24636_102460 0.366000
R20668 n1_M7_24636_108060 n1_M7_24636_102460 0.320250
R20669 n1_M7_24636_108060 n1_M7_24636_108860 0.045750
R20670 n1_M7_24636_108860 n1_M7_24636_115260 0.366000
R20671 n1_M7_24636_120060 n1_M7_24636_115260 0.274500
R20672 n1_M7_24636_120060 n1_M7_24636_121660 0.091500
R20673 n1_M7_24636_121660 n1_M7_24636_128060 0.366000
R20674 n1_M7_24636_132060 n1_M7_24636_128060 0.228750
R20675 n1_M7_24636_132060 n1_M7_24636_134460 0.137250
R20676 n1_M7_24636_134460 n1_M7_24636_140860 0.366000
R20677 n1_M7_24636_144060 n1_M7_24636_140860 0.183000
R20678 n1_M7_24636_144060 n1_M7_24636_147260 0.183000
R20679 n1_M7_28732_60 n1_M7_28732_6460 0.366000
R20680 n1_M7_28732_12060 n1_M7_28732_6460 0.320250
R20681 n1_M7_28732_12060 n1_M7_28732_12860 0.045750
R20682 n1_M7_28732_12860 n1_M7_28732_19260 0.366000
R20683 n1_M7_28732_24060 n1_M7_28732_19260 0.274500
R20684 n1_M7_28732_24060 n1_M7_28732_25660 0.091500
R20685 n1_M7_28732_25660 n1_M7_28732_32060 0.366000
R20686 n1_M7_28732_36060 n1_M7_28732_32060 0.228750
R20687 n1_M7_28732_36060 n1_M7_28732_38460 0.137250
R20688 n1_M7_28732_38460 n1_M7_28732_44860 0.366000
R20689 n1_M7_28732_48060 n1_M7_28732_44860 0.183000
R20690 n1_M7_28732_48060 n1_M7_28732_51260 0.183000
R20691 n1_M7_28732_51260 n1_M7_28732_57660 0.366000
R20692 n1_M7_28732_60060 n1_M7_28732_57660 0.137250
R20693 n1_M7_28732_60060 n1_M7_28732_64060 0.228750
R20694 n1_M7_28732_64060 n1_M7_28732_70460 0.366000
R20695 n1_M7_28732_72060 n1_M7_28732_70460 0.091500
R20696 n1_M7_28732_72060 n1_M7_28732_76860 0.274500
R20697 n1_M7_28732_76860 n1_M7_28732_83260 0.366000
R20698 n1_M7_28732_84060 n1_M7_28732_83260 0.045750
R20699 n1_M7_28732_84060 n1_M7_28732_89660 0.320250
R20700 n1_M7_28732_96060 n1_M7_28732_89660 0.366000
R20701 n1_M7_28732_96060 n1_M7_28732_102460 0.366000
R20702 n1_M7_28732_108060 n1_M7_28732_102460 0.320250
R20703 n1_M7_28732_108060 n1_M7_28732_108860 0.045750
R20704 n1_M7_28732_108860 n1_M7_28732_115260 0.366000
R20705 n1_M7_28732_120060 n1_M7_28732_115260 0.274500
R20706 n1_M7_28732_120060 n1_M7_28732_121660 0.091500
R20707 n1_M7_28732_121660 n1_M7_28732_128060 0.366000
R20708 n1_M7_28732_132060 n1_M7_28732_128060 0.228750
R20709 n1_M7_28732_132060 n1_M7_28732_134460 0.137250
R20710 n1_M7_28732_134460 n1_M7_28732_140860 0.366000
R20711 n1_M7_28732_144060 n1_M7_28732_140860 0.183000
R20712 n1_M7_28732_144060 n1_M7_28732_147260 0.183000
R20713 n1_M7_32828_60 n1_M7_32828_6460 0.366000
R20714 n1_M7_32828_12060 n1_M7_32828_6460 0.320250
R20715 n1_M7_32828_12060 n1_M7_32828_12860 0.045750
R20716 n1_M7_32828_12860 n1_M7_32828_19260 0.366000
R20717 n1_M7_32828_24060 n1_M7_32828_19260 0.274500
R20718 n1_M7_32828_24060 n1_M7_32828_25660 0.091500
R20719 n1_M7_32828_25660 n1_M7_32828_32060 0.366000
R20720 n1_M7_32828_36060 n1_M7_32828_32060 0.228750
R20721 n1_M7_32828_36060 n1_M7_32828_38460 0.137250
R20722 n1_M7_32828_38460 n1_M7_32828_44860 0.366000
R20723 n1_M7_32828_48060 n1_M7_32828_44860 0.183000
R20724 n1_M7_32828_48060 n1_M7_32828_51260 0.183000
R20725 n1_M7_32828_51260 n1_M7_32828_57660 0.366000
R20726 n1_M7_32828_60060 n1_M7_32828_57660 0.137250
R20727 n1_M7_32828_60060 n1_M7_32828_64060 0.228750
R20728 n1_M7_32828_64060 n1_M7_32828_70460 0.366000
R20729 n1_M7_32828_72060 n1_M7_32828_70460 0.091500
R20730 n1_M7_32828_72060 n1_M7_32828_76860 0.274500
R20731 n1_M7_32828_76860 n1_M7_32828_83260 0.366000
R20732 n1_M7_32828_84060 n1_M7_32828_83260 0.045750
R20733 n1_M7_32828_84060 n1_M7_32828_89660 0.320250
R20734 n1_M7_32828_96060 n1_M7_32828_89660 0.366000
R20735 n1_M7_32828_96060 n1_M7_32828_102460 0.366000
R20736 n1_M7_32828_108060 n1_M7_32828_102460 0.320250
R20737 n1_M7_32828_108060 n1_M7_32828_108860 0.045750
R20738 n1_M7_32828_108860 n1_M7_32828_115260 0.366000
R20739 n1_M7_32828_120060 n1_M7_32828_115260 0.274500
R20740 n1_M7_32828_120060 n1_M7_32828_121660 0.091500
R20741 n1_M7_32828_121660 n1_M7_32828_128060 0.366000
R20742 n1_M7_32828_132060 n1_M7_32828_128060 0.228750
R20743 n1_M7_32828_132060 n1_M7_32828_134460 0.137250
R20744 n1_M7_32828_134460 n1_M7_32828_140860 0.366000
R20745 n1_M7_32828_144060 n1_M7_32828_140860 0.183000
R20746 n1_M7_32828_144060 n1_M7_32828_147260 0.183000
R20747 n1_M7_36924_60 n1_M7_36924_6460 0.366000
R20748 n1_M7_36924_12060 n1_M7_36924_6460 0.320250
R20749 n1_M7_36924_12060 n1_M7_36924_12860 0.045750
R20750 n1_M7_36924_12860 n1_M7_36924_19260 0.366000
R20751 n1_M7_36924_24060 n1_M7_36924_19260 0.274500
R20752 n1_M7_36924_24060 n1_M7_36924_25660 0.091500
R20753 n1_M7_36924_25660 n1_M7_36924_32060 0.366000
R20754 n1_M7_36924_36060 n1_M7_36924_32060 0.228750
R20755 n1_M7_36924_36060 n1_M7_36924_38460 0.137250
R20756 n1_M7_36924_38460 n1_M7_36924_44860 0.366000
R20757 n1_M7_36924_48060 n1_M7_36924_44860 0.183000
R20758 n1_M7_36924_48060 n1_M7_36924_51260 0.183000
R20759 n1_M7_36924_51260 n1_M7_36924_57660 0.366000
R20760 n1_M7_36924_60060 n1_M7_36924_57660 0.137250
R20761 n1_M7_36924_60060 n1_M7_36924_64060 0.228750
R20762 n1_M7_36924_64060 n1_M7_36924_70460 0.366000
R20763 n1_M7_36924_72060 n1_M7_36924_70460 0.091500
R20764 n1_M7_36924_72060 n1_M7_36924_76860 0.274500
R20765 n1_M7_36924_76860 n1_M7_36924_83260 0.366000
R20766 n1_M7_36924_84060 n1_M7_36924_83260 0.045750
R20767 n1_M7_36924_84060 n1_M7_36924_89660 0.320250
R20768 n1_M7_36924_96060 n1_M7_36924_89660 0.366000
R20769 n1_M7_36924_96060 n1_M7_36924_102460 0.366000
R20770 n1_M7_36924_108060 n1_M7_36924_102460 0.320250
R20771 n1_M7_36924_108060 n1_M7_36924_108860 0.045750
R20772 n1_M7_36924_108860 n1_M7_36924_115260 0.366000
R20773 n1_M7_36924_120060 n1_M7_36924_115260 0.274500
R20774 n1_M7_36924_120060 n1_M7_36924_121660 0.091500
R20775 n1_M7_36924_121660 n1_M7_36924_128060 0.366000
R20776 n1_M7_36924_132060 n1_M7_36924_128060 0.228750
R20777 n1_M7_36924_132060 n1_M7_36924_134460 0.137250
R20778 n1_M7_36924_134460 n1_M7_36924_140860 0.366000
R20779 n1_M7_36924_144060 n1_M7_36924_140860 0.183000
R20780 n1_M7_36924_144060 n1_M7_36924_147260 0.183000
R20781 n1_M7_41020_60 n1_M7_41020_6460 0.366000
R20782 n1_M7_41020_12060 n1_M7_41020_6460 0.320250
R20783 n1_M7_41020_12060 n1_M7_41020_12860 0.045750
R20784 n1_M7_41020_12860 n1_M7_41020_19260 0.366000
R20785 n1_M7_41020_24060 n1_M7_41020_19260 0.274500
R20786 n1_M7_41020_24060 n1_M7_41020_25660 0.091500
R20787 n1_M7_41020_25660 n1_M7_41020_32060 0.366000
R20788 n1_M7_41020_36060 n1_M7_41020_32060 0.228750
R20789 n1_M7_41020_36060 n1_M7_41020_38460 0.137250
R20790 n1_M7_41020_38460 n1_M7_41020_44860 0.366000
R20791 n1_M7_41020_48060 n1_M7_41020_44860 0.183000
R20792 n1_M7_41020_48060 n1_M7_41020_51260 0.183000
R20793 n1_M7_41020_51260 n1_M7_41020_57660 0.366000
R20794 n1_M7_41020_60060 n1_M7_41020_57660 0.137250
R20795 n1_M7_41020_60060 n1_M7_41020_64060 0.228750
R20796 n1_M7_41020_64060 n1_M7_41020_70460 0.366000
R20797 n1_M7_41020_72060 n1_M7_41020_70460 0.091500
R20798 n1_M7_41020_72060 n1_M7_41020_76860 0.274500
R20799 n1_M7_41020_76860 n1_M7_41020_83260 0.366000
R20800 n1_M7_41020_84060 n1_M7_41020_83260 0.045750
R20801 n1_M7_41020_84060 n1_M7_41020_89660 0.320250
R20802 n1_M7_41020_96060 n1_M7_41020_89660 0.366000
R20803 n1_M7_41020_96060 n1_M7_41020_102460 0.366000
R20804 n1_M7_41020_108060 n1_M7_41020_102460 0.320250
R20805 n1_M7_41020_108060 n1_M7_41020_108860 0.045750
R20806 n1_M7_41020_108860 n1_M7_41020_115260 0.366000
R20807 n1_M7_41020_120060 n1_M7_41020_115260 0.274500
R20808 n1_M7_41020_120060 n1_M7_41020_121660 0.091500
R20809 n1_M7_41020_121660 n1_M7_41020_128060 0.366000
R20810 n1_M7_41020_132060 n1_M7_41020_128060 0.228750
R20811 n1_M7_41020_132060 n1_M7_41020_134460 0.137250
R20812 n1_M7_41020_134460 n1_M7_41020_140860 0.366000
R20813 n1_M7_41020_144060 n1_M7_41020_140860 0.183000
R20814 n1_M7_41020_144060 n1_M7_41020_147260 0.183000
R20815 n1_M7_45116_60 n1_M7_45116_6460 0.366000
R20816 n1_M7_45116_12060 n1_M7_45116_6460 0.320250
R20817 n1_M7_45116_12060 n1_M7_45116_12860 0.045750
R20818 n1_M7_45116_12860 n1_M7_45116_19260 0.366000
R20819 n1_M7_45116_24060 n1_M7_45116_19260 0.274500
R20820 n1_M7_45116_24060 n1_M7_45116_25660 0.091500
R20821 n1_M7_45116_25660 n1_M7_45116_32060 0.366000
R20822 n1_M7_45116_36060 n1_M7_45116_32060 0.228750
R20823 n1_M7_45116_36060 n1_M7_45116_38460 0.137250
R20824 n1_M7_45116_38460 n1_M7_45116_44860 0.366000
R20825 n1_M7_45116_48060 n1_M7_45116_44860 0.183000
R20826 n1_M7_45116_48060 n1_M7_45116_51260 0.183000
R20827 n1_M7_45116_51260 n1_M7_45116_57660 0.366000
R20828 n1_M7_45116_60060 n1_M7_45116_57660 0.137250
R20829 n1_M7_45116_60060 n1_M7_45116_64060 0.228750
R20830 n1_M7_45116_64060 n1_M7_45116_70460 0.366000
R20831 n1_M7_45116_72060 n1_M7_45116_70460 0.091500
R20832 n1_M7_45116_72060 n1_M7_45116_76860 0.274500
R20833 n1_M7_45116_76860 n1_M7_45116_83260 0.366000
R20834 n1_M7_45116_84060 n1_M7_45116_83260 0.045750
R20835 n1_M7_45116_84060 n1_M7_45116_89660 0.320250
R20836 n1_M7_45116_96060 n1_M7_45116_89660 0.366000
R20837 n1_M7_45116_96060 n1_M7_45116_102460 0.366000
R20838 n1_M7_45116_108060 n1_M7_45116_102460 0.320250
R20839 n1_M7_45116_108060 n1_M7_45116_108860 0.045750
R20840 n1_M7_45116_108860 n1_M7_45116_115260 0.366000
R20841 n1_M7_45116_120060 n1_M7_45116_115260 0.274500
R20842 n1_M7_45116_120060 n1_M7_45116_121660 0.091500
R20843 n1_M7_45116_121660 n1_M7_45116_128060 0.366000
R20844 n1_M7_45116_132060 n1_M7_45116_128060 0.228750
R20845 n1_M7_45116_132060 n1_M7_45116_134460 0.137250
R20846 n1_M7_45116_134460 n1_M7_45116_140860 0.366000
R20847 n1_M7_45116_144060 n1_M7_45116_140860 0.183000
R20848 n1_M7_45116_144060 n1_M7_45116_147260 0.183000
R20849 n1_M7_49212_60 n1_M7_49212_6460 0.366000
R20850 n1_M7_49212_12060 n1_M7_49212_6460 0.320250
R20851 n1_M7_49212_12060 n1_M7_49212_12860 0.045750
R20852 n1_M7_49212_12860 n1_M7_49212_19260 0.366000
R20853 n1_M7_49212_24060 n1_M7_49212_19260 0.274500
R20854 n1_M7_49212_24060 n1_M7_49212_25660 0.091500
R20855 n1_M7_49212_25660 n1_M7_49212_32060 0.366000
R20856 n1_M7_49212_36060 n1_M7_49212_32060 0.228750
R20857 n1_M7_49212_36060 n1_M7_49212_38460 0.137250
R20858 n1_M7_49212_38460 n1_M7_49212_44860 0.366000
R20859 n1_M7_49212_48060 n1_M7_49212_44860 0.183000
R20860 n1_M7_49212_48060 n1_M7_49212_51260 0.183000
R20861 n1_M7_49212_51260 n1_M7_49212_57660 0.366000
R20862 n1_M7_49212_60060 n1_M7_49212_57660 0.137250
R20863 n1_M7_49212_60060 n1_M7_49212_64060 0.228750
R20864 n1_M7_49212_64060 n1_M7_49212_70460 0.366000
R20865 n1_M7_49212_72060 n1_M7_49212_70460 0.091500
R20866 n1_M7_49212_72060 n1_M7_49212_76860 0.274500
R20867 n1_M7_49212_76860 n1_M7_49212_83260 0.366000
R20868 n1_M7_49212_84060 n1_M7_49212_83260 0.045750
R20869 n1_M7_49212_84060 n1_M7_49212_89660 0.320250
R20870 n1_M7_49212_96060 n1_M7_49212_89660 0.366000
R20871 n1_M7_49212_96060 n1_M7_49212_102460 0.366000
R20872 n1_M7_49212_108060 n1_M7_49212_102460 0.320250
R20873 n1_M7_49212_108060 n1_M7_49212_108860 0.045750
R20874 n1_M7_49212_108860 n1_M7_49212_115260 0.366000
R20875 n1_M7_49212_120060 n1_M7_49212_115260 0.274500
R20876 n1_M7_49212_120060 n1_M7_49212_121660 0.091500
R20877 n1_M7_49212_121660 n1_M7_49212_128060 0.366000
R20878 n1_M7_49212_132060 n1_M7_49212_128060 0.228750
R20879 n1_M7_49212_132060 n1_M7_49212_134460 0.137250
R20880 n1_M7_49212_134460 n1_M7_49212_140860 0.366000
R20881 n1_M7_49212_144060 n1_M7_49212_140860 0.183000
R20882 n1_M7_49212_144060 n1_M7_49212_147260 0.183000
R20883 n1_M7_53308_60 n1_M7_53308_6460 0.366000
R20884 n1_M7_53308_12060 n1_M7_53308_6460 0.320250
R20885 n1_M7_53308_12060 n1_M7_53308_12860 0.045750
R20886 n1_M7_53308_12860 n1_M7_53308_19260 0.366000
R20887 n1_M7_53308_24060 n1_M7_53308_19260 0.274500
R20888 n1_M7_53308_24060 n1_M7_53308_25660 0.091500
R20889 n1_M7_53308_25660 n1_M7_53308_32060 0.366000
R20890 n1_M7_53308_36060 n1_M7_53308_32060 0.228750
R20891 n1_M7_53308_36060 n1_M7_53308_38460 0.137250
R20892 n1_M7_53308_38460 n1_M7_53308_44860 0.366000
R20893 n1_M7_53308_48060 n1_M7_53308_44860 0.183000
R20894 n1_M7_53308_48060 n1_M7_53308_51260 0.183000
R20895 n1_M7_53308_51260 n1_M7_53308_57660 0.366000
R20896 n1_M7_53308_60060 n1_M7_53308_57660 0.137250
R20897 n1_M7_53308_60060 n1_M7_53308_64060 0.228750
R20898 n1_M7_53308_64060 n1_M7_53308_70460 0.366000
R20899 n1_M7_53308_72060 n1_M7_53308_70460 0.091500
R20900 n1_M7_53308_72060 n1_M7_53308_76860 0.274500
R20901 n1_M7_53308_76860 n1_M7_53308_83260 0.366000
R20902 n1_M7_53308_84060 n1_M7_53308_83260 0.045750
R20903 n1_M7_53308_84060 n1_M7_53308_89660 0.320250
R20904 n1_M7_53308_96060 n1_M7_53308_89660 0.366000
R20905 n1_M7_53308_96060 n1_M7_53308_102460 0.366000
R20906 n1_M7_53308_108060 n1_M7_53308_102460 0.320250
R20907 n1_M7_53308_108060 n1_M7_53308_108860 0.045750
R20908 n1_M7_53308_108860 n1_M7_53308_115260 0.366000
R20909 n1_M7_53308_120060 n1_M7_53308_115260 0.274500
R20910 n1_M7_53308_120060 n1_M7_53308_121660 0.091500
R20911 n1_M7_53308_121660 n1_M7_53308_128060 0.366000
R20912 n1_M7_53308_132060 n1_M7_53308_128060 0.228750
R20913 n1_M7_53308_132060 n1_M7_53308_134460 0.137250
R20914 n1_M7_53308_134460 n1_M7_53308_140860 0.366000
R20915 n1_M7_53308_144060 n1_M7_53308_140860 0.183000
R20916 n1_M7_53308_144060 n1_M7_53308_147260 0.183000
R20917 n1_M7_57404_60 n1_M7_57404_6460 0.366000
R20918 n1_M7_57404_12060 n1_M7_57404_6460 0.320250
R20919 n1_M7_57404_12060 n1_M7_57404_12860 0.045750
R20920 n1_M7_57404_12860 n1_M7_57404_19260 0.366000
R20921 n1_M7_57404_24060 n1_M7_57404_19260 0.274500
R20922 n1_M7_57404_24060 n1_M7_57404_25660 0.091500
R20923 n1_M7_57404_25660 n1_M7_57404_32060 0.366000
R20924 n1_M7_57404_36060 n1_M7_57404_32060 0.228750
R20925 n1_M7_57404_36060 n1_M7_57404_38460 0.137250
R20926 n1_M7_57404_38460 n1_M7_57404_44860 0.366000
R20927 n1_M7_57404_48060 n1_M7_57404_44860 0.183000
R20928 n1_M7_57404_48060 n1_M7_57404_51260 0.183000
R20929 n1_M7_57404_51260 n1_M7_57404_57660 0.366000
R20930 n1_M7_57404_60060 n1_M7_57404_57660 0.137250
R20931 n1_M7_57404_60060 n1_M7_57404_64060 0.228750
R20932 n1_M7_57404_64060 n1_M7_57404_70460 0.366000
R20933 n1_M7_57404_72060 n1_M7_57404_70460 0.091500
R20934 n1_M7_57404_72060 n1_M7_57404_76860 0.274500
R20935 n1_M7_57404_76860 n1_M7_57404_83260 0.366000
R20936 n1_M7_57404_84060 n1_M7_57404_83260 0.045750
R20937 n1_M7_57404_84060 n1_M7_57404_89660 0.320250
R20938 n1_M7_57404_96060 n1_M7_57404_89660 0.366000
R20939 n1_M7_57404_96060 n1_M7_57404_102460 0.366000
R20940 n1_M7_57404_108060 n1_M7_57404_102460 0.320250
R20941 n1_M7_57404_108060 n1_M7_57404_108860 0.045750
R20942 n1_M7_57404_108860 n1_M7_57404_115260 0.366000
R20943 n1_M7_57404_120060 n1_M7_57404_115260 0.274500
R20944 n1_M7_57404_120060 n1_M7_57404_121660 0.091500
R20945 n1_M7_57404_121660 n1_M7_57404_128060 0.366000
R20946 n1_M7_57404_132060 n1_M7_57404_128060 0.228750
R20947 n1_M7_57404_132060 n1_M7_57404_134460 0.137250
R20948 n1_M7_57404_134460 n1_M7_57404_140860 0.366000
R20949 n1_M7_57404_144060 n1_M7_57404_140860 0.183000
R20950 n1_M7_57404_144060 n1_M7_57404_147260 0.183000
R20951 n1_M7_61500_60 n1_M7_61500_6460 0.366000
R20952 n1_M7_61500_12060 n1_M7_61500_6460 0.320250
R20953 n1_M7_61500_12060 n1_M7_61500_12860 0.045750
R20954 n1_M7_61500_12860 n1_M7_61500_19260 0.366000
R20955 n1_M7_61500_24060 n1_M7_61500_19260 0.274500
R20956 n1_M7_61500_24060 n1_M7_61500_25660 0.091500
R20957 n1_M7_61500_25660 n1_M7_61500_32060 0.366000
R20958 n1_M7_61500_36060 n1_M7_61500_32060 0.228750
R20959 n1_M7_61500_36060 n1_M7_61500_38460 0.137250
R20960 n1_M7_61500_38460 n1_M7_61500_44860 0.366000
R20961 n1_M7_61500_48060 n1_M7_61500_44860 0.183000
R20962 n1_M7_61500_48060 n1_M7_61500_51260 0.183000
R20963 n1_M7_61500_51260 n1_M7_61500_57660 0.366000
R20964 n1_M7_61500_60060 n1_M7_61500_57660 0.137250
R20965 n1_M7_61500_60060 n1_M7_61500_64060 0.228750
R20966 n1_M7_61500_64060 n1_M7_61500_70460 0.366000
R20967 n1_M7_61500_72060 n1_M7_61500_70460 0.091500
R20968 n1_M7_61500_72060 n1_M7_61500_76860 0.274500
R20969 n1_M7_61500_76860 n1_M7_61500_83260 0.366000
R20970 n1_M7_61500_84060 n1_M7_61500_83260 0.045750
R20971 n1_M7_61500_84060 n1_M7_61500_89660 0.320250
R20972 n1_M7_61500_96060 n1_M7_61500_89660 0.366000
R20973 n1_M7_61500_96060 n1_M7_61500_102460 0.366000
R20974 n1_M7_61500_108060 n1_M7_61500_102460 0.320250
R20975 n1_M7_61500_108060 n1_M7_61500_108860 0.045750
R20976 n1_M7_61500_108860 n1_M7_61500_115260 0.366000
R20977 n1_M7_61500_120060 n1_M7_61500_115260 0.274500
R20978 n1_M7_61500_120060 n1_M7_61500_121660 0.091500
R20979 n1_M7_61500_121660 n1_M7_61500_128060 0.366000
R20980 n1_M7_61500_132060 n1_M7_61500_128060 0.228750
R20981 n1_M7_61500_132060 n1_M7_61500_134460 0.137250
R20982 n1_M7_61500_134460 n1_M7_61500_140860 0.366000
R20983 n1_M7_61500_144060 n1_M7_61500_140860 0.183000
R20984 n1_M7_61500_144060 n1_M7_61500_147260 0.183000
R20985 n1_M7_65596_60 n1_M7_65596_6460 0.366000
R20986 n1_M7_65596_12060 n1_M7_65596_6460 0.320250
R20987 n1_M7_65596_12060 n1_M7_65596_12860 0.045750
R20988 n1_M7_65596_12860 n1_M7_65596_19260 0.366000
R20989 n1_M7_65596_24060 n1_M7_65596_19260 0.274500
R20990 n1_M7_65596_24060 n1_M7_65596_25660 0.091500
R20991 n1_M7_65596_25660 n1_M7_65596_32060 0.366000
R20992 n1_M7_65596_36060 n1_M7_65596_32060 0.228750
R20993 n1_M7_65596_36060 n1_M7_65596_38460 0.137250
R20994 n1_M7_65596_38460 n1_M7_65596_44860 0.366000
R20995 n1_M7_65596_48060 n1_M7_65596_44860 0.183000
R20996 n1_M7_65596_48060 n1_M7_65596_51260 0.183000
R20997 n1_M7_65596_51260 n1_M7_65596_57660 0.366000
R20998 n1_M7_65596_60060 n1_M7_65596_57660 0.137250
R20999 n1_M7_65596_60060 n1_M7_65596_64060 0.228750
R21000 n1_M7_65596_64060 n1_M7_65596_70460 0.366000
R21001 n1_M7_65596_72060 n1_M7_65596_70460 0.091500
R21002 n1_M7_65596_72060 n1_M7_65596_76860 0.274500
R21003 n1_M7_65596_76860 n1_M7_65596_83260 0.366000
R21004 n1_M7_65596_84060 n1_M7_65596_83260 0.045750
R21005 n1_M7_65596_84060 n1_M7_65596_89660 0.320250
R21006 n1_M7_65596_96060 n1_M7_65596_89660 0.366000
R21007 n1_M7_65596_96060 n1_M7_65596_102460 0.366000
R21008 n1_M7_65596_108060 n1_M7_65596_102460 0.320250
R21009 n1_M7_65596_108060 n1_M7_65596_108860 0.045750
R21010 n1_M7_65596_108860 n1_M7_65596_115260 0.366000
R21011 n1_M7_65596_120060 n1_M7_65596_115260 0.274500
R21012 n1_M7_65596_120060 n1_M7_65596_121660 0.091500
R21013 n1_M7_65596_121660 n1_M7_65596_128060 0.366000
R21014 n1_M7_65596_132060 n1_M7_65596_128060 0.228750
R21015 n1_M7_65596_132060 n1_M7_65596_134460 0.137250
R21016 n1_M7_65596_134460 n1_M7_65596_140860 0.366000
R21017 n1_M7_65596_144060 n1_M7_65596_140860 0.183000
R21018 n1_M7_65596_144060 n1_M7_65596_147260 0.183000
R21019 n1_M7_69692_60 n1_M7_69692_6460 0.366000
R21020 n1_M7_69692_12060 n1_M7_69692_6460 0.320250
R21021 n1_M7_69692_12060 n1_M7_69692_12860 0.045750
R21022 n1_M7_69692_12860 n1_M7_69692_19260 0.366000
R21023 n1_M7_69692_24060 n1_M7_69692_19260 0.274500
R21024 n1_M7_69692_24060 n1_M7_69692_25660 0.091500
R21025 n1_M7_69692_25660 n1_M7_69692_32060 0.366000
R21026 n1_M7_69692_36060 n1_M7_69692_32060 0.228750
R21027 n1_M7_69692_36060 n1_M7_69692_38460 0.137250
R21028 n1_M7_69692_38460 n1_M7_69692_44860 0.366000
R21029 n1_M7_69692_48060 n1_M7_69692_44860 0.183000
R21030 n1_M7_69692_48060 n1_M7_69692_51260 0.183000
R21031 n1_M7_69692_51260 n1_M7_69692_57660 0.366000
R21032 n1_M7_69692_60060 n1_M7_69692_57660 0.137250
R21033 n1_M7_69692_60060 n1_M7_69692_64060 0.228750
R21034 n1_M7_69692_64060 n1_M7_69692_70460 0.366000
R21035 n1_M7_69692_72060 n1_M7_69692_70460 0.091500
R21036 n1_M7_69692_72060 n1_M7_69692_76860 0.274500
R21037 n1_M7_69692_76860 n1_M7_69692_83260 0.366000
R21038 n1_M7_69692_84060 n1_M7_69692_83260 0.045750
R21039 n1_M7_69692_84060 n1_M7_69692_89660 0.320250
R21040 n1_M7_69692_96060 n1_M7_69692_89660 0.366000
R21041 n1_M7_69692_96060 n1_M7_69692_102460 0.366000
R21042 n1_M7_69692_108060 n1_M7_69692_102460 0.320250
R21043 n1_M7_69692_108060 n1_M7_69692_108860 0.045750
R21044 n1_M7_69692_108860 n1_M7_69692_115260 0.366000
R21045 n1_M7_69692_120060 n1_M7_69692_115260 0.274500
R21046 n1_M7_69692_120060 n1_M7_69692_121660 0.091500
R21047 n1_M7_69692_121660 n1_M7_69692_128060 0.366000
R21048 n1_M7_69692_132060 n1_M7_69692_128060 0.228750
R21049 n1_M7_69692_132060 n1_M7_69692_134460 0.137250
R21050 n1_M7_69692_134460 n1_M7_69692_140860 0.366000
R21051 n1_M7_69692_144060 n1_M7_69692_140860 0.183000
R21052 n1_M7_69692_144060 n1_M7_69692_147260 0.183000
R21053 n1_M7_73788_60 n1_M7_73788_6460 0.366000
R21054 n1_M7_73788_12060 n1_M7_73788_6460 0.320250
R21055 n1_M7_73788_12060 n1_M7_73788_12860 0.045750
R21056 n1_M7_73788_12860 n1_M7_73788_19260 0.366000
R21057 n1_M7_73788_24060 n1_M7_73788_19260 0.274500
R21058 n1_M7_73788_24060 n1_M7_73788_25660 0.091500
R21059 n1_M7_73788_25660 n1_M7_73788_32060 0.366000
R21060 n1_M7_73788_36060 n1_M7_73788_32060 0.228750
R21061 n1_M7_73788_36060 n1_M7_73788_38460 0.137250
R21062 n1_M7_73788_38460 n1_M7_73788_44860 0.366000
R21063 n1_M7_73788_48060 n1_M7_73788_44860 0.183000
R21064 n1_M7_73788_48060 n1_M7_73788_51260 0.183000
R21065 n1_M7_73788_51260 n1_M7_73788_57660 0.366000
R21066 n1_M7_73788_60060 n1_M7_73788_57660 0.137250
R21067 n1_M7_73788_60060 n1_M7_73788_64060 0.228750
R21068 n1_M7_73788_64060 n1_M7_73788_70460 0.366000
R21069 n1_M7_73788_72060 n1_M7_73788_70460 0.091500
R21070 n1_M7_73788_72060 n1_M7_73788_76860 0.274500
R21071 n1_M7_73788_76860 n1_M7_73788_83260 0.366000
R21072 n1_M7_73788_84060 n1_M7_73788_83260 0.045750
R21073 n1_M7_73788_84060 n1_M7_73788_89660 0.320250
R21074 n1_M7_73788_96060 n1_M7_73788_89660 0.366000
R21075 n1_M7_73788_96060 n1_M7_73788_102460 0.366000
R21076 n1_M7_73788_108060 n1_M7_73788_102460 0.320250
R21077 n1_M7_73788_108060 n1_M7_73788_108860 0.045750
R21078 n1_M7_73788_108860 n1_M7_73788_115260 0.366000
R21079 n1_M7_73788_120060 n1_M7_73788_115260 0.274500
R21080 n1_M7_73788_120060 n1_M7_73788_121660 0.091500
R21081 n1_M7_73788_121660 n1_M7_73788_128060 0.366000
R21082 n1_M7_73788_132060 n1_M7_73788_128060 0.228750
R21083 n1_M7_73788_132060 n1_M7_73788_134460 0.137250
R21084 n1_M7_73788_134460 n1_M7_73788_140860 0.366000
R21085 n1_M7_73788_144060 n1_M7_73788_140860 0.183000
R21086 n1_M7_73788_144060 n1_M7_73788_147260 0.183000
R21087 n1_M7_77884_60 n1_M7_77884_6460 0.366000
R21088 n1_M7_77884_12060 n1_M7_77884_6460 0.320250
R21089 n1_M7_77884_12060 n1_M7_77884_12860 0.045750
R21090 n1_M7_77884_12860 n1_M7_77884_19260 0.366000
R21091 n1_M7_77884_24060 n1_M7_77884_19260 0.274500
R21092 n1_M7_77884_24060 n1_M7_77884_25660 0.091500
R21093 n1_M7_77884_25660 n1_M7_77884_32060 0.366000
R21094 n1_M7_77884_36060 n1_M7_77884_32060 0.228750
R21095 n1_M7_77884_36060 n1_M7_77884_38460 0.137250
R21096 n1_M7_77884_38460 n1_M7_77884_44860 0.366000
R21097 n1_M7_77884_48060 n1_M7_77884_44860 0.183000
R21098 n1_M7_77884_48060 n1_M7_77884_51260 0.183000
R21099 n1_M7_77884_51260 n1_M7_77884_57660 0.366000
R21100 n1_M7_77884_60060 n1_M7_77884_57660 0.137250
R21101 n1_M7_77884_60060 n1_M7_77884_64060 0.228750
R21102 n1_M7_77884_64060 n1_M7_77884_70460 0.366000
R21103 n1_M7_77884_72060 n1_M7_77884_70460 0.091500
R21104 n1_M7_77884_72060 n1_M7_77884_76860 0.274500
R21105 n1_M7_77884_76860 n1_M7_77884_83260 0.366000
R21106 n1_M7_77884_84060 n1_M7_77884_83260 0.045750
R21107 n1_M7_77884_84060 n1_M7_77884_89660 0.320250
R21108 n1_M7_77884_96060 n1_M7_77884_89660 0.366000
R21109 n1_M7_77884_96060 n1_M7_77884_102460 0.366000
R21110 n1_M7_77884_108060 n1_M7_77884_102460 0.320250
R21111 n1_M7_77884_108060 n1_M7_77884_108860 0.045750
R21112 n1_M7_77884_108860 n1_M7_77884_115260 0.366000
R21113 n1_M7_77884_120060 n1_M7_77884_115260 0.274500
R21114 n1_M7_77884_120060 n1_M7_77884_121660 0.091500
R21115 n1_M7_77884_121660 n1_M7_77884_128060 0.366000
R21116 n1_M7_77884_132060 n1_M7_77884_128060 0.228750
R21117 n1_M7_77884_132060 n1_M7_77884_134460 0.137250
R21118 n1_M7_77884_134460 n1_M7_77884_140860 0.366000
R21119 n1_M7_77884_144060 n1_M7_77884_140860 0.183000
R21120 n1_M7_77884_144060 n1_M7_77884_147260 0.183000
R21121 n1_M7_81980_60 n1_M7_81980_6460 0.366000
R21122 n1_M7_81980_12060 n1_M7_81980_6460 0.320250
R21123 n1_M7_81980_12060 n1_M7_81980_12860 0.045750
R21124 n1_M7_81980_12860 n1_M7_81980_19260 0.366000
R21125 n1_M7_81980_24060 n1_M7_81980_19260 0.274500
R21126 n1_M7_81980_24060 n1_M7_81980_25660 0.091500
R21127 n1_M7_81980_25660 n1_M7_81980_32060 0.366000
R21128 n1_M7_81980_36060 n1_M7_81980_32060 0.228750
R21129 n1_M7_81980_36060 n1_M7_81980_38460 0.137250
R21130 n1_M7_81980_38460 n1_M7_81980_44860 0.366000
R21131 n1_M7_81980_48060 n1_M7_81980_44860 0.183000
R21132 n1_M7_81980_48060 n1_M7_81980_51260 0.183000
R21133 n1_M7_81980_51260 n1_M7_81980_57660 0.366000
R21134 n1_M7_81980_60060 n1_M7_81980_57660 0.137250
R21135 n1_M7_81980_60060 n1_M7_81980_64060 0.228750
R21136 n1_M7_81980_64060 n1_M7_81980_70460 0.366000
R21137 n1_M7_81980_72060 n1_M7_81980_70460 0.091500
R21138 n1_M7_81980_72060 n1_M7_81980_76860 0.274500
R21139 n1_M7_81980_76860 n1_M7_81980_83260 0.366000
R21140 n1_M7_81980_84060 n1_M7_81980_83260 0.045750
R21141 n1_M7_81980_84060 n1_M7_81980_89660 0.320250
R21142 n1_M7_81980_96060 n1_M7_81980_89660 0.366000
R21143 n1_M7_81980_96060 n1_M7_81980_102460 0.366000
R21144 n1_M7_81980_108060 n1_M7_81980_102460 0.320250
R21145 n1_M7_81980_108060 n1_M7_81980_108860 0.045750
R21146 n1_M7_81980_108860 n1_M7_81980_115260 0.366000
R21147 n1_M7_81980_120060 n1_M7_81980_115260 0.274500
R21148 n1_M7_81980_120060 n1_M7_81980_121660 0.091500
R21149 n1_M7_81980_121660 n1_M7_81980_128060 0.366000
R21150 n1_M7_81980_132060 n1_M7_81980_128060 0.228750
R21151 n1_M7_81980_132060 n1_M7_81980_134460 0.137250
R21152 n1_M7_81980_134460 n1_M7_81980_140860 0.366000
R21153 n1_M7_81980_144060 n1_M7_81980_140860 0.183000
R21154 n1_M7_81980_144060 n1_M7_81980_147260 0.183000
R21155 n1_M7_86076_60 n1_M7_86076_6460 0.366000
R21156 n1_M7_86076_12060 n1_M7_86076_6460 0.320250
R21157 n1_M7_86076_12060 n1_M7_86076_12860 0.045750
R21158 n1_M7_86076_12860 n1_M7_86076_19260 0.366000
R21159 n1_M7_86076_24060 n1_M7_86076_19260 0.274500
R21160 n1_M7_86076_24060 n1_M7_86076_25660 0.091500
R21161 n1_M7_86076_25660 n1_M7_86076_32060 0.366000
R21162 n1_M7_86076_36060 n1_M7_86076_32060 0.228750
R21163 n1_M7_86076_36060 n1_M7_86076_38460 0.137250
R21164 n1_M7_86076_38460 n1_M7_86076_44860 0.366000
R21165 n1_M7_86076_48060 n1_M7_86076_44860 0.183000
R21166 n1_M7_86076_48060 n1_M7_86076_51260 0.183000
R21167 n1_M7_86076_51260 n1_M7_86076_57660 0.366000
R21168 n1_M7_86076_60060 n1_M7_86076_57660 0.137250
R21169 n1_M7_86076_60060 n1_M7_86076_64060 0.228750
R21170 n1_M7_86076_64060 n1_M7_86076_70460 0.366000
R21171 n1_M7_86076_72060 n1_M7_86076_70460 0.091500
R21172 n1_M7_86076_72060 n1_M7_86076_76860 0.274500
R21173 n1_M7_86076_76860 n1_M7_86076_83260 0.366000
R21174 n1_M7_86076_84060 n1_M7_86076_83260 0.045750
R21175 n1_M7_86076_84060 n1_M7_86076_89660 0.320250
R21176 n1_M7_86076_96060 n1_M7_86076_89660 0.366000
R21177 n1_M7_86076_96060 n1_M7_86076_102460 0.366000
R21178 n1_M7_86076_108060 n1_M7_86076_102460 0.320250
R21179 n1_M7_86076_108060 n1_M7_86076_108860 0.045750
R21180 n1_M7_86076_108860 n1_M7_86076_115260 0.366000
R21181 n1_M7_86076_120060 n1_M7_86076_115260 0.274500
R21182 n1_M7_86076_120060 n1_M7_86076_121660 0.091500
R21183 n1_M7_86076_121660 n1_M7_86076_128060 0.366000
R21184 n1_M7_86076_132060 n1_M7_86076_128060 0.228750
R21185 n1_M7_86076_132060 n1_M7_86076_134460 0.137250
R21186 n1_M7_86076_134460 n1_M7_86076_140860 0.366000
R21187 n1_M7_86076_144060 n1_M7_86076_140860 0.183000
R21188 n1_M7_86076_144060 n1_M7_86076_147260 0.183000
R21189 n1_M7_90172_60 n1_M7_90172_6460 0.366000
R21190 n1_M7_90172_12060 n1_M7_90172_6460 0.320250
R21191 n1_M7_90172_12060 n1_M7_90172_12860 0.045750
R21192 n1_M7_90172_12860 n1_M7_90172_19260 0.366000
R21193 n1_M7_90172_24060 n1_M7_90172_19260 0.274500
R21194 n1_M7_90172_24060 n1_M7_90172_25660 0.091500
R21195 n1_M7_90172_25660 n1_M7_90172_32060 0.366000
R21196 n1_M7_90172_36060 n1_M7_90172_32060 0.228750
R21197 n1_M7_90172_36060 n1_M7_90172_38460 0.137250
R21198 n1_M7_90172_38460 n1_M7_90172_44860 0.366000
R21199 n1_M7_90172_48060 n1_M7_90172_44860 0.183000
R21200 n1_M7_90172_48060 n1_M7_90172_51260 0.183000
R21201 n1_M7_90172_51260 n1_M7_90172_57660 0.366000
R21202 n1_M7_90172_60060 n1_M7_90172_57660 0.137250
R21203 n1_M7_90172_60060 n1_M7_90172_64060 0.228750
R21204 n1_M7_90172_64060 n1_M7_90172_70460 0.366000
R21205 n1_M7_90172_72060 n1_M7_90172_70460 0.091500
R21206 n1_M7_90172_72060 n1_M7_90172_76860 0.274500
R21207 n1_M7_90172_76860 n1_M7_90172_83260 0.366000
R21208 n1_M7_90172_84060 n1_M7_90172_83260 0.045750
R21209 n1_M7_90172_84060 n1_M7_90172_89660 0.320250
R21210 n1_M7_90172_96060 n1_M7_90172_89660 0.366000
R21211 n1_M7_90172_96060 n1_M7_90172_102460 0.366000
R21212 n1_M7_90172_108060 n1_M7_90172_102460 0.320250
R21213 n1_M7_90172_108060 n1_M7_90172_108860 0.045750
R21214 n1_M7_90172_108860 n1_M7_90172_115260 0.366000
R21215 n1_M7_90172_120060 n1_M7_90172_115260 0.274500
R21216 n1_M7_90172_120060 n1_M7_90172_121660 0.091500
R21217 n1_M7_90172_121660 n1_M7_90172_128060 0.366000
R21218 n1_M7_90172_132060 n1_M7_90172_128060 0.228750
R21219 n1_M7_90172_132060 n1_M7_90172_134460 0.137250
R21220 n1_M7_90172_134460 n1_M7_90172_140860 0.366000
R21221 n1_M7_90172_144060 n1_M7_90172_140860 0.183000
R21222 n1_M7_90172_144060 n1_M7_90172_147260 0.183000
R21223 n1_M7_94268_60 n1_M7_94268_6460 0.366000
R21224 n1_M7_94268_12060 n1_M7_94268_6460 0.320250
R21225 n1_M7_94268_12060 n1_M7_94268_12860 0.045750
R21226 n1_M7_94268_12860 n1_M7_94268_19260 0.366000
R21227 n1_M7_94268_24060 n1_M7_94268_19260 0.274500
R21228 n1_M7_94268_24060 n1_M7_94268_25660 0.091500
R21229 n1_M7_94268_25660 n1_M7_94268_32060 0.366000
R21230 n1_M7_94268_36060 n1_M7_94268_32060 0.228750
R21231 n1_M7_94268_36060 n1_M7_94268_38460 0.137250
R21232 n1_M7_94268_38460 n1_M7_94268_44860 0.366000
R21233 n1_M7_94268_48060 n1_M7_94268_44860 0.183000
R21234 n1_M7_94268_48060 n1_M7_94268_51260 0.183000
R21235 n1_M7_94268_51260 n1_M7_94268_57660 0.366000
R21236 n1_M7_94268_60060 n1_M7_94268_57660 0.137250
R21237 n1_M7_94268_60060 n1_M7_94268_64060 0.228750
R21238 n1_M7_94268_64060 n1_M7_94268_70460 0.366000
R21239 n1_M7_94268_72060 n1_M7_94268_70460 0.091500
R21240 n1_M7_94268_72060 n1_M7_94268_76860 0.274500
R21241 n1_M7_94268_76860 n1_M7_94268_83260 0.366000
R21242 n1_M7_94268_84060 n1_M7_94268_83260 0.045750
R21243 n1_M7_94268_84060 n1_M7_94268_89660 0.320250
R21244 n1_M7_94268_96060 n1_M7_94268_89660 0.366000
R21245 n1_M7_94268_96060 n1_M7_94268_102460 0.366000
R21246 n1_M7_94268_108060 n1_M7_94268_102460 0.320250
R21247 n1_M7_94268_108060 n1_M7_94268_108860 0.045750
R21248 n1_M7_94268_108860 n1_M7_94268_115260 0.366000
R21249 n1_M7_94268_120060 n1_M7_94268_115260 0.274500
R21250 n1_M7_94268_120060 n1_M7_94268_121660 0.091500
R21251 n1_M7_94268_121660 n1_M7_94268_128060 0.366000
R21252 n1_M7_94268_132060 n1_M7_94268_128060 0.228750
R21253 n1_M7_94268_132060 n1_M7_94268_134460 0.137250
R21254 n1_M7_94268_134460 n1_M7_94268_140860 0.366000
R21255 n1_M7_94268_144060 n1_M7_94268_140860 0.183000
R21256 n1_M7_94268_144060 n1_M7_94268_147260 0.183000
R21257 n1_M7_98364_60 n1_M7_98364_6460 0.366000
R21258 n1_M7_98364_12060 n1_M7_98364_6460 0.320250
R21259 n1_M7_98364_12060 n1_M7_98364_12860 0.045750
R21260 n1_M7_98364_12860 n1_M7_98364_19260 0.366000
R21261 n1_M7_98364_24060 n1_M7_98364_19260 0.274500
R21262 n1_M7_98364_24060 n1_M7_98364_25660 0.091500
R21263 n1_M7_98364_25660 n1_M7_98364_32060 0.366000
R21264 n1_M7_98364_36060 n1_M7_98364_32060 0.228750
R21265 n1_M7_98364_36060 n1_M7_98364_38460 0.137250
R21266 n1_M7_98364_38460 n1_M7_98364_44860 0.366000
R21267 n1_M7_98364_48060 n1_M7_98364_44860 0.183000
R21268 n1_M7_98364_48060 n1_M7_98364_51260 0.183000
R21269 n1_M7_98364_51260 n1_M7_98364_57660 0.366000
R21270 n1_M7_98364_60060 n1_M7_98364_57660 0.137250
R21271 n1_M7_98364_60060 n1_M7_98364_64060 0.228750
R21272 n1_M7_98364_64060 n1_M7_98364_70460 0.366000
R21273 n1_M7_98364_72060 n1_M7_98364_70460 0.091500
R21274 n1_M7_98364_72060 n1_M7_98364_76860 0.274500
R21275 n1_M7_98364_76860 n1_M7_98364_83260 0.366000
R21276 n1_M7_98364_84060 n1_M7_98364_83260 0.045750
R21277 n1_M7_98364_84060 n1_M7_98364_89660 0.320250
R21278 n1_M7_98364_96060 n1_M7_98364_89660 0.366000
R21279 n1_M7_98364_96060 n1_M7_98364_102460 0.366000
R21280 n1_M7_98364_108060 n1_M7_98364_102460 0.320250
R21281 n1_M7_98364_108060 n1_M7_98364_108860 0.045750
R21282 n1_M7_98364_108860 n1_M7_98364_115260 0.366000
R21283 n1_M7_98364_120060 n1_M7_98364_115260 0.274500
R21284 n1_M7_98364_120060 n1_M7_98364_121660 0.091500
R21285 n1_M7_98364_121660 n1_M7_98364_128060 0.366000
R21286 n1_M7_98364_132060 n1_M7_98364_128060 0.228750
R21287 n1_M7_98364_132060 n1_M7_98364_134460 0.137250
R21288 n1_M7_98364_134460 n1_M7_98364_140860 0.366000
R21289 n1_M7_98364_144060 n1_M7_98364_140860 0.183000
R21290 n1_M7_98364_144060 n1_M7_98364_147260 0.183000
R21291 n1_M7_102460_60 n1_M7_102460_6460 0.366000
R21292 n1_M7_102460_12060 n1_M7_102460_6460 0.320250
R21293 n1_M7_102460_12060 n1_M7_102460_12860 0.045750
R21294 n1_M7_102460_12860 n1_M7_102460_19260 0.366000
R21295 n1_M7_102460_24060 n1_M7_102460_19260 0.274500
R21296 n1_M7_102460_24060 n1_M7_102460_25660 0.091500
R21297 n1_M7_102460_25660 n1_M7_102460_32060 0.366000
R21298 n1_M7_102460_36060 n1_M7_102460_32060 0.228750
R21299 n1_M7_102460_36060 n1_M7_102460_38460 0.137250
R21300 n1_M7_102460_38460 n1_M7_102460_44860 0.366000
R21301 n1_M7_102460_48060 n1_M7_102460_44860 0.183000
R21302 n1_M7_102460_48060 n1_M7_102460_51260 0.183000
R21303 n1_M7_102460_51260 n1_M7_102460_57660 0.366000
R21304 n1_M7_102460_60060 n1_M7_102460_57660 0.137250
R21305 n1_M7_102460_60060 n1_M7_102460_64060 0.228750
R21306 n1_M7_102460_64060 n1_M7_102460_70460 0.366000
R21307 n1_M7_102460_72060 n1_M7_102460_70460 0.091500
R21308 n1_M7_102460_72060 n1_M7_102460_76860 0.274500
R21309 n1_M7_102460_76860 n1_M7_102460_83260 0.366000
R21310 n1_M7_102460_84060 n1_M7_102460_83260 0.045750
R21311 n1_M7_102460_84060 n1_M7_102460_89660 0.320250
R21312 n1_M7_102460_96060 n1_M7_102460_89660 0.366000
R21313 n1_M7_102460_96060 n1_M7_102460_102460 0.366000
R21314 n1_M7_102460_108060 n1_M7_102460_102460 0.320250
R21315 n1_M7_102460_108060 n1_M7_102460_108860 0.045750
R21316 n1_M7_102460_108860 n1_M7_102460_115260 0.366000
R21317 n1_M7_102460_120060 n1_M7_102460_115260 0.274500
R21318 n1_M7_102460_120060 n1_M7_102460_121660 0.091500
R21319 n1_M7_102460_121660 n1_M7_102460_128060 0.366000
R21320 n1_M7_102460_132060 n1_M7_102460_128060 0.228750
R21321 n1_M7_102460_132060 n1_M7_102460_134460 0.137250
R21322 n1_M7_102460_134460 n1_M7_102460_140860 0.366000
R21323 n1_M7_102460_144060 n1_M7_102460_140860 0.183000
R21324 n1_M7_102460_144060 n1_M7_102460_147260 0.183000
R21325 n1_M7_106556_60 n1_M7_106556_6460 0.366000
R21326 n1_M7_106556_12060 n1_M7_106556_6460 0.320250
R21327 n1_M7_106556_12060 n1_M7_106556_12860 0.045750
R21328 n1_M7_106556_12860 n1_M7_106556_19260 0.366000
R21329 n1_M7_106556_24060 n1_M7_106556_19260 0.274500
R21330 n1_M7_106556_24060 n1_M7_106556_25660 0.091500
R21331 n1_M7_106556_25660 n1_M7_106556_32060 0.366000
R21332 n1_M7_106556_36060 n1_M7_106556_32060 0.228750
R21333 n1_M7_106556_36060 n1_M7_106556_38460 0.137250
R21334 n1_M7_106556_38460 n1_M7_106556_44860 0.366000
R21335 n1_M7_106556_48060 n1_M7_106556_44860 0.183000
R21336 n1_M7_106556_48060 n1_M7_106556_51260 0.183000
R21337 n1_M7_106556_51260 n1_M7_106556_57660 0.366000
R21338 n1_M7_106556_60060 n1_M7_106556_57660 0.137250
R21339 n1_M7_106556_60060 n1_M7_106556_64060 0.228750
R21340 n1_M7_106556_64060 n1_M7_106556_70460 0.366000
R21341 n1_M7_106556_72060 n1_M7_106556_70460 0.091500
R21342 n1_M7_106556_72060 n1_M7_106556_76860 0.274500
R21343 n1_M7_106556_76860 n1_M7_106556_83260 0.366000
R21344 n1_M7_106556_84060 n1_M7_106556_83260 0.045750
R21345 n1_M7_106556_84060 n1_M7_106556_89660 0.320250
R21346 n1_M7_106556_96060 n1_M7_106556_89660 0.366000
R21347 n1_M7_106556_96060 n1_M7_106556_102460 0.366000
R21348 n1_M7_106556_108060 n1_M7_106556_102460 0.320250
R21349 n1_M7_106556_108060 n1_M7_106556_108860 0.045750
R21350 n1_M7_106556_108860 n1_M7_106556_115260 0.366000
R21351 n1_M7_106556_120060 n1_M7_106556_115260 0.274500
R21352 n1_M7_106556_120060 n1_M7_106556_121660 0.091500
R21353 n1_M7_106556_121660 n1_M7_106556_128060 0.366000
R21354 n1_M7_106556_132060 n1_M7_106556_128060 0.228750
R21355 n1_M7_106556_132060 n1_M7_106556_134460 0.137250
R21356 n1_M7_106556_134460 n1_M7_106556_140860 0.366000
R21357 n1_M7_106556_144060 n1_M7_106556_140860 0.183000
R21358 n1_M7_106556_144060 n1_M7_106556_147260 0.183000
R21359 n1_M7_110652_60 n1_M7_110652_6460 0.366000
R21360 n1_M7_110652_12060 n1_M7_110652_6460 0.320250
R21361 n1_M7_110652_12060 n1_M7_110652_12860 0.045750
R21362 n1_M7_110652_12860 n1_M7_110652_19260 0.366000
R21363 n1_M7_110652_24060 n1_M7_110652_19260 0.274500
R21364 n1_M7_110652_24060 n1_M7_110652_25660 0.091500
R21365 n1_M7_110652_25660 n1_M7_110652_32060 0.366000
R21366 n1_M7_110652_36060 n1_M7_110652_32060 0.228750
R21367 n1_M7_110652_36060 n1_M7_110652_38460 0.137250
R21368 n1_M7_110652_38460 n1_M7_110652_44860 0.366000
R21369 n1_M7_110652_48060 n1_M7_110652_44860 0.183000
R21370 n1_M7_110652_48060 n1_M7_110652_51260 0.183000
R21371 n1_M7_110652_51260 n1_M7_110652_57660 0.366000
R21372 n1_M7_110652_60060 n1_M7_110652_57660 0.137250
R21373 n1_M7_110652_60060 n1_M7_110652_64060 0.228750
R21374 n1_M7_110652_64060 n1_M7_110652_70460 0.366000
R21375 n1_M7_110652_72060 n1_M7_110652_70460 0.091500
R21376 n1_M7_110652_72060 n1_M7_110652_76860 0.274500
R21377 n1_M7_110652_76860 n1_M7_110652_83260 0.366000
R21378 n1_M7_110652_84060 n1_M7_110652_83260 0.045750
R21379 n1_M7_110652_84060 n1_M7_110652_89660 0.320250
R21380 n1_M7_110652_96060 n1_M7_110652_89660 0.366000
R21381 n1_M7_110652_96060 n1_M7_110652_102460 0.366000
R21382 n1_M7_110652_108060 n1_M7_110652_102460 0.320250
R21383 n1_M7_110652_108060 n1_M7_110652_108860 0.045750
R21384 n1_M7_110652_108860 n1_M7_110652_115260 0.366000
R21385 n1_M7_110652_120060 n1_M7_110652_115260 0.274500
R21386 n1_M7_110652_120060 n1_M7_110652_121660 0.091500
R21387 n1_M7_110652_121660 n1_M7_110652_128060 0.366000
R21388 n1_M7_110652_132060 n1_M7_110652_128060 0.228750
R21389 n1_M7_110652_132060 n1_M7_110652_134460 0.137250
R21390 n1_M7_110652_134460 n1_M7_110652_140860 0.366000
R21391 n1_M7_110652_144060 n1_M7_110652_140860 0.183000
R21392 n1_M7_110652_144060 n1_M7_110652_147260 0.183000
R21393 n1_M7_114748_60 n1_M7_114748_6460 0.366000
R21394 n1_M7_114748_12060 n1_M7_114748_6460 0.320250
R21395 n1_M7_114748_12060 n1_M7_114748_12860 0.045750
R21396 n1_M7_114748_12860 n1_M7_114748_19260 0.366000
R21397 n1_M7_114748_24060 n1_M7_114748_19260 0.274500
R21398 n1_M7_114748_24060 n1_M7_114748_25660 0.091500
R21399 n1_M7_114748_25660 n1_M7_114748_32060 0.366000
R21400 n1_M7_114748_36060 n1_M7_114748_32060 0.228750
R21401 n1_M7_114748_36060 n1_M7_114748_38460 0.137250
R21402 n1_M7_114748_38460 n1_M7_114748_44860 0.366000
R21403 n1_M7_114748_48060 n1_M7_114748_44860 0.183000
R21404 n1_M7_114748_48060 n1_M7_114748_51260 0.183000
R21405 n1_M7_114748_51260 n1_M7_114748_57660 0.366000
R21406 n1_M7_114748_60060 n1_M7_114748_57660 0.137250
R21407 n1_M7_114748_60060 n1_M7_114748_64060 0.228750
R21408 n1_M7_114748_64060 n1_M7_114748_70460 0.366000
R21409 n1_M7_114748_72060 n1_M7_114748_70460 0.091500
R21410 n1_M7_114748_72060 n1_M7_114748_76860 0.274500
R21411 n1_M7_114748_76860 n1_M7_114748_83260 0.366000
R21412 n1_M7_114748_84060 n1_M7_114748_83260 0.045750
R21413 n1_M7_114748_84060 n1_M7_114748_89660 0.320250
R21414 n1_M7_114748_96060 n1_M7_114748_89660 0.366000
R21415 n1_M7_114748_96060 n1_M7_114748_102460 0.366000
R21416 n1_M7_114748_108060 n1_M7_114748_102460 0.320250
R21417 n1_M7_114748_108060 n1_M7_114748_108860 0.045750
R21418 n1_M7_114748_108860 n1_M7_114748_115260 0.366000
R21419 n1_M7_114748_120060 n1_M7_114748_115260 0.274500
R21420 n1_M7_114748_120060 n1_M7_114748_121660 0.091500
R21421 n1_M7_114748_121660 n1_M7_114748_128060 0.366000
R21422 n1_M7_114748_132060 n1_M7_114748_128060 0.228750
R21423 n1_M7_114748_132060 n1_M7_114748_134460 0.137250
R21424 n1_M7_114748_134460 n1_M7_114748_140860 0.366000
R21425 n1_M7_114748_144060 n1_M7_114748_140860 0.183000
R21426 n1_M7_114748_144060 n1_M7_114748_147260 0.183000
R21427 n1_M7_118844_60 n1_M7_118844_6460 0.366000
R21428 n1_M7_118844_12060 n1_M7_118844_6460 0.320250
R21429 n1_M7_118844_12060 n1_M7_118844_12860 0.045750
R21430 n1_M7_118844_12860 n1_M7_118844_19260 0.366000
R21431 n1_M7_118844_24060 n1_M7_118844_19260 0.274500
R21432 n1_M7_118844_24060 n1_M7_118844_25660 0.091500
R21433 n1_M7_118844_25660 n1_M7_118844_32060 0.366000
R21434 n1_M7_118844_36060 n1_M7_118844_32060 0.228750
R21435 n1_M7_118844_36060 n1_M7_118844_38460 0.137250
R21436 n1_M7_118844_38460 n1_M7_118844_44860 0.366000
R21437 n1_M7_118844_48060 n1_M7_118844_44860 0.183000
R21438 n1_M7_118844_48060 n1_M7_118844_51260 0.183000
R21439 n1_M7_118844_51260 n1_M7_118844_57660 0.366000
R21440 n1_M7_118844_60060 n1_M7_118844_57660 0.137250
R21441 n1_M7_118844_60060 n1_M7_118844_64060 0.228750
R21442 n1_M7_118844_64060 n1_M7_118844_70460 0.366000
R21443 n1_M7_118844_72060 n1_M7_118844_70460 0.091500
R21444 n1_M7_118844_72060 n1_M7_118844_76860 0.274500
R21445 n1_M7_118844_76860 n1_M7_118844_83260 0.366000
R21446 n1_M7_118844_84060 n1_M7_118844_83260 0.045750
R21447 n1_M7_118844_84060 n1_M7_118844_89660 0.320250
R21448 n1_M7_118844_96060 n1_M7_118844_89660 0.366000
R21449 n1_M7_118844_96060 n1_M7_118844_102460 0.366000
R21450 n1_M7_118844_108060 n1_M7_118844_102460 0.320250
R21451 n1_M7_118844_108060 n1_M7_118844_108860 0.045750
R21452 n1_M7_118844_108860 n1_M7_118844_115260 0.366000
R21453 n1_M7_118844_120060 n1_M7_118844_115260 0.274500
R21454 n1_M7_118844_120060 n1_M7_118844_121660 0.091500
R21455 n1_M7_118844_121660 n1_M7_118844_128060 0.366000
R21456 n1_M7_118844_132060 n1_M7_118844_128060 0.228750
R21457 n1_M7_118844_132060 n1_M7_118844_134460 0.137250
R21458 n1_M7_118844_134460 n1_M7_118844_140860 0.366000
R21459 n1_M7_118844_144060 n1_M7_118844_140860 0.183000
R21460 n1_M7_118844_144060 n1_M7_118844_147260 0.183000
R21461 n1_M7_122940_60 n1_M7_122940_6460 0.366000
R21462 n1_M7_122940_12060 n1_M7_122940_6460 0.320250
R21463 n1_M7_122940_12060 n1_M7_122940_12860 0.045750
R21464 n1_M7_122940_12860 n1_M7_122940_19260 0.366000
R21465 n1_M7_122940_24060 n1_M7_122940_19260 0.274500
R21466 n1_M7_122940_24060 n1_M7_122940_25660 0.091500
R21467 n1_M7_122940_25660 n1_M7_122940_32060 0.366000
R21468 n1_M7_122940_36060 n1_M7_122940_32060 0.228750
R21469 n1_M7_122940_36060 n1_M7_122940_38460 0.137250
R21470 n1_M7_122940_38460 n1_M7_122940_44860 0.366000
R21471 n1_M7_122940_48060 n1_M7_122940_44860 0.183000
R21472 n1_M7_122940_48060 n1_M7_122940_51260 0.183000
R21473 n1_M7_122940_51260 n1_M7_122940_57660 0.366000
R21474 n1_M7_122940_60060 n1_M7_122940_57660 0.137250
R21475 n1_M7_122940_60060 n1_M7_122940_64060 0.228750
R21476 n1_M7_122940_64060 n1_M7_122940_70460 0.366000
R21477 n1_M7_122940_72060 n1_M7_122940_70460 0.091500
R21478 n1_M7_122940_72060 n1_M7_122940_76860 0.274500
R21479 n1_M7_122940_76860 n1_M7_122940_83260 0.366000
R21480 n1_M7_122940_84060 n1_M7_122940_83260 0.045750
R21481 n1_M7_122940_84060 n1_M7_122940_89660 0.320250
R21482 n1_M7_122940_96060 n1_M7_122940_89660 0.366000
R21483 n1_M7_122940_96060 n1_M7_122940_102460 0.366000
R21484 n1_M7_122940_108060 n1_M7_122940_102460 0.320250
R21485 n1_M7_122940_108060 n1_M7_122940_108860 0.045750
R21486 n1_M7_122940_108860 n1_M7_122940_115260 0.366000
R21487 n1_M7_122940_120060 n1_M7_122940_115260 0.274500
R21488 n1_M7_122940_120060 n1_M7_122940_121660 0.091500
R21489 n1_M7_122940_121660 n1_M7_122940_128060 0.366000
R21490 n1_M7_122940_132060 n1_M7_122940_128060 0.228750
R21491 n1_M7_122940_132060 n1_M7_122940_134460 0.137250
R21492 n1_M7_122940_134460 n1_M7_122940_140860 0.366000
R21493 n1_M7_122940_144060 n1_M7_122940_140860 0.183000
R21494 n1_M7_122940_144060 n1_M7_122940_147260 0.183000
R21495 n1_M7_127036_60 n1_M7_127036_6460 0.366000
R21496 n1_M7_127036_12060 n1_M7_127036_6460 0.320250
R21497 n1_M7_127036_12060 n1_M7_127036_12860 0.045750
R21498 n1_M7_127036_12860 n1_M7_127036_19260 0.366000
R21499 n1_M7_127036_24060 n1_M7_127036_19260 0.274500
R21500 n1_M7_127036_24060 n1_M7_127036_25660 0.091500
R21501 n1_M7_127036_25660 n1_M7_127036_32060 0.366000
R21502 n1_M7_127036_36060 n1_M7_127036_32060 0.228750
R21503 n1_M7_127036_36060 n1_M7_127036_38460 0.137250
R21504 n1_M7_127036_38460 n1_M7_127036_44860 0.366000
R21505 n1_M7_127036_48060 n1_M7_127036_44860 0.183000
R21506 n1_M7_127036_48060 n1_M7_127036_51260 0.183000
R21507 n1_M7_127036_51260 n1_M7_127036_57660 0.366000
R21508 n1_M7_127036_60060 n1_M7_127036_57660 0.137250
R21509 n1_M7_127036_60060 n1_M7_127036_64060 0.228750
R21510 n1_M7_127036_64060 n1_M7_127036_70460 0.366000
R21511 n1_M7_127036_72060 n1_M7_127036_70460 0.091500
R21512 n1_M7_127036_72060 n1_M7_127036_76860 0.274500
R21513 n1_M7_127036_76860 n1_M7_127036_83260 0.366000
R21514 n1_M7_127036_84060 n1_M7_127036_83260 0.045750
R21515 n1_M7_127036_84060 n1_M7_127036_89660 0.320250
R21516 n1_M7_127036_96060 n1_M7_127036_89660 0.366000
R21517 n1_M7_127036_96060 n1_M7_127036_102460 0.366000
R21518 n1_M7_127036_108060 n1_M7_127036_102460 0.320250
R21519 n1_M7_127036_108060 n1_M7_127036_108860 0.045750
R21520 n1_M7_127036_108860 n1_M7_127036_115260 0.366000
R21521 n1_M7_127036_120060 n1_M7_127036_115260 0.274500
R21522 n1_M7_127036_120060 n1_M7_127036_121660 0.091500
R21523 n1_M7_127036_121660 n1_M7_127036_128060 0.366000
R21524 n1_M7_127036_132060 n1_M7_127036_128060 0.228750
R21525 n1_M7_127036_132060 n1_M7_127036_134460 0.137250
R21526 n1_M7_127036_134460 n1_M7_127036_140860 0.366000
R21527 n1_M7_127036_144060 n1_M7_127036_140860 0.183000
R21528 n1_M7_127036_144060 n1_M7_127036_147260 0.183000
R21529 n1_M7_131132_60 n1_M7_131132_6460 0.366000
R21530 n1_M7_131132_12060 n1_M7_131132_6460 0.320250
R21531 n1_M7_131132_12060 n1_M7_131132_12860 0.045750
R21532 n1_M7_131132_12860 n1_M7_131132_19260 0.366000
R21533 n1_M7_131132_24060 n1_M7_131132_19260 0.274500
R21534 n1_M7_131132_24060 n1_M7_131132_25660 0.091500
R21535 n1_M7_131132_25660 n1_M7_131132_32060 0.366000
R21536 n1_M7_131132_36060 n1_M7_131132_32060 0.228750
R21537 n1_M7_131132_36060 n1_M7_131132_38460 0.137250
R21538 n1_M7_131132_38460 n1_M7_131132_44860 0.366000
R21539 n1_M7_131132_48060 n1_M7_131132_44860 0.183000
R21540 n1_M7_131132_48060 n1_M7_131132_51260 0.183000
R21541 n1_M7_131132_51260 n1_M7_131132_57660 0.366000
R21542 n1_M7_131132_60060 n1_M7_131132_57660 0.137250
R21543 n1_M7_131132_60060 n1_M7_131132_64060 0.228750
R21544 n1_M7_131132_64060 n1_M7_131132_70460 0.366000
R21545 n1_M7_131132_72060 n1_M7_131132_70460 0.091500
R21546 n1_M7_131132_72060 n1_M7_131132_76860 0.274500
R21547 n1_M7_131132_76860 n1_M7_131132_83260 0.366000
R21548 n1_M7_131132_84060 n1_M7_131132_83260 0.045750
R21549 n1_M7_131132_84060 n1_M7_131132_89660 0.320250
R21550 n1_M7_131132_96060 n1_M7_131132_89660 0.366000
R21551 n1_M7_131132_96060 n1_M7_131132_102460 0.366000
R21552 n1_M7_131132_108060 n1_M7_131132_102460 0.320250
R21553 n1_M7_131132_108060 n1_M7_131132_108860 0.045750
R21554 n1_M7_131132_108860 n1_M7_131132_115260 0.366000
R21555 n1_M7_131132_120060 n1_M7_131132_115260 0.274500
R21556 n1_M7_131132_120060 n1_M7_131132_121660 0.091500
R21557 n1_M7_131132_121660 n1_M7_131132_128060 0.366000
R21558 n1_M7_131132_132060 n1_M7_131132_128060 0.228750
R21559 n1_M7_131132_132060 n1_M7_131132_134460 0.137250
R21560 n1_M7_131132_134460 n1_M7_131132_140860 0.366000
R21561 n1_M7_131132_144060 n1_M7_131132_140860 0.183000
R21562 n1_M7_131132_144060 n1_M7_131132_147260 0.183000
R21563 n1_M7_135228_60 n1_M7_135228_6460 0.366000
R21564 n1_M7_135228_12060 n1_M7_135228_6460 0.320250
R21565 n1_M7_135228_12060 n1_M7_135228_12860 0.045750
R21566 n1_M7_135228_12860 n1_M7_135228_19260 0.366000
R21567 n1_M7_135228_24060 n1_M7_135228_19260 0.274500
R21568 n1_M7_135228_24060 n1_M7_135228_25660 0.091500
R21569 n1_M7_135228_25660 n1_M7_135228_32060 0.366000
R21570 n1_M7_135228_36060 n1_M7_135228_32060 0.228750
R21571 n1_M7_135228_36060 n1_M7_135228_38460 0.137250
R21572 n1_M7_135228_38460 n1_M7_135228_44860 0.366000
R21573 n1_M7_135228_48060 n1_M7_135228_44860 0.183000
R21574 n1_M7_135228_48060 n1_M7_135228_51260 0.183000
R21575 n1_M7_135228_51260 n1_M7_135228_57660 0.366000
R21576 n1_M7_135228_60060 n1_M7_135228_57660 0.137250
R21577 n1_M7_135228_60060 n1_M7_135228_64060 0.228750
R21578 n1_M7_135228_64060 n1_M7_135228_70460 0.366000
R21579 n1_M7_135228_72060 n1_M7_135228_70460 0.091500
R21580 n1_M7_135228_72060 n1_M7_135228_76860 0.274500
R21581 n1_M7_135228_76860 n1_M7_135228_83260 0.366000
R21582 n1_M7_135228_84060 n1_M7_135228_83260 0.045750
R21583 n1_M7_135228_84060 n1_M7_135228_89660 0.320250
R21584 n1_M7_135228_96060 n1_M7_135228_89660 0.366000
R21585 n1_M7_135228_96060 n1_M7_135228_102460 0.366000
R21586 n1_M7_135228_108060 n1_M7_135228_102460 0.320250
R21587 n1_M7_135228_108060 n1_M7_135228_108860 0.045750
R21588 n1_M7_135228_108860 n1_M7_135228_115260 0.366000
R21589 n1_M7_135228_120060 n1_M7_135228_115260 0.274500
R21590 n1_M7_135228_120060 n1_M7_135228_121660 0.091500
R21591 n1_M7_135228_121660 n1_M7_135228_128060 0.366000
R21592 n1_M7_135228_132060 n1_M7_135228_128060 0.228750
R21593 n1_M7_135228_132060 n1_M7_135228_134460 0.137250
R21594 n1_M7_135228_134460 n1_M7_135228_140860 0.366000
R21595 n1_M7_135228_144060 n1_M7_135228_140860 0.183000
R21596 n1_M7_135228_144060 n1_M7_135228_147260 0.183000
R21597 n1_M7_139324_60 n1_M7_139324_6460 0.366000
R21598 n1_M7_139324_12060 n1_M7_139324_6460 0.320250
R21599 n1_M7_139324_12060 n1_M7_139324_12860 0.045750
R21600 n1_M7_139324_12860 n1_M7_139324_19260 0.366000
R21601 n1_M7_139324_24060 n1_M7_139324_19260 0.274500
R21602 n1_M7_139324_24060 n1_M7_139324_25660 0.091500
R21603 n1_M7_139324_25660 n1_M7_139324_32060 0.366000
R21604 n1_M7_139324_36060 n1_M7_139324_32060 0.228750
R21605 n1_M7_139324_36060 n1_M7_139324_38460 0.137250
R21606 n1_M7_139324_38460 n1_M7_139324_44860 0.366000
R21607 n1_M7_139324_48060 n1_M7_139324_44860 0.183000
R21608 n1_M7_139324_48060 n1_M7_139324_51260 0.183000
R21609 n1_M7_139324_51260 n1_M7_139324_57660 0.366000
R21610 n1_M7_139324_60060 n1_M7_139324_57660 0.137250
R21611 n1_M7_139324_60060 n1_M7_139324_64060 0.228750
R21612 n1_M7_139324_64060 n1_M7_139324_70460 0.366000
R21613 n1_M7_139324_72060 n1_M7_139324_70460 0.091500
R21614 n1_M7_139324_72060 n1_M7_139324_76860 0.274500
R21615 n1_M7_139324_76860 n1_M7_139324_83260 0.366000
R21616 n1_M7_139324_84060 n1_M7_139324_83260 0.045750
R21617 n1_M7_139324_84060 n1_M7_139324_89660 0.320250
R21618 n1_M7_139324_96060 n1_M7_139324_89660 0.366000
R21619 n1_M7_139324_96060 n1_M7_139324_102460 0.366000
R21620 n1_M7_139324_108060 n1_M7_139324_102460 0.320250
R21621 n1_M7_139324_108060 n1_M7_139324_108860 0.045750
R21622 n1_M7_139324_108860 n1_M7_139324_115260 0.366000
R21623 n1_M7_139324_120060 n1_M7_139324_115260 0.274500
R21624 n1_M7_139324_120060 n1_M7_139324_121660 0.091500
R21625 n1_M7_139324_121660 n1_M7_139324_128060 0.366000
R21626 n1_M7_139324_132060 n1_M7_139324_128060 0.228750
R21627 n1_M7_139324_132060 n1_M7_139324_134460 0.137250
R21628 n1_M7_139324_134460 n1_M7_139324_140860 0.366000
R21629 n1_M7_139324_144060 n1_M7_139324_140860 0.183000
R21630 n1_M7_139324_144060 n1_M7_139324_147260 0.183000
R21631 n1_M7_143420_60 n1_M7_143420_6460 0.366000
R21632 n1_M7_143420_12060 n1_M7_143420_6460 0.320250
R21633 n1_M7_143420_12060 n1_M7_143420_12860 0.045750
R21634 n1_M7_143420_12860 n1_M7_143420_19260 0.366000
R21635 n1_M7_143420_24060 n1_M7_143420_19260 0.274500
R21636 n1_M7_143420_24060 n1_M7_143420_25660 0.091500
R21637 n1_M7_143420_25660 n1_M7_143420_32060 0.366000
R21638 n1_M7_143420_36060 n1_M7_143420_32060 0.228750
R21639 n1_M7_143420_36060 n1_M7_143420_38460 0.137250
R21640 n1_M7_143420_38460 n1_M7_143420_44860 0.366000
R21641 n1_M7_143420_48060 n1_M7_143420_44860 0.183000
R21642 n1_M7_143420_48060 n1_M7_143420_51260 0.183000
R21643 n1_M7_143420_51260 n1_M7_143420_57660 0.366000
R21644 n1_M7_143420_60060 n1_M7_143420_57660 0.137250
R21645 n1_M7_143420_60060 n1_M7_143420_64060 0.228750
R21646 n1_M7_143420_64060 n1_M7_143420_70460 0.366000
R21647 n1_M7_143420_72060 n1_M7_143420_70460 0.091500
R21648 n1_M7_143420_72060 n1_M7_143420_76860 0.274500
R21649 n1_M7_143420_76860 n1_M7_143420_83260 0.366000
R21650 n1_M7_143420_84060 n1_M7_143420_83260 0.045750
R21651 n1_M7_143420_84060 n1_M7_143420_89660 0.320250
R21652 n1_M7_143420_96060 n1_M7_143420_89660 0.366000
R21653 n1_M7_143420_96060 n1_M7_143420_102460 0.366000
R21654 n1_M7_143420_108060 n1_M7_143420_102460 0.320250
R21655 n1_M7_143420_108060 n1_M7_143420_108860 0.045750
R21656 n1_M7_143420_108860 n1_M7_143420_115260 0.366000
R21657 n1_M7_143420_120060 n1_M7_143420_115260 0.274500
R21658 n1_M7_143420_120060 n1_M7_143420_121660 0.091500
R21659 n1_M7_143420_121660 n1_M7_143420_128060 0.366000
R21660 n1_M7_143420_132060 n1_M7_143420_128060 0.228750
R21661 n1_M7_143420_132060 n1_M7_143420_134460 0.137250
R21662 n1_M7_143420_134460 n1_M7_143420_140860 0.366000
R21663 n1_M7_143420_144060 n1_M7_143420_140860 0.183000
R21664 n1_M7_143420_144060 n1_M7_143420_147260 0.183000
R21665 n1_M7_147516_60 n1_M7_147516_6460 0.366000
R21666 n1_M7_147516_12060 n1_M7_147516_6460 0.320250
R21667 n1_M7_147516_12060 n1_M7_147516_12860 0.045750
R21668 n1_M7_147516_12860 n1_M7_147516_19260 0.366000
R21669 n1_M7_147516_24060 n1_M7_147516_19260 0.274500
R21670 n1_M7_147516_24060 n1_M7_147516_25660 0.091500
R21671 n1_M7_147516_25660 n1_M7_147516_32060 0.366000
R21672 n1_M7_147516_36060 n1_M7_147516_32060 0.228750
R21673 n1_M7_147516_36060 n1_M7_147516_38460 0.137250
R21674 n1_M7_147516_38460 n1_M7_147516_44860 0.366000
R21675 n1_M7_147516_48060 n1_M7_147516_44860 0.183000
R21676 n1_M7_147516_48060 n1_M7_147516_51260 0.183000
R21677 n1_M7_147516_51260 n1_M7_147516_57660 0.366000
R21678 n1_M7_147516_60060 n1_M7_147516_57660 0.137250
R21679 n1_M7_147516_60060 n1_M7_147516_64060 0.228750
R21680 n1_M7_147516_64060 n1_M7_147516_70460 0.366000
R21681 n1_M7_147516_72060 n1_M7_147516_70460 0.091500
R21682 n1_M7_147516_72060 n1_M7_147516_76860 0.274500
R21683 n1_M7_147516_76860 n1_M7_147516_83260 0.366000
R21684 n1_M7_147516_84060 n1_M7_147516_83260 0.045750
R21685 n1_M7_147516_84060 n1_M7_147516_89660 0.320250
R21686 n1_M7_147516_96060 n1_M7_147516_89660 0.366000
R21687 n1_M7_147516_96060 n1_M7_147516_102460 0.366000
R21688 n1_M7_147516_108060 n1_M7_147516_102460 0.320250
R21689 n1_M7_147516_108060 n1_M7_147516_108860 0.045750
R21690 n1_M7_147516_108860 n1_M7_147516_115260 0.366000
R21691 n1_M7_147516_120060 n1_M7_147516_115260 0.274500
R21692 n1_M7_147516_120060 n1_M7_147516_121660 0.091500
R21693 n1_M7_147516_121660 n1_M7_147516_128060 0.366000
R21694 n1_M7_147516_132060 n1_M7_147516_128060 0.228750
R21695 n1_M7_147516_132060 n1_M7_147516_134460 0.137250
R21696 n1_M7_147516_134460 n1_M7_147516_140860 0.366000
R21697 n1_M7_147516_144060 n1_M7_147516_140860 0.183000
R21698 n1_M7_147516_144060 n1_M7_147516_147260 0.183000
R21699 n1_M8_60_60 n1_M8_1140_60 0.001755
R21700 n1_M8_1140_60 n1_M8_2220_60 0.001755
R21701 n1_M8_2220_60 n1_M8_3300_60 0.001755
R21702 n1_M8_3300_60 n1_M8_4380_60 0.001755
R21703 n1_M8_4380_60 n1_M8_5460_60 0.001755
R21704 n1_M8_5460_60 n1_M8_6540_60 0.001755
R21705 n1_M8_6540_60 n1_M8_7620_60 0.001755
R21706 n1_M8_7620_60 n1_M8_8700_60 0.001755
R21707 n1_M8_8700_60 n1_M8_9780_60 0.001755
R21708 n1_M8_9780_60 n1_M8_10860_60 0.001755
R21709 n1_M8_10860_60 n1_M8_11940_60 0.001755
R21710 n1_M8_11940_60 n1_M8_13020_60 0.001755
R21711 n1_M8_13020_60 n1_M8_14100_60 0.001755
R21712 n1_M8_14100_60 n1_M8_15180_60 0.001755
R21713 n1_M8_15180_60 n1_M8_16260_60 0.001755
R21714 n1_M8_16260_60 n1_M8_17340_60 0.001755
R21715 n1_M8_17340_60 n1_M8_18420_60 0.001755
R21716 n1_M8_18420_60 n1_M8_19500_60 0.001755
R21717 n1_M8_19500_60 n1_M8_20580_60 0.001755
R21718 n1_M8_20580_60 n1_M8_21660_60 0.001755
R21719 n1_M8_21660_60 n1_M8_22740_60 0.001755
R21720 n1_M8_22740_60 n1_M8_23820_60 0.001755
R21721 n1_M8_23820_60 n1_M8_24900_60 0.001755
R21722 n1_M8_24900_60 n1_M8_25980_60 0.001755
R21723 n1_M8_25980_60 n1_M8_27060_60 0.001755
R21724 n1_M8_27060_60 n1_M8_28140_60 0.001755
R21725 n1_M8_28140_60 n1_M8_29220_60 0.001755
R21726 n1_M8_29220_60 n1_M8_30300_60 0.001755
R21727 n1_M8_30300_60 n1_M8_31380_60 0.001755
R21728 n1_M8_31380_60 n1_M8_32460_60 0.001755
R21729 n1_M8_32460_60 n1_M8_33540_60 0.001755
R21730 n1_M8_33540_60 n1_M8_34620_60 0.001755
R21731 n1_M8_34620_60 n1_M8_35700_60 0.001755
R21732 n1_M8_35700_60 n1_M8_36780_60 0.001755
R21733 n1_M8_36780_60 n1_M8_37860_60 0.001755
R21734 n1_M8_37860_60 n1_M8_38940_60 0.001755
R21735 n1_M8_38940_60 n1_M8_40020_60 0.001755
R21736 n1_M8_40020_60 n1_M8_41100_60 0.001755
R21737 n1_M8_41100_60 n1_M8_42180_60 0.001755
R21738 n1_M8_42180_60 n1_M8_43260_60 0.001755
R21739 n1_M8_43260_60 n1_M8_44340_60 0.001755
R21740 n1_M8_44340_60 n1_M8_45420_60 0.001755
R21741 n1_M8_45420_60 n1_M8_46500_60 0.001755
R21742 n1_M8_46500_60 n1_M8_47580_60 0.001755
R21743 n1_M8_47580_60 n1_M8_48660_60 0.001755
R21744 n1_M8_48660_60 n1_M8_49740_60 0.001755
R21745 n1_M8_49740_60 n1_M8_50820_60 0.001755
R21746 n1_M8_50820_60 n1_M8_51900_60 0.001755
R21747 n1_M8_51900_60 n1_M8_52980_60 0.001755
R21748 n1_M8_52980_60 n1_M8_54060_60 0.001755
R21749 n1_M8_54060_60 n1_M8_55140_60 0.001755
R21750 n1_M8_55140_60 n1_M8_56220_60 0.001755
R21751 n1_M8_56220_60 n1_M8_57300_60 0.001755
R21752 n1_M8_57300_60 n1_M8_58380_60 0.001755
R21753 n1_M8_58380_60 n1_M8_59460_60 0.001755
R21754 n1_M8_59460_60 n1_M8_60540_60 0.001755
R21755 n1_M8_60540_60 n1_M8_61620_60 0.001755
R21756 n1_M8_61620_60 n1_M8_62700_60 0.001755
R21757 n1_M8_62700_60 n1_M8_63780_60 0.001755
R21758 n1_M8_63780_60 n1_M8_64860_60 0.001755
R21759 n1_M8_64860_60 n1_M8_65940_60 0.001755
R21760 n1_M8_65940_60 n1_M8_67020_60 0.001755
R21761 n1_M8_67020_60 n1_M8_68100_60 0.001755
R21762 n1_M8_68100_60 n1_M8_69180_60 0.001755
R21763 n1_M8_69180_60 n1_M8_70260_60 0.001755
R21764 n1_M8_70260_60 n1_M8_71340_60 0.001755
R21765 n1_M8_71340_60 n1_M8_72420_60 0.001755
R21766 n1_M8_72420_60 n1_M8_73500_60 0.001755
R21767 n1_M8_73500_60 n1_M8_74580_60 0.001755
R21768 n1_M8_74580_60 n1_M8_75660_60 0.001755
R21769 n1_M8_75660_60 n1_M8_76740_60 0.001755
R21770 n1_M8_76740_60 n1_M8_77820_60 0.001755
R21771 n1_M8_77820_60 n1_M8_78900_60 0.001755
R21772 n1_M8_78900_60 n1_M8_79980_60 0.001755
R21773 n1_M8_79980_60 n1_M8_81060_60 0.001755
R21774 n1_M8_81060_60 n1_M8_82140_60 0.001755
R21775 n1_M8_82140_60 n1_M8_83220_60 0.001755
R21776 n1_M8_83220_60 n1_M8_84300_60 0.001755
R21777 n1_M8_84300_60 n1_M8_85380_60 0.001755
R21778 n1_M8_85380_60 n1_M8_86460_60 0.001755
R21779 n1_M8_86460_60 n1_M8_87540_60 0.001755
R21780 n1_M8_87540_60 n1_M8_88620_60 0.001755
R21781 n1_M8_88620_60 n1_M8_89700_60 0.001755
R21782 n1_M8_89700_60 n1_M8_90780_60 0.001755
R21783 n1_M8_90780_60 n1_M8_91860_60 0.001755
R21784 n1_M8_91860_60 n1_M8_92940_60 0.001755
R21785 n1_M8_92940_60 n1_M8_94020_60 0.001755
R21786 n1_M8_94020_60 n1_M8_95100_60 0.001755
R21787 n1_M8_95100_60 n1_M8_96180_60 0.001755
R21788 n1_M8_96180_60 n1_M8_97260_60 0.001755
R21789 n1_M8_97260_60 n1_M8_98340_60 0.001755
R21790 n1_M8_98340_60 n1_M8_99420_60 0.001755
R21791 n1_M8_99420_60 n1_M8_100500_60 0.001755
R21792 n1_M8_100500_60 n1_M8_101580_60 0.001755
R21793 n1_M8_101580_60 n1_M8_102660_60 0.001755
R21794 n1_M8_102660_60 n1_M8_103740_60 0.001755
R21795 n1_M8_103740_60 n1_M8_104820_60 0.001755
R21796 n1_M8_104820_60 n1_M8_105900_60 0.001755
R21797 n1_M8_105900_60 n1_M8_106980_60 0.001755
R21798 n1_M8_106980_60 n1_M8_108060_60 0.001755
R21799 n1_M8_108060_60 n1_M8_109140_60 0.001755
R21800 n1_M8_109140_60 n1_M8_110220_60 0.001755
R21801 n1_M8_110220_60 n1_M8_111300_60 0.001755
R21802 n1_M8_111300_60 n1_M8_112380_60 0.001755
R21803 n1_M8_112380_60 n1_M8_113460_60 0.001755
R21804 n1_M8_113460_60 n1_M8_114540_60 0.001755
R21805 n1_M8_114540_60 n1_M8_115620_60 0.001755
R21806 n1_M8_115620_60 n1_M8_116700_60 0.001755
R21807 n1_M8_116700_60 n1_M8_117780_60 0.001755
R21808 n1_M8_117780_60 n1_M8_118860_60 0.001755
R21809 n1_M8_118860_60 n1_M8_119940_60 0.001755
R21810 n1_M8_119940_60 n1_M8_121020_60 0.001755
R21811 n1_M8_121020_60 n1_M8_122100_60 0.001755
R21812 n1_M8_122100_60 n1_M8_123180_60 0.001755
R21813 n1_M8_123180_60 n1_M8_124260_60 0.001755
R21814 n1_M8_124260_60 n1_M8_125340_60 0.001755
R21815 n1_M8_125340_60 n1_M8_126420_60 0.001755
R21816 n1_M8_126420_60 n1_M8_127500_60 0.001755
R21817 n1_M8_127500_60 n1_M8_128580_60 0.001755
R21818 n1_M8_128580_60 n1_M8_129660_60 0.001755
R21819 n1_M8_129660_60 n1_M8_130740_60 0.001755
R21820 n1_M8_130740_60 n1_M8_131820_60 0.001755
R21821 n1_M8_131820_60 n1_M8_132900_60 0.001755
R21822 n1_M8_132900_60 n1_M8_133980_60 0.001755
R21823 n1_M8_133980_60 n1_M8_135060_60 0.001755
R21824 n1_M8_135060_60 n1_M8_136140_60 0.001755
R21825 n1_M8_136140_60 n1_M8_137220_60 0.001755
R21826 n1_M8_137220_60 n1_M8_138300_60 0.001755
R21827 n1_M8_138300_60 n1_M8_139380_60 0.001755
R21828 n1_M8_139380_60 n1_M8_140460_60 0.001755
R21829 n1_M8_140460_60 n1_M8_141540_60 0.001755
R21830 n1_M8_141540_60 n1_M8_142620_60 0.001755
R21831 n1_M8_142620_60 n1_M8_143700_60 0.001755
R21832 n1_M8_143700_60 n1_M8_144780_60 0.001755
R21833 n1_M8_144780_60 n1_M8_145860_60 0.001755
R21834 n1_M8_145860_60 n1_M8_146940_60 0.001755
R21835 n1_M8_60_6460 n1_M8_1140_6460 0.001755
R21836 n1_M8_1140_6460 n1_M8_2220_6460 0.001755
R21837 n1_M8_2220_6460 n1_M8_3300_6460 0.001755
R21838 n1_M8_3300_6460 n1_M8_4380_6460 0.001755
R21839 n1_M8_4380_6460 n1_M8_5460_6460 0.001755
R21840 n1_M8_5460_6460 n1_M8_6540_6460 0.001755
R21841 n1_M8_6540_6460 n1_M8_7620_6460 0.001755
R21842 n1_M8_7620_6460 n1_M8_8700_6460 0.001755
R21843 n1_M8_8700_6460 n1_M8_9780_6460 0.001755
R21844 n1_M8_9780_6460 n1_M8_10860_6460 0.001755
R21845 n1_M8_10860_6460 n1_M8_11940_6460 0.001755
R21846 n1_M8_11940_6460 n1_M8_13020_6460 0.001755
R21847 n1_M8_13020_6460 n1_M8_14100_6460 0.001755
R21848 n1_M8_14100_6460 n1_M8_15180_6460 0.001755
R21849 n1_M8_15180_6460 n1_M8_16260_6460 0.001755
R21850 n1_M8_16260_6460 n1_M8_17340_6460 0.001755
R21851 n1_M8_17340_6460 n1_M8_18420_6460 0.001755
R21852 n1_M8_18420_6460 n1_M8_19500_6460 0.001755
R21853 n1_M8_19500_6460 n1_M8_20580_6460 0.001755
R21854 n1_M8_20580_6460 n1_M8_21660_6460 0.001755
R21855 n1_M8_21660_6460 n1_M8_22740_6460 0.001755
R21856 n1_M8_22740_6460 n1_M8_23820_6460 0.001755
R21857 n1_M8_23820_6460 n1_M8_24900_6460 0.001755
R21858 n1_M8_24900_6460 n1_M8_25980_6460 0.001755
R21859 n1_M8_25980_6460 n1_M8_27060_6460 0.001755
R21860 n1_M8_27060_6460 n1_M8_28140_6460 0.001755
R21861 n1_M8_28140_6460 n1_M8_29220_6460 0.001755
R21862 n1_M8_29220_6460 n1_M8_30300_6460 0.001755
R21863 n1_M8_30300_6460 n1_M8_31380_6460 0.001755
R21864 n1_M8_31380_6460 n1_M8_32460_6460 0.001755
R21865 n1_M8_32460_6460 n1_M8_33540_6460 0.001755
R21866 n1_M8_33540_6460 n1_M8_34620_6460 0.001755
R21867 n1_M8_34620_6460 n1_M8_35700_6460 0.001755
R21868 n1_M8_35700_6460 n1_M8_36780_6460 0.001755
R21869 n1_M8_36780_6460 n1_M8_37860_6460 0.001755
R21870 n1_M8_37860_6460 n1_M8_38940_6460 0.001755
R21871 n1_M8_38940_6460 n1_M8_40020_6460 0.001755
R21872 n1_M8_40020_6460 n1_M8_41100_6460 0.001755
R21873 n1_M8_41100_6460 n1_M8_42180_6460 0.001755
R21874 n1_M8_42180_6460 n1_M8_43260_6460 0.001755
R21875 n1_M8_43260_6460 n1_M8_44340_6460 0.001755
R21876 n1_M8_44340_6460 n1_M8_45420_6460 0.001755
R21877 n1_M8_45420_6460 n1_M8_46500_6460 0.001755
R21878 n1_M8_46500_6460 n1_M8_47580_6460 0.001755
R21879 n1_M8_47580_6460 n1_M8_48660_6460 0.001755
R21880 n1_M8_48660_6460 n1_M8_49740_6460 0.001755
R21881 n1_M8_49740_6460 n1_M8_50820_6460 0.001755
R21882 n1_M8_50820_6460 n1_M8_51900_6460 0.001755
R21883 n1_M8_51900_6460 n1_M8_52980_6460 0.001755
R21884 n1_M8_52980_6460 n1_M8_54060_6460 0.001755
R21885 n1_M8_54060_6460 n1_M8_55140_6460 0.001755
R21886 n1_M8_55140_6460 n1_M8_56220_6460 0.001755
R21887 n1_M8_56220_6460 n1_M8_57300_6460 0.001755
R21888 n1_M8_57300_6460 n1_M8_58380_6460 0.001755
R21889 n1_M8_58380_6460 n1_M8_59460_6460 0.001755
R21890 n1_M8_59460_6460 n1_M8_60540_6460 0.001755
R21891 n1_M8_60540_6460 n1_M8_61620_6460 0.001755
R21892 n1_M8_61620_6460 n1_M8_62700_6460 0.001755
R21893 n1_M8_62700_6460 n1_M8_63780_6460 0.001755
R21894 n1_M8_63780_6460 n1_M8_64860_6460 0.001755
R21895 n1_M8_64860_6460 n1_M8_65940_6460 0.001755
R21896 n1_M8_65940_6460 n1_M8_67020_6460 0.001755
R21897 n1_M8_67020_6460 n1_M8_68100_6460 0.001755
R21898 n1_M8_68100_6460 n1_M8_69180_6460 0.001755
R21899 n1_M8_69180_6460 n1_M8_70260_6460 0.001755
R21900 n1_M8_70260_6460 n1_M8_71340_6460 0.001755
R21901 n1_M8_71340_6460 n1_M8_72420_6460 0.001755
R21902 n1_M8_72420_6460 n1_M8_73500_6460 0.001755
R21903 n1_M8_73500_6460 n1_M8_74580_6460 0.001755
R21904 n1_M8_74580_6460 n1_M8_75660_6460 0.001755
R21905 n1_M8_75660_6460 n1_M8_76740_6460 0.001755
R21906 n1_M8_76740_6460 n1_M8_77820_6460 0.001755
R21907 n1_M8_77820_6460 n1_M8_78900_6460 0.001755
R21908 n1_M8_78900_6460 n1_M8_79980_6460 0.001755
R21909 n1_M8_79980_6460 n1_M8_81060_6460 0.001755
R21910 n1_M8_81060_6460 n1_M8_82140_6460 0.001755
R21911 n1_M8_82140_6460 n1_M8_83220_6460 0.001755
R21912 n1_M8_83220_6460 n1_M8_84300_6460 0.001755
R21913 n1_M8_84300_6460 n1_M8_85380_6460 0.001755
R21914 n1_M8_85380_6460 n1_M8_86460_6460 0.001755
R21915 n1_M8_86460_6460 n1_M8_87540_6460 0.001755
R21916 n1_M8_87540_6460 n1_M8_88620_6460 0.001755
R21917 n1_M8_88620_6460 n1_M8_89700_6460 0.001755
R21918 n1_M8_89700_6460 n1_M8_90780_6460 0.001755
R21919 n1_M8_90780_6460 n1_M8_91860_6460 0.001755
R21920 n1_M8_91860_6460 n1_M8_92940_6460 0.001755
R21921 n1_M8_92940_6460 n1_M8_94020_6460 0.001755
R21922 n1_M8_94020_6460 n1_M8_95100_6460 0.001755
R21923 n1_M8_95100_6460 n1_M8_96180_6460 0.001755
R21924 n1_M8_96180_6460 n1_M8_97260_6460 0.001755
R21925 n1_M8_97260_6460 n1_M8_98340_6460 0.001755
R21926 n1_M8_98340_6460 n1_M8_99420_6460 0.001755
R21927 n1_M8_99420_6460 n1_M8_100500_6460 0.001755
R21928 n1_M8_100500_6460 n1_M8_101580_6460 0.001755
R21929 n1_M8_101580_6460 n1_M8_102660_6460 0.001755
R21930 n1_M8_102660_6460 n1_M8_103740_6460 0.001755
R21931 n1_M8_103740_6460 n1_M8_104820_6460 0.001755
R21932 n1_M8_104820_6460 n1_M8_105900_6460 0.001755
R21933 n1_M8_105900_6460 n1_M8_106980_6460 0.001755
R21934 n1_M8_106980_6460 n1_M8_108060_6460 0.001755
R21935 n1_M8_108060_6460 n1_M8_109140_6460 0.001755
R21936 n1_M8_109140_6460 n1_M8_110220_6460 0.001755
R21937 n1_M8_110220_6460 n1_M8_111300_6460 0.001755
R21938 n1_M8_111300_6460 n1_M8_112380_6460 0.001755
R21939 n1_M8_112380_6460 n1_M8_113460_6460 0.001755
R21940 n1_M8_113460_6460 n1_M8_114540_6460 0.001755
R21941 n1_M8_114540_6460 n1_M8_115620_6460 0.001755
R21942 n1_M8_115620_6460 n1_M8_116700_6460 0.001755
R21943 n1_M8_116700_6460 n1_M8_117780_6460 0.001755
R21944 n1_M8_117780_6460 n1_M8_118860_6460 0.001755
R21945 n1_M8_118860_6460 n1_M8_119940_6460 0.001755
R21946 n1_M8_119940_6460 n1_M8_121020_6460 0.001755
R21947 n1_M8_121020_6460 n1_M8_122100_6460 0.001755
R21948 n1_M8_122100_6460 n1_M8_123180_6460 0.001755
R21949 n1_M8_123180_6460 n1_M8_124260_6460 0.001755
R21950 n1_M8_124260_6460 n1_M8_125340_6460 0.001755
R21951 n1_M8_125340_6460 n1_M8_126420_6460 0.001755
R21952 n1_M8_126420_6460 n1_M8_127500_6460 0.001755
R21953 n1_M8_127500_6460 n1_M8_128580_6460 0.001755
R21954 n1_M8_128580_6460 n1_M8_129660_6460 0.001755
R21955 n1_M8_129660_6460 n1_M8_130740_6460 0.001755
R21956 n1_M8_130740_6460 n1_M8_131820_6460 0.001755
R21957 n1_M8_131820_6460 n1_M8_132900_6460 0.001755
R21958 n1_M8_132900_6460 n1_M8_133980_6460 0.001755
R21959 n1_M8_133980_6460 n1_M8_135060_6460 0.001755
R21960 n1_M8_135060_6460 n1_M8_136140_6460 0.001755
R21961 n1_M8_136140_6460 n1_M8_137220_6460 0.001755
R21962 n1_M8_137220_6460 n1_M8_138300_6460 0.001755
R21963 n1_M8_138300_6460 n1_M8_139380_6460 0.001755
R21964 n1_M8_139380_6460 n1_M8_140460_6460 0.001755
R21965 n1_M8_140460_6460 n1_M8_141540_6460 0.001755
R21966 n1_M8_141540_6460 n1_M8_142620_6460 0.001755
R21967 n1_M8_142620_6460 n1_M8_143700_6460 0.001755
R21968 n1_M8_143700_6460 n1_M8_144780_6460 0.001755
R21969 n1_M8_144780_6460 n1_M8_145860_6460 0.001755
R21970 n1_M8_145860_6460 n1_M8_146940_6460 0.001755
R21971 n1_M8_60_12860 n1_M8_1140_12860 0.001755
R21972 n1_M8_1140_12860 n1_M8_2220_12860 0.001755
R21973 n1_M8_2220_12860 n1_M8_3300_12860 0.001755
R21974 n1_M8_3300_12860 n1_M8_4380_12860 0.001755
R21975 n1_M8_4380_12860 n1_M8_5460_12860 0.001755
R21976 n1_M8_5460_12860 n1_M8_6540_12860 0.001755
R21977 n1_M8_6540_12860 n1_M8_7620_12860 0.001755
R21978 n1_M8_7620_12860 n1_M8_8700_12860 0.001755
R21979 n1_M8_8700_12860 n1_M8_9780_12860 0.001755
R21980 n1_M8_9780_12860 n1_M8_10860_12860 0.001755
R21981 n1_M8_10860_12860 n1_M8_11940_12860 0.001755
R21982 n1_M8_11940_12860 n1_M8_13020_12860 0.001755
R21983 n1_M8_13020_12860 n1_M8_14100_12860 0.001755
R21984 n1_M8_14100_12860 n1_M8_15180_12860 0.001755
R21985 n1_M8_15180_12860 n1_M8_16260_12860 0.001755
R21986 n1_M8_16260_12860 n1_M8_17340_12860 0.001755
R21987 n1_M8_17340_12860 n1_M8_18420_12860 0.001755
R21988 n1_M8_18420_12860 n1_M8_19500_12860 0.001755
R21989 n1_M8_19500_12860 n1_M8_20580_12860 0.001755
R21990 n1_M8_20580_12860 n1_M8_21660_12860 0.001755
R21991 n1_M8_21660_12860 n1_M8_22740_12860 0.001755
R21992 n1_M8_22740_12860 n1_M8_23820_12860 0.001755
R21993 n1_M8_23820_12860 n1_M8_24900_12860 0.001755
R21994 n1_M8_24900_12860 n1_M8_25980_12860 0.001755
R21995 n1_M8_25980_12860 n1_M8_27060_12860 0.001755
R21996 n1_M8_27060_12860 n1_M8_28140_12860 0.001755
R21997 n1_M8_28140_12860 n1_M8_29220_12860 0.001755
R21998 n1_M8_29220_12860 n1_M8_30300_12860 0.001755
R21999 n1_M8_30300_12860 n1_M8_31380_12860 0.001755
R22000 n1_M8_31380_12860 n1_M8_32460_12860 0.001755
R22001 n1_M8_32460_12860 n1_M8_33540_12860 0.001755
R22002 n1_M8_33540_12860 n1_M8_34620_12860 0.001755
R22003 n1_M8_34620_12860 n1_M8_35700_12860 0.001755
R22004 n1_M8_35700_12860 n1_M8_36780_12860 0.001755
R22005 n1_M8_36780_12860 n1_M8_37860_12860 0.001755
R22006 n1_M8_37860_12860 n1_M8_38940_12860 0.001755
R22007 n1_M8_38940_12860 n1_M8_40020_12860 0.001755
R22008 n1_M8_40020_12860 n1_M8_41100_12860 0.001755
R22009 n1_M8_41100_12860 n1_M8_42180_12860 0.001755
R22010 n1_M8_42180_12860 n1_M8_43260_12860 0.001755
R22011 n1_M8_43260_12860 n1_M8_44340_12860 0.001755
R22012 n1_M8_44340_12860 n1_M8_45420_12860 0.001755
R22013 n1_M8_45420_12860 n1_M8_46500_12860 0.001755
R22014 n1_M8_46500_12860 n1_M8_47580_12860 0.001755
R22015 n1_M8_47580_12860 n1_M8_48660_12860 0.001755
R22016 n1_M8_48660_12860 n1_M8_49740_12860 0.001755
R22017 n1_M8_49740_12860 n1_M8_50820_12860 0.001755
R22018 n1_M8_50820_12860 n1_M8_51900_12860 0.001755
R22019 n1_M8_51900_12860 n1_M8_52980_12860 0.001755
R22020 n1_M8_52980_12860 n1_M8_54060_12860 0.001755
R22021 n1_M8_54060_12860 n1_M8_55140_12860 0.001755
R22022 n1_M8_55140_12860 n1_M8_56220_12860 0.001755
R22023 n1_M8_56220_12860 n1_M8_57300_12860 0.001755
R22024 n1_M8_57300_12860 n1_M8_58380_12860 0.001755
R22025 n1_M8_58380_12860 n1_M8_59460_12860 0.001755
R22026 n1_M8_59460_12860 n1_M8_60540_12860 0.001755
R22027 n1_M8_60540_12860 n1_M8_61620_12860 0.001755
R22028 n1_M8_61620_12860 n1_M8_62700_12860 0.001755
R22029 n1_M8_62700_12860 n1_M8_63780_12860 0.001755
R22030 n1_M8_63780_12860 n1_M8_64860_12860 0.001755
R22031 n1_M8_64860_12860 n1_M8_65940_12860 0.001755
R22032 n1_M8_65940_12860 n1_M8_67020_12860 0.001755
R22033 n1_M8_67020_12860 n1_M8_68100_12860 0.001755
R22034 n1_M8_68100_12860 n1_M8_69180_12860 0.001755
R22035 n1_M8_69180_12860 n1_M8_70260_12860 0.001755
R22036 n1_M8_70260_12860 n1_M8_71340_12860 0.001755
R22037 n1_M8_71340_12860 n1_M8_72420_12860 0.001755
R22038 n1_M8_72420_12860 n1_M8_73500_12860 0.001755
R22039 n1_M8_73500_12860 n1_M8_74580_12860 0.001755
R22040 n1_M8_74580_12860 n1_M8_75660_12860 0.001755
R22041 n1_M8_75660_12860 n1_M8_76740_12860 0.001755
R22042 n1_M8_76740_12860 n1_M8_77820_12860 0.001755
R22043 n1_M8_77820_12860 n1_M8_78900_12860 0.001755
R22044 n1_M8_78900_12860 n1_M8_79980_12860 0.001755
R22045 n1_M8_79980_12860 n1_M8_81060_12860 0.001755
R22046 n1_M8_81060_12860 n1_M8_82140_12860 0.001755
R22047 n1_M8_82140_12860 n1_M8_83220_12860 0.001755
R22048 n1_M8_83220_12860 n1_M8_84300_12860 0.001755
R22049 n1_M8_84300_12860 n1_M8_85380_12860 0.001755
R22050 n1_M8_85380_12860 n1_M8_86460_12860 0.001755
R22051 n1_M8_86460_12860 n1_M8_87540_12860 0.001755
R22052 n1_M8_87540_12860 n1_M8_88620_12860 0.001755
R22053 n1_M8_88620_12860 n1_M8_89700_12860 0.001755
R22054 n1_M8_89700_12860 n1_M8_90780_12860 0.001755
R22055 n1_M8_90780_12860 n1_M8_91860_12860 0.001755
R22056 n1_M8_91860_12860 n1_M8_92940_12860 0.001755
R22057 n1_M8_92940_12860 n1_M8_94020_12860 0.001755
R22058 n1_M8_94020_12860 n1_M8_95100_12860 0.001755
R22059 n1_M8_95100_12860 n1_M8_96180_12860 0.001755
R22060 n1_M8_96180_12860 n1_M8_97260_12860 0.001755
R22061 n1_M8_97260_12860 n1_M8_98340_12860 0.001755
R22062 n1_M8_98340_12860 n1_M8_99420_12860 0.001755
R22063 n1_M8_99420_12860 n1_M8_100500_12860 0.001755
R22064 n1_M8_100500_12860 n1_M8_101580_12860 0.001755
R22065 n1_M8_101580_12860 n1_M8_102660_12860 0.001755
R22066 n1_M8_102660_12860 n1_M8_103740_12860 0.001755
R22067 n1_M8_103740_12860 n1_M8_104820_12860 0.001755
R22068 n1_M8_104820_12860 n1_M8_105900_12860 0.001755
R22069 n1_M8_105900_12860 n1_M8_106980_12860 0.001755
R22070 n1_M8_106980_12860 n1_M8_108060_12860 0.001755
R22071 n1_M8_108060_12860 n1_M8_109140_12860 0.001755
R22072 n1_M8_109140_12860 n1_M8_110220_12860 0.001755
R22073 n1_M8_110220_12860 n1_M8_111300_12860 0.001755
R22074 n1_M8_111300_12860 n1_M8_112380_12860 0.001755
R22075 n1_M8_112380_12860 n1_M8_113460_12860 0.001755
R22076 n1_M8_113460_12860 n1_M8_114540_12860 0.001755
R22077 n1_M8_114540_12860 n1_M8_115620_12860 0.001755
R22078 n1_M8_115620_12860 n1_M8_116700_12860 0.001755
R22079 n1_M8_116700_12860 n1_M8_117780_12860 0.001755
R22080 n1_M8_117780_12860 n1_M8_118860_12860 0.001755
R22081 n1_M8_118860_12860 n1_M8_119940_12860 0.001755
R22082 n1_M8_119940_12860 n1_M8_121020_12860 0.001755
R22083 n1_M8_121020_12860 n1_M8_122100_12860 0.001755
R22084 n1_M8_122100_12860 n1_M8_123180_12860 0.001755
R22085 n1_M8_123180_12860 n1_M8_124260_12860 0.001755
R22086 n1_M8_124260_12860 n1_M8_125340_12860 0.001755
R22087 n1_M8_125340_12860 n1_M8_126420_12860 0.001755
R22088 n1_M8_126420_12860 n1_M8_127500_12860 0.001755
R22089 n1_M8_127500_12860 n1_M8_128580_12860 0.001755
R22090 n1_M8_128580_12860 n1_M8_129660_12860 0.001755
R22091 n1_M8_129660_12860 n1_M8_130740_12860 0.001755
R22092 n1_M8_130740_12860 n1_M8_131820_12860 0.001755
R22093 n1_M8_131820_12860 n1_M8_132900_12860 0.001755
R22094 n1_M8_132900_12860 n1_M8_133980_12860 0.001755
R22095 n1_M8_133980_12860 n1_M8_135060_12860 0.001755
R22096 n1_M8_135060_12860 n1_M8_136140_12860 0.001755
R22097 n1_M8_136140_12860 n1_M8_137220_12860 0.001755
R22098 n1_M8_137220_12860 n1_M8_138300_12860 0.001755
R22099 n1_M8_138300_12860 n1_M8_139380_12860 0.001755
R22100 n1_M8_139380_12860 n1_M8_140460_12860 0.001755
R22101 n1_M8_140460_12860 n1_M8_141540_12860 0.001755
R22102 n1_M8_141540_12860 n1_M8_142620_12860 0.001755
R22103 n1_M8_142620_12860 n1_M8_143700_12860 0.001755
R22104 n1_M8_143700_12860 n1_M8_144780_12860 0.001755
R22105 n1_M8_144780_12860 n1_M8_145860_12860 0.001755
R22106 n1_M8_145860_12860 n1_M8_146940_12860 0.001755
R22107 n1_M8_60_19260 n1_M8_1140_19260 0.001755
R22108 n1_M8_1140_19260 n1_M8_2220_19260 0.001755
R22109 n1_M8_2220_19260 n1_M8_3300_19260 0.001755
R22110 n1_M8_3300_19260 n1_M8_4380_19260 0.001755
R22111 n1_M8_4380_19260 n1_M8_5460_19260 0.001755
R22112 n1_M8_5460_19260 n1_M8_6540_19260 0.001755
R22113 n1_M8_6540_19260 n1_M8_7620_19260 0.001755
R22114 n1_M8_7620_19260 n1_M8_8700_19260 0.001755
R22115 n1_M8_8700_19260 n1_M8_9780_19260 0.001755
R22116 n1_M8_9780_19260 n1_M8_10860_19260 0.001755
R22117 n1_M8_10860_19260 n1_M8_11940_19260 0.001755
R22118 n1_M8_11940_19260 n1_M8_13020_19260 0.001755
R22119 n1_M8_13020_19260 n1_M8_14100_19260 0.001755
R22120 n1_M8_14100_19260 n1_M8_15180_19260 0.001755
R22121 n1_M8_15180_19260 n1_M8_16260_19260 0.001755
R22122 n1_M8_16260_19260 n1_M8_17340_19260 0.001755
R22123 n1_M8_17340_19260 n1_M8_18420_19260 0.001755
R22124 n1_M8_18420_19260 n1_M8_19500_19260 0.001755
R22125 n1_M8_19500_19260 n1_M8_20580_19260 0.001755
R22126 n1_M8_20580_19260 n1_M8_21660_19260 0.001755
R22127 n1_M8_21660_19260 n1_M8_22740_19260 0.001755
R22128 n1_M8_22740_19260 n1_M8_23820_19260 0.001755
R22129 n1_M8_23820_19260 n1_M8_24900_19260 0.001755
R22130 n1_M8_24900_19260 n1_M8_25980_19260 0.001755
R22131 n1_M8_25980_19260 n1_M8_27060_19260 0.001755
R22132 n1_M8_27060_19260 n1_M8_28140_19260 0.001755
R22133 n1_M8_28140_19260 n1_M8_29220_19260 0.001755
R22134 n1_M8_29220_19260 n1_M8_30300_19260 0.001755
R22135 n1_M8_30300_19260 n1_M8_31380_19260 0.001755
R22136 n1_M8_31380_19260 n1_M8_32460_19260 0.001755
R22137 n1_M8_32460_19260 n1_M8_33540_19260 0.001755
R22138 n1_M8_33540_19260 n1_M8_34620_19260 0.001755
R22139 n1_M8_34620_19260 n1_M8_35700_19260 0.001755
R22140 n1_M8_35700_19260 n1_M8_36780_19260 0.001755
R22141 n1_M8_36780_19260 n1_M8_37860_19260 0.001755
R22142 n1_M8_37860_19260 n1_M8_38940_19260 0.001755
R22143 n1_M8_38940_19260 n1_M8_40020_19260 0.001755
R22144 n1_M8_40020_19260 n1_M8_41100_19260 0.001755
R22145 n1_M8_41100_19260 n1_M8_42180_19260 0.001755
R22146 n1_M8_42180_19260 n1_M8_43260_19260 0.001755
R22147 n1_M8_43260_19260 n1_M8_44340_19260 0.001755
R22148 n1_M8_44340_19260 n1_M8_45420_19260 0.001755
R22149 n1_M8_45420_19260 n1_M8_46500_19260 0.001755
R22150 n1_M8_46500_19260 n1_M8_47580_19260 0.001755
R22151 n1_M8_47580_19260 n1_M8_48660_19260 0.001755
R22152 n1_M8_48660_19260 n1_M8_49740_19260 0.001755
R22153 n1_M8_49740_19260 n1_M8_50820_19260 0.001755
R22154 n1_M8_50820_19260 n1_M8_51900_19260 0.001755
R22155 n1_M8_51900_19260 n1_M8_52980_19260 0.001755
R22156 n1_M8_52980_19260 n1_M8_54060_19260 0.001755
R22157 n1_M8_54060_19260 n1_M8_55140_19260 0.001755
R22158 n1_M8_55140_19260 n1_M8_56220_19260 0.001755
R22159 n1_M8_56220_19260 n1_M8_57300_19260 0.001755
R22160 n1_M8_57300_19260 n1_M8_58380_19260 0.001755
R22161 n1_M8_58380_19260 n1_M8_59460_19260 0.001755
R22162 n1_M8_59460_19260 n1_M8_60540_19260 0.001755
R22163 n1_M8_60540_19260 n1_M8_61620_19260 0.001755
R22164 n1_M8_61620_19260 n1_M8_62700_19260 0.001755
R22165 n1_M8_62700_19260 n1_M8_63780_19260 0.001755
R22166 n1_M8_63780_19260 n1_M8_64860_19260 0.001755
R22167 n1_M8_64860_19260 n1_M8_65940_19260 0.001755
R22168 n1_M8_65940_19260 n1_M8_67020_19260 0.001755
R22169 n1_M8_67020_19260 n1_M8_68100_19260 0.001755
R22170 n1_M8_68100_19260 n1_M8_69180_19260 0.001755
R22171 n1_M8_69180_19260 n1_M8_70260_19260 0.001755
R22172 n1_M8_70260_19260 n1_M8_71340_19260 0.001755
R22173 n1_M8_71340_19260 n1_M8_72420_19260 0.001755
R22174 n1_M8_72420_19260 n1_M8_73500_19260 0.001755
R22175 n1_M8_73500_19260 n1_M8_74580_19260 0.001755
R22176 n1_M8_74580_19260 n1_M8_75660_19260 0.001755
R22177 n1_M8_75660_19260 n1_M8_76740_19260 0.001755
R22178 n1_M8_76740_19260 n1_M8_77820_19260 0.001755
R22179 n1_M8_77820_19260 n1_M8_78900_19260 0.001755
R22180 n1_M8_78900_19260 n1_M8_79980_19260 0.001755
R22181 n1_M8_79980_19260 n1_M8_81060_19260 0.001755
R22182 n1_M8_81060_19260 n1_M8_82140_19260 0.001755
R22183 n1_M8_82140_19260 n1_M8_83220_19260 0.001755
R22184 n1_M8_83220_19260 n1_M8_84300_19260 0.001755
R22185 n1_M8_84300_19260 n1_M8_85380_19260 0.001755
R22186 n1_M8_85380_19260 n1_M8_86460_19260 0.001755
R22187 n1_M8_86460_19260 n1_M8_87540_19260 0.001755
R22188 n1_M8_87540_19260 n1_M8_88620_19260 0.001755
R22189 n1_M8_88620_19260 n1_M8_89700_19260 0.001755
R22190 n1_M8_89700_19260 n1_M8_90780_19260 0.001755
R22191 n1_M8_90780_19260 n1_M8_91860_19260 0.001755
R22192 n1_M8_91860_19260 n1_M8_92940_19260 0.001755
R22193 n1_M8_92940_19260 n1_M8_94020_19260 0.001755
R22194 n1_M8_94020_19260 n1_M8_95100_19260 0.001755
R22195 n1_M8_95100_19260 n1_M8_96180_19260 0.001755
R22196 n1_M8_96180_19260 n1_M8_97260_19260 0.001755
R22197 n1_M8_97260_19260 n1_M8_98340_19260 0.001755
R22198 n1_M8_98340_19260 n1_M8_99420_19260 0.001755
R22199 n1_M8_99420_19260 n1_M8_100500_19260 0.001755
R22200 n1_M8_100500_19260 n1_M8_101580_19260 0.001755
R22201 n1_M8_101580_19260 n1_M8_102660_19260 0.001755
R22202 n1_M8_102660_19260 n1_M8_103740_19260 0.001755
R22203 n1_M8_103740_19260 n1_M8_104820_19260 0.001755
R22204 n1_M8_104820_19260 n1_M8_105900_19260 0.001755
R22205 n1_M8_105900_19260 n1_M8_106980_19260 0.001755
R22206 n1_M8_106980_19260 n1_M8_108060_19260 0.001755
R22207 n1_M8_108060_19260 n1_M8_109140_19260 0.001755
R22208 n1_M8_109140_19260 n1_M8_110220_19260 0.001755
R22209 n1_M8_110220_19260 n1_M8_111300_19260 0.001755
R22210 n1_M8_111300_19260 n1_M8_112380_19260 0.001755
R22211 n1_M8_112380_19260 n1_M8_113460_19260 0.001755
R22212 n1_M8_113460_19260 n1_M8_114540_19260 0.001755
R22213 n1_M8_114540_19260 n1_M8_115620_19260 0.001755
R22214 n1_M8_115620_19260 n1_M8_116700_19260 0.001755
R22215 n1_M8_116700_19260 n1_M8_117780_19260 0.001755
R22216 n1_M8_117780_19260 n1_M8_118860_19260 0.001755
R22217 n1_M8_118860_19260 n1_M8_119940_19260 0.001755
R22218 n1_M8_119940_19260 n1_M8_121020_19260 0.001755
R22219 n1_M8_121020_19260 n1_M8_122100_19260 0.001755
R22220 n1_M8_122100_19260 n1_M8_123180_19260 0.001755
R22221 n1_M8_123180_19260 n1_M8_124260_19260 0.001755
R22222 n1_M8_124260_19260 n1_M8_125340_19260 0.001755
R22223 n1_M8_125340_19260 n1_M8_126420_19260 0.001755
R22224 n1_M8_126420_19260 n1_M8_127500_19260 0.001755
R22225 n1_M8_127500_19260 n1_M8_128580_19260 0.001755
R22226 n1_M8_128580_19260 n1_M8_129660_19260 0.001755
R22227 n1_M8_129660_19260 n1_M8_130740_19260 0.001755
R22228 n1_M8_130740_19260 n1_M8_131820_19260 0.001755
R22229 n1_M8_131820_19260 n1_M8_132900_19260 0.001755
R22230 n1_M8_132900_19260 n1_M8_133980_19260 0.001755
R22231 n1_M8_133980_19260 n1_M8_135060_19260 0.001755
R22232 n1_M8_135060_19260 n1_M8_136140_19260 0.001755
R22233 n1_M8_136140_19260 n1_M8_137220_19260 0.001755
R22234 n1_M8_137220_19260 n1_M8_138300_19260 0.001755
R22235 n1_M8_138300_19260 n1_M8_139380_19260 0.001755
R22236 n1_M8_139380_19260 n1_M8_140460_19260 0.001755
R22237 n1_M8_140460_19260 n1_M8_141540_19260 0.001755
R22238 n1_M8_141540_19260 n1_M8_142620_19260 0.001755
R22239 n1_M8_142620_19260 n1_M8_143700_19260 0.001755
R22240 n1_M8_143700_19260 n1_M8_144780_19260 0.001755
R22241 n1_M8_144780_19260 n1_M8_145860_19260 0.001755
R22242 n1_M8_145860_19260 n1_M8_146940_19260 0.001755
R22243 n1_M8_60_25660 n1_M8_1140_25660 0.001755
R22244 n1_M8_1140_25660 n1_M8_2220_25660 0.001755
R22245 n1_M8_2220_25660 n1_M8_3300_25660 0.001755
R22246 n1_M8_3300_25660 n1_M8_4380_25660 0.001755
R22247 n1_M8_4380_25660 n1_M8_5460_25660 0.001755
R22248 n1_M8_5460_25660 n1_M8_6540_25660 0.001755
R22249 n1_M8_6540_25660 n1_M8_7620_25660 0.001755
R22250 n1_M8_7620_25660 n1_M8_8700_25660 0.001755
R22251 n1_M8_8700_25660 n1_M8_9780_25660 0.001755
R22252 n1_M8_9780_25660 n1_M8_10860_25660 0.001755
R22253 n1_M8_10860_25660 n1_M8_11940_25660 0.001755
R22254 n1_M8_11940_25660 n1_M8_13020_25660 0.001755
R22255 n1_M8_13020_25660 n1_M8_14100_25660 0.001755
R22256 n1_M8_14100_25660 n1_M8_15180_25660 0.001755
R22257 n1_M8_15180_25660 n1_M8_16260_25660 0.001755
R22258 n1_M8_16260_25660 n1_M8_17340_25660 0.001755
R22259 n1_M8_17340_25660 n1_M8_18420_25660 0.001755
R22260 n1_M8_18420_25660 n1_M8_19500_25660 0.001755
R22261 n1_M8_19500_25660 n1_M8_20580_25660 0.001755
R22262 n1_M8_20580_25660 n1_M8_21660_25660 0.001755
R22263 n1_M8_21660_25660 n1_M8_22740_25660 0.001755
R22264 n1_M8_22740_25660 n1_M8_23820_25660 0.001755
R22265 n1_M8_23820_25660 n1_M8_24900_25660 0.001755
R22266 n1_M8_24900_25660 n1_M8_25980_25660 0.001755
R22267 n1_M8_25980_25660 n1_M8_27060_25660 0.001755
R22268 n1_M8_27060_25660 n1_M8_28140_25660 0.001755
R22269 n1_M8_28140_25660 n1_M8_29220_25660 0.001755
R22270 n1_M8_29220_25660 n1_M8_30300_25660 0.001755
R22271 n1_M8_30300_25660 n1_M8_31380_25660 0.001755
R22272 n1_M8_31380_25660 n1_M8_32460_25660 0.001755
R22273 n1_M8_32460_25660 n1_M8_33540_25660 0.001755
R22274 n1_M8_33540_25660 n1_M8_34620_25660 0.001755
R22275 n1_M8_34620_25660 n1_M8_35700_25660 0.001755
R22276 n1_M8_35700_25660 n1_M8_36780_25660 0.001755
R22277 n1_M8_36780_25660 n1_M8_37860_25660 0.001755
R22278 n1_M8_37860_25660 n1_M8_38940_25660 0.001755
R22279 n1_M8_38940_25660 n1_M8_40020_25660 0.001755
R22280 n1_M8_40020_25660 n1_M8_41100_25660 0.001755
R22281 n1_M8_41100_25660 n1_M8_42180_25660 0.001755
R22282 n1_M8_42180_25660 n1_M8_43260_25660 0.001755
R22283 n1_M8_43260_25660 n1_M8_44340_25660 0.001755
R22284 n1_M8_44340_25660 n1_M8_45420_25660 0.001755
R22285 n1_M8_45420_25660 n1_M8_46500_25660 0.001755
R22286 n1_M8_46500_25660 n1_M8_47580_25660 0.001755
R22287 n1_M8_47580_25660 n1_M8_48660_25660 0.001755
R22288 n1_M8_48660_25660 n1_M8_49740_25660 0.001755
R22289 n1_M8_49740_25660 n1_M8_50820_25660 0.001755
R22290 n1_M8_50820_25660 n1_M8_51900_25660 0.001755
R22291 n1_M8_51900_25660 n1_M8_52980_25660 0.001755
R22292 n1_M8_52980_25660 n1_M8_54060_25660 0.001755
R22293 n1_M8_54060_25660 n1_M8_55140_25660 0.001755
R22294 n1_M8_55140_25660 n1_M8_56220_25660 0.001755
R22295 n1_M8_56220_25660 n1_M8_57300_25660 0.001755
R22296 n1_M8_57300_25660 n1_M8_58380_25660 0.001755
R22297 n1_M8_58380_25660 n1_M8_59460_25660 0.001755
R22298 n1_M8_59460_25660 n1_M8_60540_25660 0.001755
R22299 n1_M8_60540_25660 n1_M8_61620_25660 0.001755
R22300 n1_M8_61620_25660 n1_M8_62700_25660 0.001755
R22301 n1_M8_62700_25660 n1_M8_63780_25660 0.001755
R22302 n1_M8_63780_25660 n1_M8_64860_25660 0.001755
R22303 n1_M8_64860_25660 n1_M8_65940_25660 0.001755
R22304 n1_M8_65940_25660 n1_M8_67020_25660 0.001755
R22305 n1_M8_67020_25660 n1_M8_68100_25660 0.001755
R22306 n1_M8_68100_25660 n1_M8_69180_25660 0.001755
R22307 n1_M8_69180_25660 n1_M8_70260_25660 0.001755
R22308 n1_M8_70260_25660 n1_M8_71340_25660 0.001755
R22309 n1_M8_71340_25660 n1_M8_72420_25660 0.001755
R22310 n1_M8_72420_25660 n1_M8_73500_25660 0.001755
R22311 n1_M8_73500_25660 n1_M8_74580_25660 0.001755
R22312 n1_M8_74580_25660 n1_M8_75660_25660 0.001755
R22313 n1_M8_75660_25660 n1_M8_76740_25660 0.001755
R22314 n1_M8_76740_25660 n1_M8_77820_25660 0.001755
R22315 n1_M8_77820_25660 n1_M8_78900_25660 0.001755
R22316 n1_M8_78900_25660 n1_M8_79980_25660 0.001755
R22317 n1_M8_79980_25660 n1_M8_81060_25660 0.001755
R22318 n1_M8_81060_25660 n1_M8_82140_25660 0.001755
R22319 n1_M8_82140_25660 n1_M8_83220_25660 0.001755
R22320 n1_M8_83220_25660 n1_M8_84300_25660 0.001755
R22321 n1_M8_84300_25660 n1_M8_85380_25660 0.001755
R22322 n1_M8_85380_25660 n1_M8_86460_25660 0.001755
R22323 n1_M8_86460_25660 n1_M8_87540_25660 0.001755
R22324 n1_M8_87540_25660 n1_M8_88620_25660 0.001755
R22325 n1_M8_88620_25660 n1_M8_89700_25660 0.001755
R22326 n1_M8_89700_25660 n1_M8_90780_25660 0.001755
R22327 n1_M8_90780_25660 n1_M8_91860_25660 0.001755
R22328 n1_M8_91860_25660 n1_M8_92940_25660 0.001755
R22329 n1_M8_92940_25660 n1_M8_94020_25660 0.001755
R22330 n1_M8_94020_25660 n1_M8_95100_25660 0.001755
R22331 n1_M8_95100_25660 n1_M8_96180_25660 0.001755
R22332 n1_M8_96180_25660 n1_M8_97260_25660 0.001755
R22333 n1_M8_97260_25660 n1_M8_98340_25660 0.001755
R22334 n1_M8_98340_25660 n1_M8_99420_25660 0.001755
R22335 n1_M8_99420_25660 n1_M8_100500_25660 0.001755
R22336 n1_M8_100500_25660 n1_M8_101580_25660 0.001755
R22337 n1_M8_101580_25660 n1_M8_102660_25660 0.001755
R22338 n1_M8_102660_25660 n1_M8_103740_25660 0.001755
R22339 n1_M8_103740_25660 n1_M8_104820_25660 0.001755
R22340 n1_M8_104820_25660 n1_M8_105900_25660 0.001755
R22341 n1_M8_105900_25660 n1_M8_106980_25660 0.001755
R22342 n1_M8_106980_25660 n1_M8_108060_25660 0.001755
R22343 n1_M8_108060_25660 n1_M8_109140_25660 0.001755
R22344 n1_M8_109140_25660 n1_M8_110220_25660 0.001755
R22345 n1_M8_110220_25660 n1_M8_111300_25660 0.001755
R22346 n1_M8_111300_25660 n1_M8_112380_25660 0.001755
R22347 n1_M8_112380_25660 n1_M8_113460_25660 0.001755
R22348 n1_M8_113460_25660 n1_M8_114540_25660 0.001755
R22349 n1_M8_114540_25660 n1_M8_115620_25660 0.001755
R22350 n1_M8_115620_25660 n1_M8_116700_25660 0.001755
R22351 n1_M8_116700_25660 n1_M8_117780_25660 0.001755
R22352 n1_M8_117780_25660 n1_M8_118860_25660 0.001755
R22353 n1_M8_118860_25660 n1_M8_119940_25660 0.001755
R22354 n1_M8_119940_25660 n1_M8_121020_25660 0.001755
R22355 n1_M8_121020_25660 n1_M8_122100_25660 0.001755
R22356 n1_M8_122100_25660 n1_M8_123180_25660 0.001755
R22357 n1_M8_123180_25660 n1_M8_124260_25660 0.001755
R22358 n1_M8_124260_25660 n1_M8_125340_25660 0.001755
R22359 n1_M8_125340_25660 n1_M8_126420_25660 0.001755
R22360 n1_M8_126420_25660 n1_M8_127500_25660 0.001755
R22361 n1_M8_127500_25660 n1_M8_128580_25660 0.001755
R22362 n1_M8_128580_25660 n1_M8_129660_25660 0.001755
R22363 n1_M8_129660_25660 n1_M8_130740_25660 0.001755
R22364 n1_M8_130740_25660 n1_M8_131820_25660 0.001755
R22365 n1_M8_131820_25660 n1_M8_132900_25660 0.001755
R22366 n1_M8_132900_25660 n1_M8_133980_25660 0.001755
R22367 n1_M8_133980_25660 n1_M8_135060_25660 0.001755
R22368 n1_M8_135060_25660 n1_M8_136140_25660 0.001755
R22369 n1_M8_136140_25660 n1_M8_137220_25660 0.001755
R22370 n1_M8_137220_25660 n1_M8_138300_25660 0.001755
R22371 n1_M8_138300_25660 n1_M8_139380_25660 0.001755
R22372 n1_M8_139380_25660 n1_M8_140460_25660 0.001755
R22373 n1_M8_140460_25660 n1_M8_141540_25660 0.001755
R22374 n1_M8_141540_25660 n1_M8_142620_25660 0.001755
R22375 n1_M8_142620_25660 n1_M8_143700_25660 0.001755
R22376 n1_M8_143700_25660 n1_M8_144780_25660 0.001755
R22377 n1_M8_144780_25660 n1_M8_145860_25660 0.001755
R22378 n1_M8_145860_25660 n1_M8_146940_25660 0.001755
R22379 n1_M8_60_32060 n1_M8_1140_32060 0.001755
R22380 n1_M8_1140_32060 n1_M8_2220_32060 0.001755
R22381 n1_M8_2220_32060 n1_M8_3300_32060 0.001755
R22382 n1_M8_3300_32060 n1_M8_4380_32060 0.001755
R22383 n1_M8_4380_32060 n1_M8_5460_32060 0.001755
R22384 n1_M8_5460_32060 n1_M8_6540_32060 0.001755
R22385 n1_M8_6540_32060 n1_M8_7620_32060 0.001755
R22386 n1_M8_7620_32060 n1_M8_8700_32060 0.001755
R22387 n1_M8_8700_32060 n1_M8_9780_32060 0.001755
R22388 n1_M8_9780_32060 n1_M8_10860_32060 0.001755
R22389 n1_M8_10860_32060 n1_M8_11940_32060 0.001755
R22390 n1_M8_11940_32060 n1_M8_13020_32060 0.001755
R22391 n1_M8_13020_32060 n1_M8_14100_32060 0.001755
R22392 n1_M8_14100_32060 n1_M8_15180_32060 0.001755
R22393 n1_M8_15180_32060 n1_M8_16260_32060 0.001755
R22394 n1_M8_16260_32060 n1_M8_17340_32060 0.001755
R22395 n1_M8_17340_32060 n1_M8_18420_32060 0.001755
R22396 n1_M8_18420_32060 n1_M8_19500_32060 0.001755
R22397 n1_M8_19500_32060 n1_M8_20580_32060 0.001755
R22398 n1_M8_20580_32060 n1_M8_21660_32060 0.001755
R22399 n1_M8_21660_32060 n1_M8_22740_32060 0.001755
R22400 n1_M8_22740_32060 n1_M8_23820_32060 0.001755
R22401 n1_M8_23820_32060 n1_M8_24900_32060 0.001755
R22402 n1_M8_24900_32060 n1_M8_25980_32060 0.001755
R22403 n1_M8_25980_32060 n1_M8_27060_32060 0.001755
R22404 n1_M8_27060_32060 n1_M8_28140_32060 0.001755
R22405 n1_M8_28140_32060 n1_M8_29220_32060 0.001755
R22406 n1_M8_29220_32060 n1_M8_30300_32060 0.001755
R22407 n1_M8_30300_32060 n1_M8_31380_32060 0.001755
R22408 n1_M8_31380_32060 n1_M8_32460_32060 0.001755
R22409 n1_M8_32460_32060 n1_M8_33540_32060 0.001755
R22410 n1_M8_33540_32060 n1_M8_34620_32060 0.001755
R22411 n1_M8_34620_32060 n1_M8_35700_32060 0.001755
R22412 n1_M8_35700_32060 n1_M8_36780_32060 0.001755
R22413 n1_M8_36780_32060 n1_M8_37860_32060 0.001755
R22414 n1_M8_37860_32060 n1_M8_38940_32060 0.001755
R22415 n1_M8_38940_32060 n1_M8_40020_32060 0.001755
R22416 n1_M8_40020_32060 n1_M8_41100_32060 0.001755
R22417 n1_M8_41100_32060 n1_M8_42180_32060 0.001755
R22418 n1_M8_42180_32060 n1_M8_43260_32060 0.001755
R22419 n1_M8_43260_32060 n1_M8_44340_32060 0.001755
R22420 n1_M8_44340_32060 n1_M8_45420_32060 0.001755
R22421 n1_M8_45420_32060 n1_M8_46500_32060 0.001755
R22422 n1_M8_46500_32060 n1_M8_47580_32060 0.001755
R22423 n1_M8_47580_32060 n1_M8_48660_32060 0.001755
R22424 n1_M8_48660_32060 n1_M8_49740_32060 0.001755
R22425 n1_M8_49740_32060 n1_M8_50820_32060 0.001755
R22426 n1_M8_50820_32060 n1_M8_51900_32060 0.001755
R22427 n1_M8_51900_32060 n1_M8_52980_32060 0.001755
R22428 n1_M8_52980_32060 n1_M8_54060_32060 0.001755
R22429 n1_M8_54060_32060 n1_M8_55140_32060 0.001755
R22430 n1_M8_55140_32060 n1_M8_56220_32060 0.001755
R22431 n1_M8_56220_32060 n1_M8_57300_32060 0.001755
R22432 n1_M8_57300_32060 n1_M8_58380_32060 0.001755
R22433 n1_M8_58380_32060 n1_M8_59460_32060 0.001755
R22434 n1_M8_59460_32060 n1_M8_60540_32060 0.001755
R22435 n1_M8_60540_32060 n1_M8_61620_32060 0.001755
R22436 n1_M8_61620_32060 n1_M8_62700_32060 0.001755
R22437 n1_M8_62700_32060 n1_M8_63780_32060 0.001755
R22438 n1_M8_63780_32060 n1_M8_64860_32060 0.001755
R22439 n1_M8_64860_32060 n1_M8_65940_32060 0.001755
R22440 n1_M8_65940_32060 n1_M8_67020_32060 0.001755
R22441 n1_M8_67020_32060 n1_M8_68100_32060 0.001755
R22442 n1_M8_68100_32060 n1_M8_69180_32060 0.001755
R22443 n1_M8_69180_32060 n1_M8_70260_32060 0.001755
R22444 n1_M8_70260_32060 n1_M8_71340_32060 0.001755
R22445 n1_M8_71340_32060 n1_M8_72420_32060 0.001755
R22446 n1_M8_72420_32060 n1_M8_73500_32060 0.001755
R22447 n1_M8_73500_32060 n1_M8_74580_32060 0.001755
R22448 n1_M8_74580_32060 n1_M8_75660_32060 0.001755
R22449 n1_M8_75660_32060 n1_M8_76740_32060 0.001755
R22450 n1_M8_76740_32060 n1_M8_77820_32060 0.001755
R22451 n1_M8_77820_32060 n1_M8_78900_32060 0.001755
R22452 n1_M8_78900_32060 n1_M8_79980_32060 0.001755
R22453 n1_M8_79980_32060 n1_M8_81060_32060 0.001755
R22454 n1_M8_81060_32060 n1_M8_82140_32060 0.001755
R22455 n1_M8_82140_32060 n1_M8_83220_32060 0.001755
R22456 n1_M8_83220_32060 n1_M8_84300_32060 0.001755
R22457 n1_M8_84300_32060 n1_M8_85380_32060 0.001755
R22458 n1_M8_85380_32060 n1_M8_86460_32060 0.001755
R22459 n1_M8_86460_32060 n1_M8_87540_32060 0.001755
R22460 n1_M8_87540_32060 n1_M8_88620_32060 0.001755
R22461 n1_M8_88620_32060 n1_M8_89700_32060 0.001755
R22462 n1_M8_89700_32060 n1_M8_90780_32060 0.001755
R22463 n1_M8_90780_32060 n1_M8_91860_32060 0.001755
R22464 n1_M8_91860_32060 n1_M8_92940_32060 0.001755
R22465 n1_M8_92940_32060 n1_M8_94020_32060 0.001755
R22466 n1_M8_94020_32060 n1_M8_95100_32060 0.001755
R22467 n1_M8_95100_32060 n1_M8_96180_32060 0.001755
R22468 n1_M8_96180_32060 n1_M8_97260_32060 0.001755
R22469 n1_M8_97260_32060 n1_M8_98340_32060 0.001755
R22470 n1_M8_98340_32060 n1_M8_99420_32060 0.001755
R22471 n1_M8_99420_32060 n1_M8_100500_32060 0.001755
R22472 n1_M8_100500_32060 n1_M8_101580_32060 0.001755
R22473 n1_M8_101580_32060 n1_M8_102660_32060 0.001755
R22474 n1_M8_102660_32060 n1_M8_103740_32060 0.001755
R22475 n1_M8_103740_32060 n1_M8_104820_32060 0.001755
R22476 n1_M8_104820_32060 n1_M8_105900_32060 0.001755
R22477 n1_M8_105900_32060 n1_M8_106980_32060 0.001755
R22478 n1_M8_106980_32060 n1_M8_108060_32060 0.001755
R22479 n1_M8_108060_32060 n1_M8_109140_32060 0.001755
R22480 n1_M8_109140_32060 n1_M8_110220_32060 0.001755
R22481 n1_M8_110220_32060 n1_M8_111300_32060 0.001755
R22482 n1_M8_111300_32060 n1_M8_112380_32060 0.001755
R22483 n1_M8_112380_32060 n1_M8_113460_32060 0.001755
R22484 n1_M8_113460_32060 n1_M8_114540_32060 0.001755
R22485 n1_M8_114540_32060 n1_M8_115620_32060 0.001755
R22486 n1_M8_115620_32060 n1_M8_116700_32060 0.001755
R22487 n1_M8_116700_32060 n1_M8_117780_32060 0.001755
R22488 n1_M8_117780_32060 n1_M8_118860_32060 0.001755
R22489 n1_M8_118860_32060 n1_M8_119940_32060 0.001755
R22490 n1_M8_119940_32060 n1_M8_121020_32060 0.001755
R22491 n1_M8_121020_32060 n1_M8_122100_32060 0.001755
R22492 n1_M8_122100_32060 n1_M8_123180_32060 0.001755
R22493 n1_M8_123180_32060 n1_M8_124260_32060 0.001755
R22494 n1_M8_124260_32060 n1_M8_125340_32060 0.001755
R22495 n1_M8_125340_32060 n1_M8_126420_32060 0.001755
R22496 n1_M8_126420_32060 n1_M8_127500_32060 0.001755
R22497 n1_M8_127500_32060 n1_M8_128580_32060 0.001755
R22498 n1_M8_128580_32060 n1_M8_129660_32060 0.001755
R22499 n1_M8_129660_32060 n1_M8_130740_32060 0.001755
R22500 n1_M8_130740_32060 n1_M8_131820_32060 0.001755
R22501 n1_M8_131820_32060 n1_M8_132900_32060 0.001755
R22502 n1_M8_132900_32060 n1_M8_133980_32060 0.001755
R22503 n1_M8_133980_32060 n1_M8_135060_32060 0.001755
R22504 n1_M8_135060_32060 n1_M8_136140_32060 0.001755
R22505 n1_M8_136140_32060 n1_M8_137220_32060 0.001755
R22506 n1_M8_137220_32060 n1_M8_138300_32060 0.001755
R22507 n1_M8_138300_32060 n1_M8_139380_32060 0.001755
R22508 n1_M8_139380_32060 n1_M8_140460_32060 0.001755
R22509 n1_M8_140460_32060 n1_M8_141540_32060 0.001755
R22510 n1_M8_141540_32060 n1_M8_142620_32060 0.001755
R22511 n1_M8_142620_32060 n1_M8_143700_32060 0.001755
R22512 n1_M8_143700_32060 n1_M8_144780_32060 0.001755
R22513 n1_M8_144780_32060 n1_M8_145860_32060 0.001755
R22514 n1_M8_145860_32060 n1_M8_146940_32060 0.001755
R22515 n1_M8_60_38460 n1_M8_1140_38460 0.001755
R22516 n1_M8_1140_38460 n1_M8_2220_38460 0.001755
R22517 n1_M8_2220_38460 n1_M8_3300_38460 0.001755
R22518 n1_M8_3300_38460 n1_M8_4380_38460 0.001755
R22519 n1_M8_4380_38460 n1_M8_5460_38460 0.001755
R22520 n1_M8_5460_38460 n1_M8_6540_38460 0.001755
R22521 n1_M8_6540_38460 n1_M8_7620_38460 0.001755
R22522 n1_M8_7620_38460 n1_M8_8700_38460 0.001755
R22523 n1_M8_8700_38460 n1_M8_9780_38460 0.001755
R22524 n1_M8_9780_38460 n1_M8_10860_38460 0.001755
R22525 n1_M8_10860_38460 n1_M8_11940_38460 0.001755
R22526 n1_M8_11940_38460 n1_M8_13020_38460 0.001755
R22527 n1_M8_13020_38460 n1_M8_14100_38460 0.001755
R22528 n1_M8_14100_38460 n1_M8_15180_38460 0.001755
R22529 n1_M8_15180_38460 n1_M8_16260_38460 0.001755
R22530 n1_M8_16260_38460 n1_M8_17340_38460 0.001755
R22531 n1_M8_17340_38460 n1_M8_18420_38460 0.001755
R22532 n1_M8_18420_38460 n1_M8_19500_38460 0.001755
R22533 n1_M8_19500_38460 n1_M8_20580_38460 0.001755
R22534 n1_M8_20580_38460 n1_M8_21660_38460 0.001755
R22535 n1_M8_21660_38460 n1_M8_22740_38460 0.001755
R22536 n1_M8_22740_38460 n1_M8_23820_38460 0.001755
R22537 n1_M8_23820_38460 n1_M8_24900_38460 0.001755
R22538 n1_M8_24900_38460 n1_M8_25980_38460 0.001755
R22539 n1_M8_25980_38460 n1_M8_27060_38460 0.001755
R22540 n1_M8_27060_38460 n1_M8_28140_38460 0.001755
R22541 n1_M8_28140_38460 n1_M8_29220_38460 0.001755
R22542 n1_M8_29220_38460 n1_M8_30300_38460 0.001755
R22543 n1_M8_30300_38460 n1_M8_31380_38460 0.001755
R22544 n1_M8_31380_38460 n1_M8_32460_38460 0.001755
R22545 n1_M8_32460_38460 n1_M8_33540_38460 0.001755
R22546 n1_M8_33540_38460 n1_M8_34620_38460 0.001755
R22547 n1_M8_34620_38460 n1_M8_35700_38460 0.001755
R22548 n1_M8_35700_38460 n1_M8_36780_38460 0.001755
R22549 n1_M8_36780_38460 n1_M8_37860_38460 0.001755
R22550 n1_M8_37860_38460 n1_M8_38940_38460 0.001755
R22551 n1_M8_38940_38460 n1_M8_40020_38460 0.001755
R22552 n1_M8_40020_38460 n1_M8_41100_38460 0.001755
R22553 n1_M8_41100_38460 n1_M8_42180_38460 0.001755
R22554 n1_M8_42180_38460 n1_M8_43260_38460 0.001755
R22555 n1_M8_43260_38460 n1_M8_44340_38460 0.001755
R22556 n1_M8_44340_38460 n1_M8_45420_38460 0.001755
R22557 n1_M8_45420_38460 n1_M8_46500_38460 0.001755
R22558 n1_M8_46500_38460 n1_M8_47580_38460 0.001755
R22559 n1_M8_47580_38460 n1_M8_48660_38460 0.001755
R22560 n1_M8_48660_38460 n1_M8_49740_38460 0.001755
R22561 n1_M8_49740_38460 n1_M8_50820_38460 0.001755
R22562 n1_M8_50820_38460 n1_M8_51900_38460 0.001755
R22563 n1_M8_51900_38460 n1_M8_52980_38460 0.001755
R22564 n1_M8_52980_38460 n1_M8_54060_38460 0.001755
R22565 n1_M8_54060_38460 n1_M8_55140_38460 0.001755
R22566 n1_M8_55140_38460 n1_M8_56220_38460 0.001755
R22567 n1_M8_56220_38460 n1_M8_57300_38460 0.001755
R22568 n1_M8_57300_38460 n1_M8_58380_38460 0.001755
R22569 n1_M8_58380_38460 n1_M8_59460_38460 0.001755
R22570 n1_M8_59460_38460 n1_M8_60540_38460 0.001755
R22571 n1_M8_60540_38460 n1_M8_61620_38460 0.001755
R22572 n1_M8_61620_38460 n1_M8_62700_38460 0.001755
R22573 n1_M8_62700_38460 n1_M8_63780_38460 0.001755
R22574 n1_M8_63780_38460 n1_M8_64860_38460 0.001755
R22575 n1_M8_64860_38460 n1_M8_65940_38460 0.001755
R22576 n1_M8_65940_38460 n1_M8_67020_38460 0.001755
R22577 n1_M8_67020_38460 n1_M8_68100_38460 0.001755
R22578 n1_M8_68100_38460 n1_M8_69180_38460 0.001755
R22579 n1_M8_69180_38460 n1_M8_70260_38460 0.001755
R22580 n1_M8_70260_38460 n1_M8_71340_38460 0.001755
R22581 n1_M8_71340_38460 n1_M8_72420_38460 0.001755
R22582 n1_M8_72420_38460 n1_M8_73500_38460 0.001755
R22583 n1_M8_73500_38460 n1_M8_74580_38460 0.001755
R22584 n1_M8_74580_38460 n1_M8_75660_38460 0.001755
R22585 n1_M8_75660_38460 n1_M8_76740_38460 0.001755
R22586 n1_M8_76740_38460 n1_M8_77820_38460 0.001755
R22587 n1_M8_77820_38460 n1_M8_78900_38460 0.001755
R22588 n1_M8_78900_38460 n1_M8_79980_38460 0.001755
R22589 n1_M8_79980_38460 n1_M8_81060_38460 0.001755
R22590 n1_M8_81060_38460 n1_M8_82140_38460 0.001755
R22591 n1_M8_82140_38460 n1_M8_83220_38460 0.001755
R22592 n1_M8_83220_38460 n1_M8_84300_38460 0.001755
R22593 n1_M8_84300_38460 n1_M8_85380_38460 0.001755
R22594 n1_M8_85380_38460 n1_M8_86460_38460 0.001755
R22595 n1_M8_86460_38460 n1_M8_87540_38460 0.001755
R22596 n1_M8_87540_38460 n1_M8_88620_38460 0.001755
R22597 n1_M8_88620_38460 n1_M8_89700_38460 0.001755
R22598 n1_M8_89700_38460 n1_M8_90780_38460 0.001755
R22599 n1_M8_90780_38460 n1_M8_91860_38460 0.001755
R22600 n1_M8_91860_38460 n1_M8_92940_38460 0.001755
R22601 n1_M8_92940_38460 n1_M8_94020_38460 0.001755
R22602 n1_M8_94020_38460 n1_M8_95100_38460 0.001755
R22603 n1_M8_95100_38460 n1_M8_96180_38460 0.001755
R22604 n1_M8_96180_38460 n1_M8_97260_38460 0.001755
R22605 n1_M8_97260_38460 n1_M8_98340_38460 0.001755
R22606 n1_M8_98340_38460 n1_M8_99420_38460 0.001755
R22607 n1_M8_99420_38460 n1_M8_100500_38460 0.001755
R22608 n1_M8_100500_38460 n1_M8_101580_38460 0.001755
R22609 n1_M8_101580_38460 n1_M8_102660_38460 0.001755
R22610 n1_M8_102660_38460 n1_M8_103740_38460 0.001755
R22611 n1_M8_103740_38460 n1_M8_104820_38460 0.001755
R22612 n1_M8_104820_38460 n1_M8_105900_38460 0.001755
R22613 n1_M8_105900_38460 n1_M8_106980_38460 0.001755
R22614 n1_M8_106980_38460 n1_M8_108060_38460 0.001755
R22615 n1_M8_108060_38460 n1_M8_109140_38460 0.001755
R22616 n1_M8_109140_38460 n1_M8_110220_38460 0.001755
R22617 n1_M8_110220_38460 n1_M8_111300_38460 0.001755
R22618 n1_M8_111300_38460 n1_M8_112380_38460 0.001755
R22619 n1_M8_112380_38460 n1_M8_113460_38460 0.001755
R22620 n1_M8_113460_38460 n1_M8_114540_38460 0.001755
R22621 n1_M8_114540_38460 n1_M8_115620_38460 0.001755
R22622 n1_M8_115620_38460 n1_M8_116700_38460 0.001755
R22623 n1_M8_116700_38460 n1_M8_117780_38460 0.001755
R22624 n1_M8_117780_38460 n1_M8_118860_38460 0.001755
R22625 n1_M8_118860_38460 n1_M8_119940_38460 0.001755
R22626 n1_M8_119940_38460 n1_M8_121020_38460 0.001755
R22627 n1_M8_121020_38460 n1_M8_122100_38460 0.001755
R22628 n1_M8_122100_38460 n1_M8_123180_38460 0.001755
R22629 n1_M8_123180_38460 n1_M8_124260_38460 0.001755
R22630 n1_M8_124260_38460 n1_M8_125340_38460 0.001755
R22631 n1_M8_125340_38460 n1_M8_126420_38460 0.001755
R22632 n1_M8_126420_38460 n1_M8_127500_38460 0.001755
R22633 n1_M8_127500_38460 n1_M8_128580_38460 0.001755
R22634 n1_M8_128580_38460 n1_M8_129660_38460 0.001755
R22635 n1_M8_129660_38460 n1_M8_130740_38460 0.001755
R22636 n1_M8_130740_38460 n1_M8_131820_38460 0.001755
R22637 n1_M8_131820_38460 n1_M8_132900_38460 0.001755
R22638 n1_M8_132900_38460 n1_M8_133980_38460 0.001755
R22639 n1_M8_133980_38460 n1_M8_135060_38460 0.001755
R22640 n1_M8_135060_38460 n1_M8_136140_38460 0.001755
R22641 n1_M8_136140_38460 n1_M8_137220_38460 0.001755
R22642 n1_M8_137220_38460 n1_M8_138300_38460 0.001755
R22643 n1_M8_138300_38460 n1_M8_139380_38460 0.001755
R22644 n1_M8_139380_38460 n1_M8_140460_38460 0.001755
R22645 n1_M8_140460_38460 n1_M8_141540_38460 0.001755
R22646 n1_M8_141540_38460 n1_M8_142620_38460 0.001755
R22647 n1_M8_142620_38460 n1_M8_143700_38460 0.001755
R22648 n1_M8_143700_38460 n1_M8_144780_38460 0.001755
R22649 n1_M8_144780_38460 n1_M8_145860_38460 0.001755
R22650 n1_M8_145860_38460 n1_M8_146940_38460 0.001755
R22651 n1_M8_60_44860 n1_M8_1140_44860 0.001755
R22652 n1_M8_1140_44860 n1_M8_2220_44860 0.001755
R22653 n1_M8_2220_44860 n1_M8_3300_44860 0.001755
R22654 n1_M8_3300_44860 n1_M8_4380_44860 0.001755
R22655 n1_M8_4380_44860 n1_M8_5460_44860 0.001755
R22656 n1_M8_5460_44860 n1_M8_6540_44860 0.001755
R22657 n1_M8_6540_44860 n1_M8_7620_44860 0.001755
R22658 n1_M8_7620_44860 n1_M8_8700_44860 0.001755
R22659 n1_M8_8700_44860 n1_M8_9780_44860 0.001755
R22660 n1_M8_9780_44860 n1_M8_10860_44860 0.001755
R22661 n1_M8_10860_44860 n1_M8_11940_44860 0.001755
R22662 n1_M8_11940_44860 n1_M8_13020_44860 0.001755
R22663 n1_M8_13020_44860 n1_M8_14100_44860 0.001755
R22664 n1_M8_14100_44860 n1_M8_15180_44860 0.001755
R22665 n1_M8_15180_44860 n1_M8_16260_44860 0.001755
R22666 n1_M8_16260_44860 n1_M8_17340_44860 0.001755
R22667 n1_M8_17340_44860 n1_M8_18420_44860 0.001755
R22668 n1_M8_18420_44860 n1_M8_19500_44860 0.001755
R22669 n1_M8_19500_44860 n1_M8_20580_44860 0.001755
R22670 n1_M8_20580_44860 n1_M8_21660_44860 0.001755
R22671 n1_M8_21660_44860 n1_M8_22740_44860 0.001755
R22672 n1_M8_22740_44860 n1_M8_23820_44860 0.001755
R22673 n1_M8_23820_44860 n1_M8_24900_44860 0.001755
R22674 n1_M8_24900_44860 n1_M8_25980_44860 0.001755
R22675 n1_M8_25980_44860 n1_M8_27060_44860 0.001755
R22676 n1_M8_27060_44860 n1_M8_28140_44860 0.001755
R22677 n1_M8_28140_44860 n1_M8_29220_44860 0.001755
R22678 n1_M8_29220_44860 n1_M8_30300_44860 0.001755
R22679 n1_M8_30300_44860 n1_M8_31380_44860 0.001755
R22680 n1_M8_31380_44860 n1_M8_32460_44860 0.001755
R22681 n1_M8_32460_44860 n1_M8_33540_44860 0.001755
R22682 n1_M8_33540_44860 n1_M8_34620_44860 0.001755
R22683 n1_M8_34620_44860 n1_M8_35700_44860 0.001755
R22684 n1_M8_35700_44860 n1_M8_36780_44860 0.001755
R22685 n1_M8_36780_44860 n1_M8_37860_44860 0.001755
R22686 n1_M8_37860_44860 n1_M8_38940_44860 0.001755
R22687 n1_M8_38940_44860 n1_M8_40020_44860 0.001755
R22688 n1_M8_40020_44860 n1_M8_41100_44860 0.001755
R22689 n1_M8_41100_44860 n1_M8_42180_44860 0.001755
R22690 n1_M8_42180_44860 n1_M8_43260_44860 0.001755
R22691 n1_M8_43260_44860 n1_M8_44340_44860 0.001755
R22692 n1_M8_44340_44860 n1_M8_45420_44860 0.001755
R22693 n1_M8_45420_44860 n1_M8_46500_44860 0.001755
R22694 n1_M8_46500_44860 n1_M8_47580_44860 0.001755
R22695 n1_M8_47580_44860 n1_M8_48660_44860 0.001755
R22696 n1_M8_48660_44860 n1_M8_49740_44860 0.001755
R22697 n1_M8_49740_44860 n1_M8_50820_44860 0.001755
R22698 n1_M8_50820_44860 n1_M8_51900_44860 0.001755
R22699 n1_M8_51900_44860 n1_M8_52980_44860 0.001755
R22700 n1_M8_52980_44860 n1_M8_54060_44860 0.001755
R22701 n1_M8_54060_44860 n1_M8_55140_44860 0.001755
R22702 n1_M8_55140_44860 n1_M8_56220_44860 0.001755
R22703 n1_M8_56220_44860 n1_M8_57300_44860 0.001755
R22704 n1_M8_57300_44860 n1_M8_58380_44860 0.001755
R22705 n1_M8_58380_44860 n1_M8_59460_44860 0.001755
R22706 n1_M8_59460_44860 n1_M8_60540_44860 0.001755
R22707 n1_M8_60540_44860 n1_M8_61620_44860 0.001755
R22708 n1_M8_61620_44860 n1_M8_62700_44860 0.001755
R22709 n1_M8_62700_44860 n1_M8_63780_44860 0.001755
R22710 n1_M8_63780_44860 n1_M8_64860_44860 0.001755
R22711 n1_M8_64860_44860 n1_M8_65940_44860 0.001755
R22712 n1_M8_65940_44860 n1_M8_67020_44860 0.001755
R22713 n1_M8_67020_44860 n1_M8_68100_44860 0.001755
R22714 n1_M8_68100_44860 n1_M8_69180_44860 0.001755
R22715 n1_M8_69180_44860 n1_M8_70260_44860 0.001755
R22716 n1_M8_70260_44860 n1_M8_71340_44860 0.001755
R22717 n1_M8_71340_44860 n1_M8_72420_44860 0.001755
R22718 n1_M8_72420_44860 n1_M8_73500_44860 0.001755
R22719 n1_M8_73500_44860 n1_M8_74580_44860 0.001755
R22720 n1_M8_74580_44860 n1_M8_75660_44860 0.001755
R22721 n1_M8_75660_44860 n1_M8_76740_44860 0.001755
R22722 n1_M8_76740_44860 n1_M8_77820_44860 0.001755
R22723 n1_M8_77820_44860 n1_M8_78900_44860 0.001755
R22724 n1_M8_78900_44860 n1_M8_79980_44860 0.001755
R22725 n1_M8_79980_44860 n1_M8_81060_44860 0.001755
R22726 n1_M8_81060_44860 n1_M8_82140_44860 0.001755
R22727 n1_M8_82140_44860 n1_M8_83220_44860 0.001755
R22728 n1_M8_83220_44860 n1_M8_84300_44860 0.001755
R22729 n1_M8_84300_44860 n1_M8_85380_44860 0.001755
R22730 n1_M8_85380_44860 n1_M8_86460_44860 0.001755
R22731 n1_M8_86460_44860 n1_M8_87540_44860 0.001755
R22732 n1_M8_87540_44860 n1_M8_88620_44860 0.001755
R22733 n1_M8_88620_44860 n1_M8_89700_44860 0.001755
R22734 n1_M8_89700_44860 n1_M8_90780_44860 0.001755
R22735 n1_M8_90780_44860 n1_M8_91860_44860 0.001755
R22736 n1_M8_91860_44860 n1_M8_92940_44860 0.001755
R22737 n1_M8_92940_44860 n1_M8_94020_44860 0.001755
R22738 n1_M8_94020_44860 n1_M8_95100_44860 0.001755
R22739 n1_M8_95100_44860 n1_M8_96180_44860 0.001755
R22740 n1_M8_96180_44860 n1_M8_97260_44860 0.001755
R22741 n1_M8_97260_44860 n1_M8_98340_44860 0.001755
R22742 n1_M8_98340_44860 n1_M8_99420_44860 0.001755
R22743 n1_M8_99420_44860 n1_M8_100500_44860 0.001755
R22744 n1_M8_100500_44860 n1_M8_101580_44860 0.001755
R22745 n1_M8_101580_44860 n1_M8_102660_44860 0.001755
R22746 n1_M8_102660_44860 n1_M8_103740_44860 0.001755
R22747 n1_M8_103740_44860 n1_M8_104820_44860 0.001755
R22748 n1_M8_104820_44860 n1_M8_105900_44860 0.001755
R22749 n1_M8_105900_44860 n1_M8_106980_44860 0.001755
R22750 n1_M8_106980_44860 n1_M8_108060_44860 0.001755
R22751 n1_M8_108060_44860 n1_M8_109140_44860 0.001755
R22752 n1_M8_109140_44860 n1_M8_110220_44860 0.001755
R22753 n1_M8_110220_44860 n1_M8_111300_44860 0.001755
R22754 n1_M8_111300_44860 n1_M8_112380_44860 0.001755
R22755 n1_M8_112380_44860 n1_M8_113460_44860 0.001755
R22756 n1_M8_113460_44860 n1_M8_114540_44860 0.001755
R22757 n1_M8_114540_44860 n1_M8_115620_44860 0.001755
R22758 n1_M8_115620_44860 n1_M8_116700_44860 0.001755
R22759 n1_M8_116700_44860 n1_M8_117780_44860 0.001755
R22760 n1_M8_117780_44860 n1_M8_118860_44860 0.001755
R22761 n1_M8_118860_44860 n1_M8_119940_44860 0.001755
R22762 n1_M8_119940_44860 n1_M8_121020_44860 0.001755
R22763 n1_M8_121020_44860 n1_M8_122100_44860 0.001755
R22764 n1_M8_122100_44860 n1_M8_123180_44860 0.001755
R22765 n1_M8_123180_44860 n1_M8_124260_44860 0.001755
R22766 n1_M8_124260_44860 n1_M8_125340_44860 0.001755
R22767 n1_M8_125340_44860 n1_M8_126420_44860 0.001755
R22768 n1_M8_126420_44860 n1_M8_127500_44860 0.001755
R22769 n1_M8_127500_44860 n1_M8_128580_44860 0.001755
R22770 n1_M8_128580_44860 n1_M8_129660_44860 0.001755
R22771 n1_M8_129660_44860 n1_M8_130740_44860 0.001755
R22772 n1_M8_130740_44860 n1_M8_131820_44860 0.001755
R22773 n1_M8_131820_44860 n1_M8_132900_44860 0.001755
R22774 n1_M8_132900_44860 n1_M8_133980_44860 0.001755
R22775 n1_M8_133980_44860 n1_M8_135060_44860 0.001755
R22776 n1_M8_135060_44860 n1_M8_136140_44860 0.001755
R22777 n1_M8_136140_44860 n1_M8_137220_44860 0.001755
R22778 n1_M8_137220_44860 n1_M8_138300_44860 0.001755
R22779 n1_M8_138300_44860 n1_M8_139380_44860 0.001755
R22780 n1_M8_139380_44860 n1_M8_140460_44860 0.001755
R22781 n1_M8_140460_44860 n1_M8_141540_44860 0.001755
R22782 n1_M8_141540_44860 n1_M8_142620_44860 0.001755
R22783 n1_M8_142620_44860 n1_M8_143700_44860 0.001755
R22784 n1_M8_143700_44860 n1_M8_144780_44860 0.001755
R22785 n1_M8_144780_44860 n1_M8_145860_44860 0.001755
R22786 n1_M8_145860_44860 n1_M8_146940_44860 0.001755
R22787 n1_M8_60_51260 n1_M8_1140_51260 0.001755
R22788 n1_M8_1140_51260 n1_M8_2220_51260 0.001755
R22789 n1_M8_2220_51260 n1_M8_3300_51260 0.001755
R22790 n1_M8_3300_51260 n1_M8_4380_51260 0.001755
R22791 n1_M8_4380_51260 n1_M8_5460_51260 0.001755
R22792 n1_M8_5460_51260 n1_M8_6540_51260 0.001755
R22793 n1_M8_6540_51260 n1_M8_7620_51260 0.001755
R22794 n1_M8_7620_51260 n1_M8_8700_51260 0.001755
R22795 n1_M8_8700_51260 n1_M8_9780_51260 0.001755
R22796 n1_M8_9780_51260 n1_M8_10860_51260 0.001755
R22797 n1_M8_10860_51260 n1_M8_11940_51260 0.001755
R22798 n1_M8_11940_51260 n1_M8_13020_51260 0.001755
R22799 n1_M8_13020_51260 n1_M8_14100_51260 0.001755
R22800 n1_M8_14100_51260 n1_M8_15180_51260 0.001755
R22801 n1_M8_15180_51260 n1_M8_16260_51260 0.001755
R22802 n1_M8_16260_51260 n1_M8_17340_51260 0.001755
R22803 n1_M8_17340_51260 n1_M8_18420_51260 0.001755
R22804 n1_M8_18420_51260 n1_M8_19500_51260 0.001755
R22805 n1_M8_19500_51260 n1_M8_20580_51260 0.001755
R22806 n1_M8_20580_51260 n1_M8_21660_51260 0.001755
R22807 n1_M8_21660_51260 n1_M8_22740_51260 0.001755
R22808 n1_M8_22740_51260 n1_M8_23820_51260 0.001755
R22809 n1_M8_23820_51260 n1_M8_24900_51260 0.001755
R22810 n1_M8_24900_51260 n1_M8_25980_51260 0.001755
R22811 n1_M8_25980_51260 n1_M8_27060_51260 0.001755
R22812 n1_M8_27060_51260 n1_M8_28140_51260 0.001755
R22813 n1_M8_28140_51260 n1_M8_29220_51260 0.001755
R22814 n1_M8_29220_51260 n1_M8_30300_51260 0.001755
R22815 n1_M8_30300_51260 n1_M8_31380_51260 0.001755
R22816 n1_M8_31380_51260 n1_M8_32460_51260 0.001755
R22817 n1_M8_32460_51260 n1_M8_33540_51260 0.001755
R22818 n1_M8_33540_51260 n1_M8_34620_51260 0.001755
R22819 n1_M8_34620_51260 n1_M8_35700_51260 0.001755
R22820 n1_M8_35700_51260 n1_M8_36780_51260 0.001755
R22821 n1_M8_36780_51260 n1_M8_37860_51260 0.001755
R22822 n1_M8_37860_51260 n1_M8_38940_51260 0.001755
R22823 n1_M8_38940_51260 n1_M8_40020_51260 0.001755
R22824 n1_M8_40020_51260 n1_M8_41100_51260 0.001755
R22825 n1_M8_41100_51260 n1_M8_42180_51260 0.001755
R22826 n1_M8_42180_51260 n1_M8_43260_51260 0.001755
R22827 n1_M8_43260_51260 n1_M8_44340_51260 0.001755
R22828 n1_M8_44340_51260 n1_M8_45420_51260 0.001755
R22829 n1_M8_45420_51260 n1_M8_46500_51260 0.001755
R22830 n1_M8_46500_51260 n1_M8_47580_51260 0.001755
R22831 n1_M8_47580_51260 n1_M8_48660_51260 0.001755
R22832 n1_M8_48660_51260 n1_M8_49740_51260 0.001755
R22833 n1_M8_49740_51260 n1_M8_50820_51260 0.001755
R22834 n1_M8_50820_51260 n1_M8_51900_51260 0.001755
R22835 n1_M8_51900_51260 n1_M8_52980_51260 0.001755
R22836 n1_M8_52980_51260 n1_M8_54060_51260 0.001755
R22837 n1_M8_54060_51260 n1_M8_55140_51260 0.001755
R22838 n1_M8_55140_51260 n1_M8_56220_51260 0.001755
R22839 n1_M8_56220_51260 n1_M8_57300_51260 0.001755
R22840 n1_M8_57300_51260 n1_M8_58380_51260 0.001755
R22841 n1_M8_58380_51260 n1_M8_59460_51260 0.001755
R22842 n1_M8_59460_51260 n1_M8_60540_51260 0.001755
R22843 n1_M8_60540_51260 n1_M8_61620_51260 0.001755
R22844 n1_M8_61620_51260 n1_M8_62700_51260 0.001755
R22845 n1_M8_62700_51260 n1_M8_63780_51260 0.001755
R22846 n1_M8_63780_51260 n1_M8_64860_51260 0.001755
R22847 n1_M8_64860_51260 n1_M8_65940_51260 0.001755
R22848 n1_M8_65940_51260 n1_M8_67020_51260 0.001755
R22849 n1_M8_67020_51260 n1_M8_68100_51260 0.001755
R22850 n1_M8_68100_51260 n1_M8_69180_51260 0.001755
R22851 n1_M8_69180_51260 n1_M8_70260_51260 0.001755
R22852 n1_M8_70260_51260 n1_M8_71340_51260 0.001755
R22853 n1_M8_71340_51260 n1_M8_72420_51260 0.001755
R22854 n1_M8_72420_51260 n1_M8_73500_51260 0.001755
R22855 n1_M8_73500_51260 n1_M8_74580_51260 0.001755
R22856 n1_M8_74580_51260 n1_M8_75660_51260 0.001755
R22857 n1_M8_75660_51260 n1_M8_76740_51260 0.001755
R22858 n1_M8_76740_51260 n1_M8_77820_51260 0.001755
R22859 n1_M8_77820_51260 n1_M8_78900_51260 0.001755
R22860 n1_M8_78900_51260 n1_M8_79980_51260 0.001755
R22861 n1_M8_79980_51260 n1_M8_81060_51260 0.001755
R22862 n1_M8_81060_51260 n1_M8_82140_51260 0.001755
R22863 n1_M8_82140_51260 n1_M8_83220_51260 0.001755
R22864 n1_M8_83220_51260 n1_M8_84300_51260 0.001755
R22865 n1_M8_84300_51260 n1_M8_85380_51260 0.001755
R22866 n1_M8_85380_51260 n1_M8_86460_51260 0.001755
R22867 n1_M8_86460_51260 n1_M8_87540_51260 0.001755
R22868 n1_M8_87540_51260 n1_M8_88620_51260 0.001755
R22869 n1_M8_88620_51260 n1_M8_89700_51260 0.001755
R22870 n1_M8_89700_51260 n1_M8_90780_51260 0.001755
R22871 n1_M8_90780_51260 n1_M8_91860_51260 0.001755
R22872 n1_M8_91860_51260 n1_M8_92940_51260 0.001755
R22873 n1_M8_92940_51260 n1_M8_94020_51260 0.001755
R22874 n1_M8_94020_51260 n1_M8_95100_51260 0.001755
R22875 n1_M8_95100_51260 n1_M8_96180_51260 0.001755
R22876 n1_M8_96180_51260 n1_M8_97260_51260 0.001755
R22877 n1_M8_97260_51260 n1_M8_98340_51260 0.001755
R22878 n1_M8_98340_51260 n1_M8_99420_51260 0.001755
R22879 n1_M8_99420_51260 n1_M8_100500_51260 0.001755
R22880 n1_M8_100500_51260 n1_M8_101580_51260 0.001755
R22881 n1_M8_101580_51260 n1_M8_102660_51260 0.001755
R22882 n1_M8_102660_51260 n1_M8_103740_51260 0.001755
R22883 n1_M8_103740_51260 n1_M8_104820_51260 0.001755
R22884 n1_M8_104820_51260 n1_M8_105900_51260 0.001755
R22885 n1_M8_105900_51260 n1_M8_106980_51260 0.001755
R22886 n1_M8_106980_51260 n1_M8_108060_51260 0.001755
R22887 n1_M8_108060_51260 n1_M8_109140_51260 0.001755
R22888 n1_M8_109140_51260 n1_M8_110220_51260 0.001755
R22889 n1_M8_110220_51260 n1_M8_111300_51260 0.001755
R22890 n1_M8_111300_51260 n1_M8_112380_51260 0.001755
R22891 n1_M8_112380_51260 n1_M8_113460_51260 0.001755
R22892 n1_M8_113460_51260 n1_M8_114540_51260 0.001755
R22893 n1_M8_114540_51260 n1_M8_115620_51260 0.001755
R22894 n1_M8_115620_51260 n1_M8_116700_51260 0.001755
R22895 n1_M8_116700_51260 n1_M8_117780_51260 0.001755
R22896 n1_M8_117780_51260 n1_M8_118860_51260 0.001755
R22897 n1_M8_118860_51260 n1_M8_119940_51260 0.001755
R22898 n1_M8_119940_51260 n1_M8_121020_51260 0.001755
R22899 n1_M8_121020_51260 n1_M8_122100_51260 0.001755
R22900 n1_M8_122100_51260 n1_M8_123180_51260 0.001755
R22901 n1_M8_123180_51260 n1_M8_124260_51260 0.001755
R22902 n1_M8_124260_51260 n1_M8_125340_51260 0.001755
R22903 n1_M8_125340_51260 n1_M8_126420_51260 0.001755
R22904 n1_M8_126420_51260 n1_M8_127500_51260 0.001755
R22905 n1_M8_127500_51260 n1_M8_128580_51260 0.001755
R22906 n1_M8_128580_51260 n1_M8_129660_51260 0.001755
R22907 n1_M8_129660_51260 n1_M8_130740_51260 0.001755
R22908 n1_M8_130740_51260 n1_M8_131820_51260 0.001755
R22909 n1_M8_131820_51260 n1_M8_132900_51260 0.001755
R22910 n1_M8_132900_51260 n1_M8_133980_51260 0.001755
R22911 n1_M8_133980_51260 n1_M8_135060_51260 0.001755
R22912 n1_M8_135060_51260 n1_M8_136140_51260 0.001755
R22913 n1_M8_136140_51260 n1_M8_137220_51260 0.001755
R22914 n1_M8_137220_51260 n1_M8_138300_51260 0.001755
R22915 n1_M8_138300_51260 n1_M8_139380_51260 0.001755
R22916 n1_M8_139380_51260 n1_M8_140460_51260 0.001755
R22917 n1_M8_140460_51260 n1_M8_141540_51260 0.001755
R22918 n1_M8_141540_51260 n1_M8_142620_51260 0.001755
R22919 n1_M8_142620_51260 n1_M8_143700_51260 0.001755
R22920 n1_M8_143700_51260 n1_M8_144780_51260 0.001755
R22921 n1_M8_144780_51260 n1_M8_145860_51260 0.001755
R22922 n1_M8_145860_51260 n1_M8_146940_51260 0.001755
R22923 n1_M8_60_57660 n1_M8_1140_57660 0.001755
R22924 n1_M8_1140_57660 n1_M8_2220_57660 0.001755
R22925 n1_M8_2220_57660 n1_M8_3300_57660 0.001755
R22926 n1_M8_3300_57660 n1_M8_4380_57660 0.001755
R22927 n1_M8_4380_57660 n1_M8_5460_57660 0.001755
R22928 n1_M8_5460_57660 n1_M8_6540_57660 0.001755
R22929 n1_M8_6540_57660 n1_M8_7620_57660 0.001755
R22930 n1_M8_7620_57660 n1_M8_8700_57660 0.001755
R22931 n1_M8_8700_57660 n1_M8_9780_57660 0.001755
R22932 n1_M8_9780_57660 n1_M8_10860_57660 0.001755
R22933 n1_M8_10860_57660 n1_M8_11940_57660 0.001755
R22934 n1_M8_11940_57660 n1_M8_13020_57660 0.001755
R22935 n1_M8_13020_57660 n1_M8_14100_57660 0.001755
R22936 n1_M8_14100_57660 n1_M8_15180_57660 0.001755
R22937 n1_M8_15180_57660 n1_M8_16260_57660 0.001755
R22938 n1_M8_16260_57660 n1_M8_17340_57660 0.001755
R22939 n1_M8_17340_57660 n1_M8_18420_57660 0.001755
R22940 n1_M8_18420_57660 n1_M8_19500_57660 0.001755
R22941 n1_M8_19500_57660 n1_M8_20580_57660 0.001755
R22942 n1_M8_20580_57660 n1_M8_21660_57660 0.001755
R22943 n1_M8_21660_57660 n1_M8_22740_57660 0.001755
R22944 n1_M8_22740_57660 n1_M8_23820_57660 0.001755
R22945 n1_M8_23820_57660 n1_M8_24900_57660 0.001755
R22946 n1_M8_24900_57660 n1_M8_25980_57660 0.001755
R22947 n1_M8_25980_57660 n1_M8_27060_57660 0.001755
R22948 n1_M8_27060_57660 n1_M8_28140_57660 0.001755
R22949 n1_M8_28140_57660 n1_M8_29220_57660 0.001755
R22950 n1_M8_29220_57660 n1_M8_30300_57660 0.001755
R22951 n1_M8_30300_57660 n1_M8_31380_57660 0.001755
R22952 n1_M8_31380_57660 n1_M8_32460_57660 0.001755
R22953 n1_M8_32460_57660 n1_M8_33540_57660 0.001755
R22954 n1_M8_33540_57660 n1_M8_34620_57660 0.001755
R22955 n1_M8_34620_57660 n1_M8_35700_57660 0.001755
R22956 n1_M8_35700_57660 n1_M8_36780_57660 0.001755
R22957 n1_M8_36780_57660 n1_M8_37860_57660 0.001755
R22958 n1_M8_37860_57660 n1_M8_38940_57660 0.001755
R22959 n1_M8_38940_57660 n1_M8_40020_57660 0.001755
R22960 n1_M8_40020_57660 n1_M8_41100_57660 0.001755
R22961 n1_M8_41100_57660 n1_M8_42180_57660 0.001755
R22962 n1_M8_42180_57660 n1_M8_43260_57660 0.001755
R22963 n1_M8_43260_57660 n1_M8_44340_57660 0.001755
R22964 n1_M8_44340_57660 n1_M8_45420_57660 0.001755
R22965 n1_M8_45420_57660 n1_M8_46500_57660 0.001755
R22966 n1_M8_46500_57660 n1_M8_47580_57660 0.001755
R22967 n1_M8_47580_57660 n1_M8_48660_57660 0.001755
R22968 n1_M8_48660_57660 n1_M8_49740_57660 0.001755
R22969 n1_M8_49740_57660 n1_M8_50820_57660 0.001755
R22970 n1_M8_50820_57660 n1_M8_51900_57660 0.001755
R22971 n1_M8_51900_57660 n1_M8_52980_57660 0.001755
R22972 n1_M8_52980_57660 n1_M8_54060_57660 0.001755
R22973 n1_M8_54060_57660 n1_M8_55140_57660 0.001755
R22974 n1_M8_55140_57660 n1_M8_56220_57660 0.001755
R22975 n1_M8_56220_57660 n1_M8_57300_57660 0.001755
R22976 n1_M8_57300_57660 n1_M8_58380_57660 0.001755
R22977 n1_M8_58380_57660 n1_M8_59460_57660 0.001755
R22978 n1_M8_59460_57660 n1_M8_60540_57660 0.001755
R22979 n1_M8_60540_57660 n1_M8_61620_57660 0.001755
R22980 n1_M8_61620_57660 n1_M8_62700_57660 0.001755
R22981 n1_M8_62700_57660 n1_M8_63780_57660 0.001755
R22982 n1_M8_63780_57660 n1_M8_64860_57660 0.001755
R22983 n1_M8_64860_57660 n1_M8_65940_57660 0.001755
R22984 n1_M8_65940_57660 n1_M8_67020_57660 0.001755
R22985 n1_M8_67020_57660 n1_M8_68100_57660 0.001755
R22986 n1_M8_68100_57660 n1_M8_69180_57660 0.001755
R22987 n1_M8_69180_57660 n1_M8_70260_57660 0.001755
R22988 n1_M8_70260_57660 n1_M8_71340_57660 0.001755
R22989 n1_M8_71340_57660 n1_M8_72420_57660 0.001755
R22990 n1_M8_72420_57660 n1_M8_73500_57660 0.001755
R22991 n1_M8_73500_57660 n1_M8_74580_57660 0.001755
R22992 n1_M8_74580_57660 n1_M8_75660_57660 0.001755
R22993 n1_M8_75660_57660 n1_M8_76740_57660 0.001755
R22994 n1_M8_76740_57660 n1_M8_77820_57660 0.001755
R22995 n1_M8_77820_57660 n1_M8_78900_57660 0.001755
R22996 n1_M8_78900_57660 n1_M8_79980_57660 0.001755
R22997 n1_M8_79980_57660 n1_M8_81060_57660 0.001755
R22998 n1_M8_81060_57660 n1_M8_82140_57660 0.001755
R22999 n1_M8_82140_57660 n1_M8_83220_57660 0.001755
R23000 n1_M8_83220_57660 n1_M8_84300_57660 0.001755
R23001 n1_M8_84300_57660 n1_M8_85380_57660 0.001755
R23002 n1_M8_85380_57660 n1_M8_86460_57660 0.001755
R23003 n1_M8_86460_57660 n1_M8_87540_57660 0.001755
R23004 n1_M8_87540_57660 n1_M8_88620_57660 0.001755
R23005 n1_M8_88620_57660 n1_M8_89700_57660 0.001755
R23006 n1_M8_89700_57660 n1_M8_90780_57660 0.001755
R23007 n1_M8_90780_57660 n1_M8_91860_57660 0.001755
R23008 n1_M8_91860_57660 n1_M8_92940_57660 0.001755
R23009 n1_M8_92940_57660 n1_M8_94020_57660 0.001755
R23010 n1_M8_94020_57660 n1_M8_95100_57660 0.001755
R23011 n1_M8_95100_57660 n1_M8_96180_57660 0.001755
R23012 n1_M8_96180_57660 n1_M8_97260_57660 0.001755
R23013 n1_M8_97260_57660 n1_M8_98340_57660 0.001755
R23014 n1_M8_98340_57660 n1_M8_99420_57660 0.001755
R23015 n1_M8_99420_57660 n1_M8_100500_57660 0.001755
R23016 n1_M8_100500_57660 n1_M8_101580_57660 0.001755
R23017 n1_M8_101580_57660 n1_M8_102660_57660 0.001755
R23018 n1_M8_102660_57660 n1_M8_103740_57660 0.001755
R23019 n1_M8_103740_57660 n1_M8_104820_57660 0.001755
R23020 n1_M8_104820_57660 n1_M8_105900_57660 0.001755
R23021 n1_M8_105900_57660 n1_M8_106980_57660 0.001755
R23022 n1_M8_106980_57660 n1_M8_108060_57660 0.001755
R23023 n1_M8_108060_57660 n1_M8_109140_57660 0.001755
R23024 n1_M8_109140_57660 n1_M8_110220_57660 0.001755
R23025 n1_M8_110220_57660 n1_M8_111300_57660 0.001755
R23026 n1_M8_111300_57660 n1_M8_112380_57660 0.001755
R23027 n1_M8_112380_57660 n1_M8_113460_57660 0.001755
R23028 n1_M8_113460_57660 n1_M8_114540_57660 0.001755
R23029 n1_M8_114540_57660 n1_M8_115620_57660 0.001755
R23030 n1_M8_115620_57660 n1_M8_116700_57660 0.001755
R23031 n1_M8_116700_57660 n1_M8_117780_57660 0.001755
R23032 n1_M8_117780_57660 n1_M8_118860_57660 0.001755
R23033 n1_M8_118860_57660 n1_M8_119940_57660 0.001755
R23034 n1_M8_119940_57660 n1_M8_121020_57660 0.001755
R23035 n1_M8_121020_57660 n1_M8_122100_57660 0.001755
R23036 n1_M8_122100_57660 n1_M8_123180_57660 0.001755
R23037 n1_M8_123180_57660 n1_M8_124260_57660 0.001755
R23038 n1_M8_124260_57660 n1_M8_125340_57660 0.001755
R23039 n1_M8_125340_57660 n1_M8_126420_57660 0.001755
R23040 n1_M8_126420_57660 n1_M8_127500_57660 0.001755
R23041 n1_M8_127500_57660 n1_M8_128580_57660 0.001755
R23042 n1_M8_128580_57660 n1_M8_129660_57660 0.001755
R23043 n1_M8_129660_57660 n1_M8_130740_57660 0.001755
R23044 n1_M8_130740_57660 n1_M8_131820_57660 0.001755
R23045 n1_M8_131820_57660 n1_M8_132900_57660 0.001755
R23046 n1_M8_132900_57660 n1_M8_133980_57660 0.001755
R23047 n1_M8_133980_57660 n1_M8_135060_57660 0.001755
R23048 n1_M8_135060_57660 n1_M8_136140_57660 0.001755
R23049 n1_M8_136140_57660 n1_M8_137220_57660 0.001755
R23050 n1_M8_137220_57660 n1_M8_138300_57660 0.001755
R23051 n1_M8_138300_57660 n1_M8_139380_57660 0.001755
R23052 n1_M8_139380_57660 n1_M8_140460_57660 0.001755
R23053 n1_M8_140460_57660 n1_M8_141540_57660 0.001755
R23054 n1_M8_141540_57660 n1_M8_142620_57660 0.001755
R23055 n1_M8_142620_57660 n1_M8_143700_57660 0.001755
R23056 n1_M8_143700_57660 n1_M8_144780_57660 0.001755
R23057 n1_M8_144780_57660 n1_M8_145860_57660 0.001755
R23058 n1_M8_145860_57660 n1_M8_146940_57660 0.001755
R23059 n1_M8_60_64060 n1_M8_1140_64060 0.001755
R23060 n1_M8_1140_64060 n1_M8_2220_64060 0.001755
R23061 n1_M8_2220_64060 n1_M8_3300_64060 0.001755
R23062 n1_M8_3300_64060 n1_M8_4380_64060 0.001755
R23063 n1_M8_4380_64060 n1_M8_5460_64060 0.001755
R23064 n1_M8_5460_64060 n1_M8_6540_64060 0.001755
R23065 n1_M8_6540_64060 n1_M8_7620_64060 0.001755
R23066 n1_M8_7620_64060 n1_M8_8700_64060 0.001755
R23067 n1_M8_8700_64060 n1_M8_9780_64060 0.001755
R23068 n1_M8_9780_64060 n1_M8_10860_64060 0.001755
R23069 n1_M8_10860_64060 n1_M8_11940_64060 0.001755
R23070 n1_M8_11940_64060 n1_M8_13020_64060 0.001755
R23071 n1_M8_13020_64060 n1_M8_14100_64060 0.001755
R23072 n1_M8_14100_64060 n1_M8_15180_64060 0.001755
R23073 n1_M8_15180_64060 n1_M8_16260_64060 0.001755
R23074 n1_M8_16260_64060 n1_M8_17340_64060 0.001755
R23075 n1_M8_17340_64060 n1_M8_18420_64060 0.001755
R23076 n1_M8_18420_64060 n1_M8_19500_64060 0.001755
R23077 n1_M8_19500_64060 n1_M8_20580_64060 0.001755
R23078 n1_M8_20580_64060 n1_M8_21660_64060 0.001755
R23079 n1_M8_21660_64060 n1_M8_22740_64060 0.001755
R23080 n1_M8_22740_64060 n1_M8_23820_64060 0.001755
R23081 n1_M8_23820_64060 n1_M8_24900_64060 0.001755
R23082 n1_M8_24900_64060 n1_M8_25980_64060 0.001755
R23083 n1_M8_25980_64060 n1_M8_27060_64060 0.001755
R23084 n1_M8_27060_64060 n1_M8_28140_64060 0.001755
R23085 n1_M8_28140_64060 n1_M8_29220_64060 0.001755
R23086 n1_M8_29220_64060 n1_M8_30300_64060 0.001755
R23087 n1_M8_30300_64060 n1_M8_31380_64060 0.001755
R23088 n1_M8_31380_64060 n1_M8_32460_64060 0.001755
R23089 n1_M8_32460_64060 n1_M8_33540_64060 0.001755
R23090 n1_M8_33540_64060 n1_M8_34620_64060 0.001755
R23091 n1_M8_34620_64060 n1_M8_35700_64060 0.001755
R23092 n1_M8_35700_64060 n1_M8_36780_64060 0.001755
R23093 n1_M8_36780_64060 n1_M8_37860_64060 0.001755
R23094 n1_M8_37860_64060 n1_M8_38940_64060 0.001755
R23095 n1_M8_38940_64060 n1_M8_40020_64060 0.001755
R23096 n1_M8_40020_64060 n1_M8_41100_64060 0.001755
R23097 n1_M8_41100_64060 n1_M8_42180_64060 0.001755
R23098 n1_M8_42180_64060 n1_M8_43260_64060 0.001755
R23099 n1_M8_43260_64060 n1_M8_44340_64060 0.001755
R23100 n1_M8_44340_64060 n1_M8_45420_64060 0.001755
R23101 n1_M8_45420_64060 n1_M8_46500_64060 0.001755
R23102 n1_M8_46500_64060 n1_M8_47580_64060 0.001755
R23103 n1_M8_47580_64060 n1_M8_48660_64060 0.001755
R23104 n1_M8_48660_64060 n1_M8_49740_64060 0.001755
R23105 n1_M8_49740_64060 n1_M8_50820_64060 0.001755
R23106 n1_M8_50820_64060 n1_M8_51900_64060 0.001755
R23107 n1_M8_51900_64060 n1_M8_52980_64060 0.001755
R23108 n1_M8_52980_64060 n1_M8_54060_64060 0.001755
R23109 n1_M8_54060_64060 n1_M8_55140_64060 0.001755
R23110 n1_M8_55140_64060 n1_M8_56220_64060 0.001755
R23111 n1_M8_56220_64060 n1_M8_57300_64060 0.001755
R23112 n1_M8_57300_64060 n1_M8_58380_64060 0.001755
R23113 n1_M8_58380_64060 n1_M8_59460_64060 0.001755
R23114 n1_M8_59460_64060 n1_M8_60540_64060 0.001755
R23115 n1_M8_60540_64060 n1_M8_61620_64060 0.001755
R23116 n1_M8_61620_64060 n1_M8_62700_64060 0.001755
R23117 n1_M8_62700_64060 n1_M8_63780_64060 0.001755
R23118 n1_M8_63780_64060 n1_M8_64860_64060 0.001755
R23119 n1_M8_64860_64060 n1_M8_65940_64060 0.001755
R23120 n1_M8_65940_64060 n1_M8_67020_64060 0.001755
R23121 n1_M8_67020_64060 n1_M8_68100_64060 0.001755
R23122 n1_M8_68100_64060 n1_M8_69180_64060 0.001755
R23123 n1_M8_69180_64060 n1_M8_70260_64060 0.001755
R23124 n1_M8_70260_64060 n1_M8_71340_64060 0.001755
R23125 n1_M8_71340_64060 n1_M8_72420_64060 0.001755
R23126 n1_M8_72420_64060 n1_M8_73500_64060 0.001755
R23127 n1_M8_73500_64060 n1_M8_74580_64060 0.001755
R23128 n1_M8_74580_64060 n1_M8_75660_64060 0.001755
R23129 n1_M8_75660_64060 n1_M8_76740_64060 0.001755
R23130 n1_M8_76740_64060 n1_M8_77820_64060 0.001755
R23131 n1_M8_77820_64060 n1_M8_78900_64060 0.001755
R23132 n1_M8_78900_64060 n1_M8_79980_64060 0.001755
R23133 n1_M8_79980_64060 n1_M8_81060_64060 0.001755
R23134 n1_M8_81060_64060 n1_M8_82140_64060 0.001755
R23135 n1_M8_82140_64060 n1_M8_83220_64060 0.001755
R23136 n1_M8_83220_64060 n1_M8_84300_64060 0.001755
R23137 n1_M8_84300_64060 n1_M8_85380_64060 0.001755
R23138 n1_M8_85380_64060 n1_M8_86460_64060 0.001755
R23139 n1_M8_86460_64060 n1_M8_87540_64060 0.001755
R23140 n1_M8_87540_64060 n1_M8_88620_64060 0.001755
R23141 n1_M8_88620_64060 n1_M8_89700_64060 0.001755
R23142 n1_M8_89700_64060 n1_M8_90780_64060 0.001755
R23143 n1_M8_90780_64060 n1_M8_91860_64060 0.001755
R23144 n1_M8_91860_64060 n1_M8_92940_64060 0.001755
R23145 n1_M8_92940_64060 n1_M8_94020_64060 0.001755
R23146 n1_M8_94020_64060 n1_M8_95100_64060 0.001755
R23147 n1_M8_95100_64060 n1_M8_96180_64060 0.001755
R23148 n1_M8_96180_64060 n1_M8_97260_64060 0.001755
R23149 n1_M8_97260_64060 n1_M8_98340_64060 0.001755
R23150 n1_M8_98340_64060 n1_M8_99420_64060 0.001755
R23151 n1_M8_99420_64060 n1_M8_100500_64060 0.001755
R23152 n1_M8_100500_64060 n1_M8_101580_64060 0.001755
R23153 n1_M8_101580_64060 n1_M8_102660_64060 0.001755
R23154 n1_M8_102660_64060 n1_M8_103740_64060 0.001755
R23155 n1_M8_103740_64060 n1_M8_104820_64060 0.001755
R23156 n1_M8_104820_64060 n1_M8_105900_64060 0.001755
R23157 n1_M8_105900_64060 n1_M8_106980_64060 0.001755
R23158 n1_M8_106980_64060 n1_M8_108060_64060 0.001755
R23159 n1_M8_108060_64060 n1_M8_109140_64060 0.001755
R23160 n1_M8_109140_64060 n1_M8_110220_64060 0.001755
R23161 n1_M8_110220_64060 n1_M8_111300_64060 0.001755
R23162 n1_M8_111300_64060 n1_M8_112380_64060 0.001755
R23163 n1_M8_112380_64060 n1_M8_113460_64060 0.001755
R23164 n1_M8_113460_64060 n1_M8_114540_64060 0.001755
R23165 n1_M8_114540_64060 n1_M8_115620_64060 0.001755
R23166 n1_M8_115620_64060 n1_M8_116700_64060 0.001755
R23167 n1_M8_116700_64060 n1_M8_117780_64060 0.001755
R23168 n1_M8_117780_64060 n1_M8_118860_64060 0.001755
R23169 n1_M8_118860_64060 n1_M8_119940_64060 0.001755
R23170 n1_M8_119940_64060 n1_M8_121020_64060 0.001755
R23171 n1_M8_121020_64060 n1_M8_122100_64060 0.001755
R23172 n1_M8_122100_64060 n1_M8_123180_64060 0.001755
R23173 n1_M8_123180_64060 n1_M8_124260_64060 0.001755
R23174 n1_M8_124260_64060 n1_M8_125340_64060 0.001755
R23175 n1_M8_125340_64060 n1_M8_126420_64060 0.001755
R23176 n1_M8_126420_64060 n1_M8_127500_64060 0.001755
R23177 n1_M8_127500_64060 n1_M8_128580_64060 0.001755
R23178 n1_M8_128580_64060 n1_M8_129660_64060 0.001755
R23179 n1_M8_129660_64060 n1_M8_130740_64060 0.001755
R23180 n1_M8_130740_64060 n1_M8_131820_64060 0.001755
R23181 n1_M8_131820_64060 n1_M8_132900_64060 0.001755
R23182 n1_M8_132900_64060 n1_M8_133980_64060 0.001755
R23183 n1_M8_133980_64060 n1_M8_135060_64060 0.001755
R23184 n1_M8_135060_64060 n1_M8_136140_64060 0.001755
R23185 n1_M8_136140_64060 n1_M8_137220_64060 0.001755
R23186 n1_M8_137220_64060 n1_M8_138300_64060 0.001755
R23187 n1_M8_138300_64060 n1_M8_139380_64060 0.001755
R23188 n1_M8_139380_64060 n1_M8_140460_64060 0.001755
R23189 n1_M8_140460_64060 n1_M8_141540_64060 0.001755
R23190 n1_M8_141540_64060 n1_M8_142620_64060 0.001755
R23191 n1_M8_142620_64060 n1_M8_143700_64060 0.001755
R23192 n1_M8_143700_64060 n1_M8_144780_64060 0.001755
R23193 n1_M8_144780_64060 n1_M8_145860_64060 0.001755
R23194 n1_M8_145860_64060 n1_M8_146940_64060 0.001755
R23195 n1_M8_60_70460 n1_M8_1140_70460 0.001755
R23196 n1_M8_1140_70460 n1_M8_2220_70460 0.001755
R23197 n1_M8_2220_70460 n1_M8_3300_70460 0.001755
R23198 n1_M8_3300_70460 n1_M8_4380_70460 0.001755
R23199 n1_M8_4380_70460 n1_M8_5460_70460 0.001755
R23200 n1_M8_5460_70460 n1_M8_6540_70460 0.001755
R23201 n1_M8_6540_70460 n1_M8_7620_70460 0.001755
R23202 n1_M8_7620_70460 n1_M8_8700_70460 0.001755
R23203 n1_M8_8700_70460 n1_M8_9780_70460 0.001755
R23204 n1_M8_9780_70460 n1_M8_10860_70460 0.001755
R23205 n1_M8_10860_70460 n1_M8_11940_70460 0.001755
R23206 n1_M8_11940_70460 n1_M8_13020_70460 0.001755
R23207 n1_M8_13020_70460 n1_M8_14100_70460 0.001755
R23208 n1_M8_14100_70460 n1_M8_15180_70460 0.001755
R23209 n1_M8_15180_70460 n1_M8_16260_70460 0.001755
R23210 n1_M8_16260_70460 n1_M8_17340_70460 0.001755
R23211 n1_M8_17340_70460 n1_M8_18420_70460 0.001755
R23212 n1_M8_18420_70460 n1_M8_19500_70460 0.001755
R23213 n1_M8_19500_70460 n1_M8_20580_70460 0.001755
R23214 n1_M8_20580_70460 n1_M8_21660_70460 0.001755
R23215 n1_M8_21660_70460 n1_M8_22740_70460 0.001755
R23216 n1_M8_22740_70460 n1_M8_23820_70460 0.001755
R23217 n1_M8_23820_70460 n1_M8_24900_70460 0.001755
R23218 n1_M8_24900_70460 n1_M8_25980_70460 0.001755
R23219 n1_M8_25980_70460 n1_M8_27060_70460 0.001755
R23220 n1_M8_27060_70460 n1_M8_28140_70460 0.001755
R23221 n1_M8_28140_70460 n1_M8_29220_70460 0.001755
R23222 n1_M8_29220_70460 n1_M8_30300_70460 0.001755
R23223 n1_M8_30300_70460 n1_M8_31380_70460 0.001755
R23224 n1_M8_31380_70460 n1_M8_32460_70460 0.001755
R23225 n1_M8_32460_70460 n1_M8_33540_70460 0.001755
R23226 n1_M8_33540_70460 n1_M8_34620_70460 0.001755
R23227 n1_M8_34620_70460 n1_M8_35700_70460 0.001755
R23228 n1_M8_35700_70460 n1_M8_36780_70460 0.001755
R23229 n1_M8_36780_70460 n1_M8_37860_70460 0.001755
R23230 n1_M8_37860_70460 n1_M8_38940_70460 0.001755
R23231 n1_M8_38940_70460 n1_M8_40020_70460 0.001755
R23232 n1_M8_40020_70460 n1_M8_41100_70460 0.001755
R23233 n1_M8_41100_70460 n1_M8_42180_70460 0.001755
R23234 n1_M8_42180_70460 n1_M8_43260_70460 0.001755
R23235 n1_M8_43260_70460 n1_M8_44340_70460 0.001755
R23236 n1_M8_44340_70460 n1_M8_45420_70460 0.001755
R23237 n1_M8_45420_70460 n1_M8_46500_70460 0.001755
R23238 n1_M8_46500_70460 n1_M8_47580_70460 0.001755
R23239 n1_M8_47580_70460 n1_M8_48660_70460 0.001755
R23240 n1_M8_48660_70460 n1_M8_49740_70460 0.001755
R23241 n1_M8_49740_70460 n1_M8_50820_70460 0.001755
R23242 n1_M8_50820_70460 n1_M8_51900_70460 0.001755
R23243 n1_M8_51900_70460 n1_M8_52980_70460 0.001755
R23244 n1_M8_52980_70460 n1_M8_54060_70460 0.001755
R23245 n1_M8_54060_70460 n1_M8_55140_70460 0.001755
R23246 n1_M8_55140_70460 n1_M8_56220_70460 0.001755
R23247 n1_M8_56220_70460 n1_M8_57300_70460 0.001755
R23248 n1_M8_57300_70460 n1_M8_58380_70460 0.001755
R23249 n1_M8_58380_70460 n1_M8_59460_70460 0.001755
R23250 n1_M8_59460_70460 n1_M8_60540_70460 0.001755
R23251 n1_M8_60540_70460 n1_M8_61620_70460 0.001755
R23252 n1_M8_61620_70460 n1_M8_62700_70460 0.001755
R23253 n1_M8_62700_70460 n1_M8_63780_70460 0.001755
R23254 n1_M8_63780_70460 n1_M8_64860_70460 0.001755
R23255 n1_M8_64860_70460 n1_M8_65940_70460 0.001755
R23256 n1_M8_65940_70460 n1_M8_67020_70460 0.001755
R23257 n1_M8_67020_70460 n1_M8_68100_70460 0.001755
R23258 n1_M8_68100_70460 n1_M8_69180_70460 0.001755
R23259 n1_M8_69180_70460 n1_M8_70260_70460 0.001755
R23260 n1_M8_70260_70460 n1_M8_71340_70460 0.001755
R23261 n1_M8_71340_70460 n1_M8_72420_70460 0.001755
R23262 n1_M8_72420_70460 n1_M8_73500_70460 0.001755
R23263 n1_M8_73500_70460 n1_M8_74580_70460 0.001755
R23264 n1_M8_74580_70460 n1_M8_75660_70460 0.001755
R23265 n1_M8_75660_70460 n1_M8_76740_70460 0.001755
R23266 n1_M8_76740_70460 n1_M8_77820_70460 0.001755
R23267 n1_M8_77820_70460 n1_M8_78900_70460 0.001755
R23268 n1_M8_78900_70460 n1_M8_79980_70460 0.001755
R23269 n1_M8_79980_70460 n1_M8_81060_70460 0.001755
R23270 n1_M8_81060_70460 n1_M8_82140_70460 0.001755
R23271 n1_M8_82140_70460 n1_M8_83220_70460 0.001755
R23272 n1_M8_83220_70460 n1_M8_84300_70460 0.001755
R23273 n1_M8_84300_70460 n1_M8_85380_70460 0.001755
R23274 n1_M8_85380_70460 n1_M8_86460_70460 0.001755
R23275 n1_M8_86460_70460 n1_M8_87540_70460 0.001755
R23276 n1_M8_87540_70460 n1_M8_88620_70460 0.001755
R23277 n1_M8_88620_70460 n1_M8_89700_70460 0.001755
R23278 n1_M8_89700_70460 n1_M8_90780_70460 0.001755
R23279 n1_M8_90780_70460 n1_M8_91860_70460 0.001755
R23280 n1_M8_91860_70460 n1_M8_92940_70460 0.001755
R23281 n1_M8_92940_70460 n1_M8_94020_70460 0.001755
R23282 n1_M8_94020_70460 n1_M8_95100_70460 0.001755
R23283 n1_M8_95100_70460 n1_M8_96180_70460 0.001755
R23284 n1_M8_96180_70460 n1_M8_97260_70460 0.001755
R23285 n1_M8_97260_70460 n1_M8_98340_70460 0.001755
R23286 n1_M8_98340_70460 n1_M8_99420_70460 0.001755
R23287 n1_M8_99420_70460 n1_M8_100500_70460 0.001755
R23288 n1_M8_100500_70460 n1_M8_101580_70460 0.001755
R23289 n1_M8_101580_70460 n1_M8_102660_70460 0.001755
R23290 n1_M8_102660_70460 n1_M8_103740_70460 0.001755
R23291 n1_M8_103740_70460 n1_M8_104820_70460 0.001755
R23292 n1_M8_104820_70460 n1_M8_105900_70460 0.001755
R23293 n1_M8_105900_70460 n1_M8_106980_70460 0.001755
R23294 n1_M8_106980_70460 n1_M8_108060_70460 0.001755
R23295 n1_M8_108060_70460 n1_M8_109140_70460 0.001755
R23296 n1_M8_109140_70460 n1_M8_110220_70460 0.001755
R23297 n1_M8_110220_70460 n1_M8_111300_70460 0.001755
R23298 n1_M8_111300_70460 n1_M8_112380_70460 0.001755
R23299 n1_M8_112380_70460 n1_M8_113460_70460 0.001755
R23300 n1_M8_113460_70460 n1_M8_114540_70460 0.001755
R23301 n1_M8_114540_70460 n1_M8_115620_70460 0.001755
R23302 n1_M8_115620_70460 n1_M8_116700_70460 0.001755
R23303 n1_M8_116700_70460 n1_M8_117780_70460 0.001755
R23304 n1_M8_117780_70460 n1_M8_118860_70460 0.001755
R23305 n1_M8_118860_70460 n1_M8_119940_70460 0.001755
R23306 n1_M8_119940_70460 n1_M8_121020_70460 0.001755
R23307 n1_M8_121020_70460 n1_M8_122100_70460 0.001755
R23308 n1_M8_122100_70460 n1_M8_123180_70460 0.001755
R23309 n1_M8_123180_70460 n1_M8_124260_70460 0.001755
R23310 n1_M8_124260_70460 n1_M8_125340_70460 0.001755
R23311 n1_M8_125340_70460 n1_M8_126420_70460 0.001755
R23312 n1_M8_126420_70460 n1_M8_127500_70460 0.001755
R23313 n1_M8_127500_70460 n1_M8_128580_70460 0.001755
R23314 n1_M8_128580_70460 n1_M8_129660_70460 0.001755
R23315 n1_M8_129660_70460 n1_M8_130740_70460 0.001755
R23316 n1_M8_130740_70460 n1_M8_131820_70460 0.001755
R23317 n1_M8_131820_70460 n1_M8_132900_70460 0.001755
R23318 n1_M8_132900_70460 n1_M8_133980_70460 0.001755
R23319 n1_M8_133980_70460 n1_M8_135060_70460 0.001755
R23320 n1_M8_135060_70460 n1_M8_136140_70460 0.001755
R23321 n1_M8_136140_70460 n1_M8_137220_70460 0.001755
R23322 n1_M8_137220_70460 n1_M8_138300_70460 0.001755
R23323 n1_M8_138300_70460 n1_M8_139380_70460 0.001755
R23324 n1_M8_139380_70460 n1_M8_140460_70460 0.001755
R23325 n1_M8_140460_70460 n1_M8_141540_70460 0.001755
R23326 n1_M8_141540_70460 n1_M8_142620_70460 0.001755
R23327 n1_M8_142620_70460 n1_M8_143700_70460 0.001755
R23328 n1_M8_143700_70460 n1_M8_144780_70460 0.001755
R23329 n1_M8_144780_70460 n1_M8_145860_70460 0.001755
R23330 n1_M8_145860_70460 n1_M8_146940_70460 0.001755
R23331 n1_M8_60_76860 n1_M8_1140_76860 0.001755
R23332 n1_M8_1140_76860 n1_M8_2220_76860 0.001755
R23333 n1_M8_2220_76860 n1_M8_3300_76860 0.001755
R23334 n1_M8_3300_76860 n1_M8_4380_76860 0.001755
R23335 n1_M8_4380_76860 n1_M8_5460_76860 0.001755
R23336 n1_M8_5460_76860 n1_M8_6540_76860 0.001755
R23337 n1_M8_6540_76860 n1_M8_7620_76860 0.001755
R23338 n1_M8_7620_76860 n1_M8_8700_76860 0.001755
R23339 n1_M8_8700_76860 n1_M8_9780_76860 0.001755
R23340 n1_M8_9780_76860 n1_M8_10860_76860 0.001755
R23341 n1_M8_10860_76860 n1_M8_11940_76860 0.001755
R23342 n1_M8_11940_76860 n1_M8_13020_76860 0.001755
R23343 n1_M8_13020_76860 n1_M8_14100_76860 0.001755
R23344 n1_M8_14100_76860 n1_M8_15180_76860 0.001755
R23345 n1_M8_15180_76860 n1_M8_16260_76860 0.001755
R23346 n1_M8_16260_76860 n1_M8_17340_76860 0.001755
R23347 n1_M8_17340_76860 n1_M8_18420_76860 0.001755
R23348 n1_M8_18420_76860 n1_M8_19500_76860 0.001755
R23349 n1_M8_19500_76860 n1_M8_20580_76860 0.001755
R23350 n1_M8_20580_76860 n1_M8_21660_76860 0.001755
R23351 n1_M8_21660_76860 n1_M8_22740_76860 0.001755
R23352 n1_M8_22740_76860 n1_M8_23820_76860 0.001755
R23353 n1_M8_23820_76860 n1_M8_24900_76860 0.001755
R23354 n1_M8_24900_76860 n1_M8_25980_76860 0.001755
R23355 n1_M8_25980_76860 n1_M8_27060_76860 0.001755
R23356 n1_M8_27060_76860 n1_M8_28140_76860 0.001755
R23357 n1_M8_28140_76860 n1_M8_29220_76860 0.001755
R23358 n1_M8_29220_76860 n1_M8_30300_76860 0.001755
R23359 n1_M8_30300_76860 n1_M8_31380_76860 0.001755
R23360 n1_M8_31380_76860 n1_M8_32460_76860 0.001755
R23361 n1_M8_32460_76860 n1_M8_33540_76860 0.001755
R23362 n1_M8_33540_76860 n1_M8_34620_76860 0.001755
R23363 n1_M8_34620_76860 n1_M8_35700_76860 0.001755
R23364 n1_M8_35700_76860 n1_M8_36780_76860 0.001755
R23365 n1_M8_36780_76860 n1_M8_37860_76860 0.001755
R23366 n1_M8_37860_76860 n1_M8_38940_76860 0.001755
R23367 n1_M8_38940_76860 n1_M8_40020_76860 0.001755
R23368 n1_M8_40020_76860 n1_M8_41100_76860 0.001755
R23369 n1_M8_41100_76860 n1_M8_42180_76860 0.001755
R23370 n1_M8_42180_76860 n1_M8_43260_76860 0.001755
R23371 n1_M8_43260_76860 n1_M8_44340_76860 0.001755
R23372 n1_M8_44340_76860 n1_M8_45420_76860 0.001755
R23373 n1_M8_45420_76860 n1_M8_46500_76860 0.001755
R23374 n1_M8_46500_76860 n1_M8_47580_76860 0.001755
R23375 n1_M8_47580_76860 n1_M8_48660_76860 0.001755
R23376 n1_M8_48660_76860 n1_M8_49740_76860 0.001755
R23377 n1_M8_49740_76860 n1_M8_50820_76860 0.001755
R23378 n1_M8_50820_76860 n1_M8_51900_76860 0.001755
R23379 n1_M8_51900_76860 n1_M8_52980_76860 0.001755
R23380 n1_M8_52980_76860 n1_M8_54060_76860 0.001755
R23381 n1_M8_54060_76860 n1_M8_55140_76860 0.001755
R23382 n1_M8_55140_76860 n1_M8_56220_76860 0.001755
R23383 n1_M8_56220_76860 n1_M8_57300_76860 0.001755
R23384 n1_M8_57300_76860 n1_M8_58380_76860 0.001755
R23385 n1_M8_58380_76860 n1_M8_59460_76860 0.001755
R23386 n1_M8_59460_76860 n1_M8_60540_76860 0.001755
R23387 n1_M8_60540_76860 n1_M8_61620_76860 0.001755
R23388 n1_M8_61620_76860 n1_M8_62700_76860 0.001755
R23389 n1_M8_62700_76860 n1_M8_63780_76860 0.001755
R23390 n1_M8_63780_76860 n1_M8_64860_76860 0.001755
R23391 n1_M8_64860_76860 n1_M8_65940_76860 0.001755
R23392 n1_M8_65940_76860 n1_M8_67020_76860 0.001755
R23393 n1_M8_67020_76860 n1_M8_68100_76860 0.001755
R23394 n1_M8_68100_76860 n1_M8_69180_76860 0.001755
R23395 n1_M8_69180_76860 n1_M8_70260_76860 0.001755
R23396 n1_M8_70260_76860 n1_M8_71340_76860 0.001755
R23397 n1_M8_71340_76860 n1_M8_72420_76860 0.001755
R23398 n1_M8_72420_76860 n1_M8_73500_76860 0.001755
R23399 n1_M8_73500_76860 n1_M8_74580_76860 0.001755
R23400 n1_M8_74580_76860 n1_M8_75660_76860 0.001755
R23401 n1_M8_75660_76860 n1_M8_76740_76860 0.001755
R23402 n1_M8_76740_76860 n1_M8_77820_76860 0.001755
R23403 n1_M8_77820_76860 n1_M8_78900_76860 0.001755
R23404 n1_M8_78900_76860 n1_M8_79980_76860 0.001755
R23405 n1_M8_79980_76860 n1_M8_81060_76860 0.001755
R23406 n1_M8_81060_76860 n1_M8_82140_76860 0.001755
R23407 n1_M8_82140_76860 n1_M8_83220_76860 0.001755
R23408 n1_M8_83220_76860 n1_M8_84300_76860 0.001755
R23409 n1_M8_84300_76860 n1_M8_85380_76860 0.001755
R23410 n1_M8_85380_76860 n1_M8_86460_76860 0.001755
R23411 n1_M8_86460_76860 n1_M8_87540_76860 0.001755
R23412 n1_M8_87540_76860 n1_M8_88620_76860 0.001755
R23413 n1_M8_88620_76860 n1_M8_89700_76860 0.001755
R23414 n1_M8_89700_76860 n1_M8_90780_76860 0.001755
R23415 n1_M8_90780_76860 n1_M8_91860_76860 0.001755
R23416 n1_M8_91860_76860 n1_M8_92940_76860 0.001755
R23417 n1_M8_92940_76860 n1_M8_94020_76860 0.001755
R23418 n1_M8_94020_76860 n1_M8_95100_76860 0.001755
R23419 n1_M8_95100_76860 n1_M8_96180_76860 0.001755
R23420 n1_M8_96180_76860 n1_M8_97260_76860 0.001755
R23421 n1_M8_97260_76860 n1_M8_98340_76860 0.001755
R23422 n1_M8_98340_76860 n1_M8_99420_76860 0.001755
R23423 n1_M8_99420_76860 n1_M8_100500_76860 0.001755
R23424 n1_M8_100500_76860 n1_M8_101580_76860 0.001755
R23425 n1_M8_101580_76860 n1_M8_102660_76860 0.001755
R23426 n1_M8_102660_76860 n1_M8_103740_76860 0.001755
R23427 n1_M8_103740_76860 n1_M8_104820_76860 0.001755
R23428 n1_M8_104820_76860 n1_M8_105900_76860 0.001755
R23429 n1_M8_105900_76860 n1_M8_106980_76860 0.001755
R23430 n1_M8_106980_76860 n1_M8_108060_76860 0.001755
R23431 n1_M8_108060_76860 n1_M8_109140_76860 0.001755
R23432 n1_M8_109140_76860 n1_M8_110220_76860 0.001755
R23433 n1_M8_110220_76860 n1_M8_111300_76860 0.001755
R23434 n1_M8_111300_76860 n1_M8_112380_76860 0.001755
R23435 n1_M8_112380_76860 n1_M8_113460_76860 0.001755
R23436 n1_M8_113460_76860 n1_M8_114540_76860 0.001755
R23437 n1_M8_114540_76860 n1_M8_115620_76860 0.001755
R23438 n1_M8_115620_76860 n1_M8_116700_76860 0.001755
R23439 n1_M8_116700_76860 n1_M8_117780_76860 0.001755
R23440 n1_M8_117780_76860 n1_M8_118860_76860 0.001755
R23441 n1_M8_118860_76860 n1_M8_119940_76860 0.001755
R23442 n1_M8_119940_76860 n1_M8_121020_76860 0.001755
R23443 n1_M8_121020_76860 n1_M8_122100_76860 0.001755
R23444 n1_M8_122100_76860 n1_M8_123180_76860 0.001755
R23445 n1_M8_123180_76860 n1_M8_124260_76860 0.001755
R23446 n1_M8_124260_76860 n1_M8_125340_76860 0.001755
R23447 n1_M8_125340_76860 n1_M8_126420_76860 0.001755
R23448 n1_M8_126420_76860 n1_M8_127500_76860 0.001755
R23449 n1_M8_127500_76860 n1_M8_128580_76860 0.001755
R23450 n1_M8_128580_76860 n1_M8_129660_76860 0.001755
R23451 n1_M8_129660_76860 n1_M8_130740_76860 0.001755
R23452 n1_M8_130740_76860 n1_M8_131820_76860 0.001755
R23453 n1_M8_131820_76860 n1_M8_132900_76860 0.001755
R23454 n1_M8_132900_76860 n1_M8_133980_76860 0.001755
R23455 n1_M8_133980_76860 n1_M8_135060_76860 0.001755
R23456 n1_M8_135060_76860 n1_M8_136140_76860 0.001755
R23457 n1_M8_136140_76860 n1_M8_137220_76860 0.001755
R23458 n1_M8_137220_76860 n1_M8_138300_76860 0.001755
R23459 n1_M8_138300_76860 n1_M8_139380_76860 0.001755
R23460 n1_M8_139380_76860 n1_M8_140460_76860 0.001755
R23461 n1_M8_140460_76860 n1_M8_141540_76860 0.001755
R23462 n1_M8_141540_76860 n1_M8_142620_76860 0.001755
R23463 n1_M8_142620_76860 n1_M8_143700_76860 0.001755
R23464 n1_M8_143700_76860 n1_M8_144780_76860 0.001755
R23465 n1_M8_144780_76860 n1_M8_145860_76860 0.001755
R23466 n1_M8_145860_76860 n1_M8_146940_76860 0.001755
R23467 n1_M8_60_83260 n1_M8_1140_83260 0.001755
R23468 n1_M8_1140_83260 n1_M8_2220_83260 0.001755
R23469 n1_M8_2220_83260 n1_M8_3300_83260 0.001755
R23470 n1_M8_3300_83260 n1_M8_4380_83260 0.001755
R23471 n1_M8_4380_83260 n1_M8_5460_83260 0.001755
R23472 n1_M8_5460_83260 n1_M8_6540_83260 0.001755
R23473 n1_M8_6540_83260 n1_M8_7620_83260 0.001755
R23474 n1_M8_7620_83260 n1_M8_8700_83260 0.001755
R23475 n1_M8_8700_83260 n1_M8_9780_83260 0.001755
R23476 n1_M8_9780_83260 n1_M8_10860_83260 0.001755
R23477 n1_M8_10860_83260 n1_M8_11940_83260 0.001755
R23478 n1_M8_11940_83260 n1_M8_13020_83260 0.001755
R23479 n1_M8_13020_83260 n1_M8_14100_83260 0.001755
R23480 n1_M8_14100_83260 n1_M8_15180_83260 0.001755
R23481 n1_M8_15180_83260 n1_M8_16260_83260 0.001755
R23482 n1_M8_16260_83260 n1_M8_17340_83260 0.001755
R23483 n1_M8_17340_83260 n1_M8_18420_83260 0.001755
R23484 n1_M8_18420_83260 n1_M8_19500_83260 0.001755
R23485 n1_M8_19500_83260 n1_M8_20580_83260 0.001755
R23486 n1_M8_20580_83260 n1_M8_21660_83260 0.001755
R23487 n1_M8_21660_83260 n1_M8_22740_83260 0.001755
R23488 n1_M8_22740_83260 n1_M8_23820_83260 0.001755
R23489 n1_M8_23820_83260 n1_M8_24900_83260 0.001755
R23490 n1_M8_24900_83260 n1_M8_25980_83260 0.001755
R23491 n1_M8_25980_83260 n1_M8_27060_83260 0.001755
R23492 n1_M8_27060_83260 n1_M8_28140_83260 0.001755
R23493 n1_M8_28140_83260 n1_M8_29220_83260 0.001755
R23494 n1_M8_29220_83260 n1_M8_30300_83260 0.001755
R23495 n1_M8_30300_83260 n1_M8_31380_83260 0.001755
R23496 n1_M8_31380_83260 n1_M8_32460_83260 0.001755
R23497 n1_M8_32460_83260 n1_M8_33540_83260 0.001755
R23498 n1_M8_33540_83260 n1_M8_34620_83260 0.001755
R23499 n1_M8_34620_83260 n1_M8_35700_83260 0.001755
R23500 n1_M8_35700_83260 n1_M8_36780_83260 0.001755
R23501 n1_M8_36780_83260 n1_M8_37860_83260 0.001755
R23502 n1_M8_37860_83260 n1_M8_38940_83260 0.001755
R23503 n1_M8_38940_83260 n1_M8_40020_83260 0.001755
R23504 n1_M8_40020_83260 n1_M8_41100_83260 0.001755
R23505 n1_M8_41100_83260 n1_M8_42180_83260 0.001755
R23506 n1_M8_42180_83260 n1_M8_43260_83260 0.001755
R23507 n1_M8_43260_83260 n1_M8_44340_83260 0.001755
R23508 n1_M8_44340_83260 n1_M8_45420_83260 0.001755
R23509 n1_M8_45420_83260 n1_M8_46500_83260 0.001755
R23510 n1_M8_46500_83260 n1_M8_47580_83260 0.001755
R23511 n1_M8_47580_83260 n1_M8_48660_83260 0.001755
R23512 n1_M8_48660_83260 n1_M8_49740_83260 0.001755
R23513 n1_M8_49740_83260 n1_M8_50820_83260 0.001755
R23514 n1_M8_50820_83260 n1_M8_51900_83260 0.001755
R23515 n1_M8_51900_83260 n1_M8_52980_83260 0.001755
R23516 n1_M8_52980_83260 n1_M8_54060_83260 0.001755
R23517 n1_M8_54060_83260 n1_M8_55140_83260 0.001755
R23518 n1_M8_55140_83260 n1_M8_56220_83260 0.001755
R23519 n1_M8_56220_83260 n1_M8_57300_83260 0.001755
R23520 n1_M8_57300_83260 n1_M8_58380_83260 0.001755
R23521 n1_M8_58380_83260 n1_M8_59460_83260 0.001755
R23522 n1_M8_59460_83260 n1_M8_60540_83260 0.001755
R23523 n1_M8_60540_83260 n1_M8_61620_83260 0.001755
R23524 n1_M8_61620_83260 n1_M8_62700_83260 0.001755
R23525 n1_M8_62700_83260 n1_M8_63780_83260 0.001755
R23526 n1_M8_63780_83260 n1_M8_64860_83260 0.001755
R23527 n1_M8_64860_83260 n1_M8_65940_83260 0.001755
R23528 n1_M8_65940_83260 n1_M8_67020_83260 0.001755
R23529 n1_M8_67020_83260 n1_M8_68100_83260 0.001755
R23530 n1_M8_68100_83260 n1_M8_69180_83260 0.001755
R23531 n1_M8_69180_83260 n1_M8_70260_83260 0.001755
R23532 n1_M8_70260_83260 n1_M8_71340_83260 0.001755
R23533 n1_M8_71340_83260 n1_M8_72420_83260 0.001755
R23534 n1_M8_72420_83260 n1_M8_73500_83260 0.001755
R23535 n1_M8_73500_83260 n1_M8_74580_83260 0.001755
R23536 n1_M8_74580_83260 n1_M8_75660_83260 0.001755
R23537 n1_M8_75660_83260 n1_M8_76740_83260 0.001755
R23538 n1_M8_76740_83260 n1_M8_77820_83260 0.001755
R23539 n1_M8_77820_83260 n1_M8_78900_83260 0.001755
R23540 n1_M8_78900_83260 n1_M8_79980_83260 0.001755
R23541 n1_M8_79980_83260 n1_M8_81060_83260 0.001755
R23542 n1_M8_81060_83260 n1_M8_82140_83260 0.001755
R23543 n1_M8_82140_83260 n1_M8_83220_83260 0.001755
R23544 n1_M8_83220_83260 n1_M8_84300_83260 0.001755
R23545 n1_M8_84300_83260 n1_M8_85380_83260 0.001755
R23546 n1_M8_85380_83260 n1_M8_86460_83260 0.001755
R23547 n1_M8_86460_83260 n1_M8_87540_83260 0.001755
R23548 n1_M8_87540_83260 n1_M8_88620_83260 0.001755
R23549 n1_M8_88620_83260 n1_M8_89700_83260 0.001755
R23550 n1_M8_89700_83260 n1_M8_90780_83260 0.001755
R23551 n1_M8_90780_83260 n1_M8_91860_83260 0.001755
R23552 n1_M8_91860_83260 n1_M8_92940_83260 0.001755
R23553 n1_M8_92940_83260 n1_M8_94020_83260 0.001755
R23554 n1_M8_94020_83260 n1_M8_95100_83260 0.001755
R23555 n1_M8_95100_83260 n1_M8_96180_83260 0.001755
R23556 n1_M8_96180_83260 n1_M8_97260_83260 0.001755
R23557 n1_M8_97260_83260 n1_M8_98340_83260 0.001755
R23558 n1_M8_98340_83260 n1_M8_99420_83260 0.001755
R23559 n1_M8_99420_83260 n1_M8_100500_83260 0.001755
R23560 n1_M8_100500_83260 n1_M8_101580_83260 0.001755
R23561 n1_M8_101580_83260 n1_M8_102660_83260 0.001755
R23562 n1_M8_102660_83260 n1_M8_103740_83260 0.001755
R23563 n1_M8_103740_83260 n1_M8_104820_83260 0.001755
R23564 n1_M8_104820_83260 n1_M8_105900_83260 0.001755
R23565 n1_M8_105900_83260 n1_M8_106980_83260 0.001755
R23566 n1_M8_106980_83260 n1_M8_108060_83260 0.001755
R23567 n1_M8_108060_83260 n1_M8_109140_83260 0.001755
R23568 n1_M8_109140_83260 n1_M8_110220_83260 0.001755
R23569 n1_M8_110220_83260 n1_M8_111300_83260 0.001755
R23570 n1_M8_111300_83260 n1_M8_112380_83260 0.001755
R23571 n1_M8_112380_83260 n1_M8_113460_83260 0.001755
R23572 n1_M8_113460_83260 n1_M8_114540_83260 0.001755
R23573 n1_M8_114540_83260 n1_M8_115620_83260 0.001755
R23574 n1_M8_115620_83260 n1_M8_116700_83260 0.001755
R23575 n1_M8_116700_83260 n1_M8_117780_83260 0.001755
R23576 n1_M8_117780_83260 n1_M8_118860_83260 0.001755
R23577 n1_M8_118860_83260 n1_M8_119940_83260 0.001755
R23578 n1_M8_119940_83260 n1_M8_121020_83260 0.001755
R23579 n1_M8_121020_83260 n1_M8_122100_83260 0.001755
R23580 n1_M8_122100_83260 n1_M8_123180_83260 0.001755
R23581 n1_M8_123180_83260 n1_M8_124260_83260 0.001755
R23582 n1_M8_124260_83260 n1_M8_125340_83260 0.001755
R23583 n1_M8_125340_83260 n1_M8_126420_83260 0.001755
R23584 n1_M8_126420_83260 n1_M8_127500_83260 0.001755
R23585 n1_M8_127500_83260 n1_M8_128580_83260 0.001755
R23586 n1_M8_128580_83260 n1_M8_129660_83260 0.001755
R23587 n1_M8_129660_83260 n1_M8_130740_83260 0.001755
R23588 n1_M8_130740_83260 n1_M8_131820_83260 0.001755
R23589 n1_M8_131820_83260 n1_M8_132900_83260 0.001755
R23590 n1_M8_132900_83260 n1_M8_133980_83260 0.001755
R23591 n1_M8_133980_83260 n1_M8_135060_83260 0.001755
R23592 n1_M8_135060_83260 n1_M8_136140_83260 0.001755
R23593 n1_M8_136140_83260 n1_M8_137220_83260 0.001755
R23594 n1_M8_137220_83260 n1_M8_138300_83260 0.001755
R23595 n1_M8_138300_83260 n1_M8_139380_83260 0.001755
R23596 n1_M8_139380_83260 n1_M8_140460_83260 0.001755
R23597 n1_M8_140460_83260 n1_M8_141540_83260 0.001755
R23598 n1_M8_141540_83260 n1_M8_142620_83260 0.001755
R23599 n1_M8_142620_83260 n1_M8_143700_83260 0.001755
R23600 n1_M8_143700_83260 n1_M8_144780_83260 0.001755
R23601 n1_M8_144780_83260 n1_M8_145860_83260 0.001755
R23602 n1_M8_145860_83260 n1_M8_146940_83260 0.001755
R23603 n1_M8_60_89660 n1_M8_1140_89660 0.001755
R23604 n1_M8_1140_89660 n1_M8_2220_89660 0.001755
R23605 n1_M8_2220_89660 n1_M8_3300_89660 0.001755
R23606 n1_M8_3300_89660 n1_M8_4380_89660 0.001755
R23607 n1_M8_4380_89660 n1_M8_5460_89660 0.001755
R23608 n1_M8_5460_89660 n1_M8_6540_89660 0.001755
R23609 n1_M8_6540_89660 n1_M8_7620_89660 0.001755
R23610 n1_M8_7620_89660 n1_M8_8700_89660 0.001755
R23611 n1_M8_8700_89660 n1_M8_9780_89660 0.001755
R23612 n1_M8_9780_89660 n1_M8_10860_89660 0.001755
R23613 n1_M8_10860_89660 n1_M8_11940_89660 0.001755
R23614 n1_M8_11940_89660 n1_M8_13020_89660 0.001755
R23615 n1_M8_13020_89660 n1_M8_14100_89660 0.001755
R23616 n1_M8_14100_89660 n1_M8_15180_89660 0.001755
R23617 n1_M8_15180_89660 n1_M8_16260_89660 0.001755
R23618 n1_M8_16260_89660 n1_M8_17340_89660 0.001755
R23619 n1_M8_17340_89660 n1_M8_18420_89660 0.001755
R23620 n1_M8_18420_89660 n1_M8_19500_89660 0.001755
R23621 n1_M8_19500_89660 n1_M8_20580_89660 0.001755
R23622 n1_M8_20580_89660 n1_M8_21660_89660 0.001755
R23623 n1_M8_21660_89660 n1_M8_22740_89660 0.001755
R23624 n1_M8_22740_89660 n1_M8_23820_89660 0.001755
R23625 n1_M8_23820_89660 n1_M8_24900_89660 0.001755
R23626 n1_M8_24900_89660 n1_M8_25980_89660 0.001755
R23627 n1_M8_25980_89660 n1_M8_27060_89660 0.001755
R23628 n1_M8_27060_89660 n1_M8_28140_89660 0.001755
R23629 n1_M8_28140_89660 n1_M8_29220_89660 0.001755
R23630 n1_M8_29220_89660 n1_M8_30300_89660 0.001755
R23631 n1_M8_30300_89660 n1_M8_31380_89660 0.001755
R23632 n1_M8_31380_89660 n1_M8_32460_89660 0.001755
R23633 n1_M8_32460_89660 n1_M8_33540_89660 0.001755
R23634 n1_M8_33540_89660 n1_M8_34620_89660 0.001755
R23635 n1_M8_34620_89660 n1_M8_35700_89660 0.001755
R23636 n1_M8_35700_89660 n1_M8_36780_89660 0.001755
R23637 n1_M8_36780_89660 n1_M8_37860_89660 0.001755
R23638 n1_M8_37860_89660 n1_M8_38940_89660 0.001755
R23639 n1_M8_38940_89660 n1_M8_40020_89660 0.001755
R23640 n1_M8_40020_89660 n1_M8_41100_89660 0.001755
R23641 n1_M8_41100_89660 n1_M8_42180_89660 0.001755
R23642 n1_M8_42180_89660 n1_M8_43260_89660 0.001755
R23643 n1_M8_43260_89660 n1_M8_44340_89660 0.001755
R23644 n1_M8_44340_89660 n1_M8_45420_89660 0.001755
R23645 n1_M8_45420_89660 n1_M8_46500_89660 0.001755
R23646 n1_M8_46500_89660 n1_M8_47580_89660 0.001755
R23647 n1_M8_47580_89660 n1_M8_48660_89660 0.001755
R23648 n1_M8_48660_89660 n1_M8_49740_89660 0.001755
R23649 n1_M8_49740_89660 n1_M8_50820_89660 0.001755
R23650 n1_M8_50820_89660 n1_M8_51900_89660 0.001755
R23651 n1_M8_51900_89660 n1_M8_52980_89660 0.001755
R23652 n1_M8_52980_89660 n1_M8_54060_89660 0.001755
R23653 n1_M8_54060_89660 n1_M8_55140_89660 0.001755
R23654 n1_M8_55140_89660 n1_M8_56220_89660 0.001755
R23655 n1_M8_56220_89660 n1_M8_57300_89660 0.001755
R23656 n1_M8_57300_89660 n1_M8_58380_89660 0.001755
R23657 n1_M8_58380_89660 n1_M8_59460_89660 0.001755
R23658 n1_M8_59460_89660 n1_M8_60540_89660 0.001755
R23659 n1_M8_60540_89660 n1_M8_61620_89660 0.001755
R23660 n1_M8_61620_89660 n1_M8_62700_89660 0.001755
R23661 n1_M8_62700_89660 n1_M8_63780_89660 0.001755
R23662 n1_M8_63780_89660 n1_M8_64860_89660 0.001755
R23663 n1_M8_64860_89660 n1_M8_65940_89660 0.001755
R23664 n1_M8_65940_89660 n1_M8_67020_89660 0.001755
R23665 n1_M8_67020_89660 n1_M8_68100_89660 0.001755
R23666 n1_M8_68100_89660 n1_M8_69180_89660 0.001755
R23667 n1_M8_69180_89660 n1_M8_70260_89660 0.001755
R23668 n1_M8_70260_89660 n1_M8_71340_89660 0.001755
R23669 n1_M8_71340_89660 n1_M8_72420_89660 0.001755
R23670 n1_M8_72420_89660 n1_M8_73500_89660 0.001755
R23671 n1_M8_73500_89660 n1_M8_74580_89660 0.001755
R23672 n1_M8_74580_89660 n1_M8_75660_89660 0.001755
R23673 n1_M8_75660_89660 n1_M8_76740_89660 0.001755
R23674 n1_M8_76740_89660 n1_M8_77820_89660 0.001755
R23675 n1_M8_77820_89660 n1_M8_78900_89660 0.001755
R23676 n1_M8_78900_89660 n1_M8_79980_89660 0.001755
R23677 n1_M8_79980_89660 n1_M8_81060_89660 0.001755
R23678 n1_M8_81060_89660 n1_M8_82140_89660 0.001755
R23679 n1_M8_82140_89660 n1_M8_83220_89660 0.001755
R23680 n1_M8_83220_89660 n1_M8_84300_89660 0.001755
R23681 n1_M8_84300_89660 n1_M8_85380_89660 0.001755
R23682 n1_M8_85380_89660 n1_M8_86460_89660 0.001755
R23683 n1_M8_86460_89660 n1_M8_87540_89660 0.001755
R23684 n1_M8_87540_89660 n1_M8_88620_89660 0.001755
R23685 n1_M8_88620_89660 n1_M8_89700_89660 0.001755
R23686 n1_M8_89700_89660 n1_M8_90780_89660 0.001755
R23687 n1_M8_90780_89660 n1_M8_91860_89660 0.001755
R23688 n1_M8_91860_89660 n1_M8_92940_89660 0.001755
R23689 n1_M8_92940_89660 n1_M8_94020_89660 0.001755
R23690 n1_M8_94020_89660 n1_M8_95100_89660 0.001755
R23691 n1_M8_95100_89660 n1_M8_96180_89660 0.001755
R23692 n1_M8_96180_89660 n1_M8_97260_89660 0.001755
R23693 n1_M8_97260_89660 n1_M8_98340_89660 0.001755
R23694 n1_M8_98340_89660 n1_M8_99420_89660 0.001755
R23695 n1_M8_99420_89660 n1_M8_100500_89660 0.001755
R23696 n1_M8_100500_89660 n1_M8_101580_89660 0.001755
R23697 n1_M8_101580_89660 n1_M8_102660_89660 0.001755
R23698 n1_M8_102660_89660 n1_M8_103740_89660 0.001755
R23699 n1_M8_103740_89660 n1_M8_104820_89660 0.001755
R23700 n1_M8_104820_89660 n1_M8_105900_89660 0.001755
R23701 n1_M8_105900_89660 n1_M8_106980_89660 0.001755
R23702 n1_M8_106980_89660 n1_M8_108060_89660 0.001755
R23703 n1_M8_108060_89660 n1_M8_109140_89660 0.001755
R23704 n1_M8_109140_89660 n1_M8_110220_89660 0.001755
R23705 n1_M8_110220_89660 n1_M8_111300_89660 0.001755
R23706 n1_M8_111300_89660 n1_M8_112380_89660 0.001755
R23707 n1_M8_112380_89660 n1_M8_113460_89660 0.001755
R23708 n1_M8_113460_89660 n1_M8_114540_89660 0.001755
R23709 n1_M8_114540_89660 n1_M8_115620_89660 0.001755
R23710 n1_M8_115620_89660 n1_M8_116700_89660 0.001755
R23711 n1_M8_116700_89660 n1_M8_117780_89660 0.001755
R23712 n1_M8_117780_89660 n1_M8_118860_89660 0.001755
R23713 n1_M8_118860_89660 n1_M8_119940_89660 0.001755
R23714 n1_M8_119940_89660 n1_M8_121020_89660 0.001755
R23715 n1_M8_121020_89660 n1_M8_122100_89660 0.001755
R23716 n1_M8_122100_89660 n1_M8_123180_89660 0.001755
R23717 n1_M8_123180_89660 n1_M8_124260_89660 0.001755
R23718 n1_M8_124260_89660 n1_M8_125340_89660 0.001755
R23719 n1_M8_125340_89660 n1_M8_126420_89660 0.001755
R23720 n1_M8_126420_89660 n1_M8_127500_89660 0.001755
R23721 n1_M8_127500_89660 n1_M8_128580_89660 0.001755
R23722 n1_M8_128580_89660 n1_M8_129660_89660 0.001755
R23723 n1_M8_129660_89660 n1_M8_130740_89660 0.001755
R23724 n1_M8_130740_89660 n1_M8_131820_89660 0.001755
R23725 n1_M8_131820_89660 n1_M8_132900_89660 0.001755
R23726 n1_M8_132900_89660 n1_M8_133980_89660 0.001755
R23727 n1_M8_133980_89660 n1_M8_135060_89660 0.001755
R23728 n1_M8_135060_89660 n1_M8_136140_89660 0.001755
R23729 n1_M8_136140_89660 n1_M8_137220_89660 0.001755
R23730 n1_M8_137220_89660 n1_M8_138300_89660 0.001755
R23731 n1_M8_138300_89660 n1_M8_139380_89660 0.001755
R23732 n1_M8_139380_89660 n1_M8_140460_89660 0.001755
R23733 n1_M8_140460_89660 n1_M8_141540_89660 0.001755
R23734 n1_M8_141540_89660 n1_M8_142620_89660 0.001755
R23735 n1_M8_142620_89660 n1_M8_143700_89660 0.001755
R23736 n1_M8_143700_89660 n1_M8_144780_89660 0.001755
R23737 n1_M8_144780_89660 n1_M8_145860_89660 0.001755
R23738 n1_M8_145860_89660 n1_M8_146940_89660 0.001755
R23739 n1_M8_60_96060 n1_M8_1140_96060 0.001755
R23740 n1_M8_1140_96060 n1_M8_2220_96060 0.001755
R23741 n1_M8_2220_96060 n1_M8_3300_96060 0.001755
R23742 n1_M8_3300_96060 n1_M8_4380_96060 0.001755
R23743 n1_M8_4380_96060 n1_M8_5460_96060 0.001755
R23744 n1_M8_5460_96060 n1_M8_6540_96060 0.001755
R23745 n1_M8_6540_96060 n1_M8_7620_96060 0.001755
R23746 n1_M8_7620_96060 n1_M8_8700_96060 0.001755
R23747 n1_M8_8700_96060 n1_M8_9780_96060 0.001755
R23748 n1_M8_9780_96060 n1_M8_10860_96060 0.001755
R23749 n1_M8_10860_96060 n1_M8_11940_96060 0.001755
R23750 n1_M8_11940_96060 n1_M8_13020_96060 0.001755
R23751 n1_M8_13020_96060 n1_M8_14100_96060 0.001755
R23752 n1_M8_14100_96060 n1_M8_15180_96060 0.001755
R23753 n1_M8_15180_96060 n1_M8_16260_96060 0.001755
R23754 n1_M8_16260_96060 n1_M8_17340_96060 0.001755
R23755 n1_M8_17340_96060 n1_M8_18420_96060 0.001755
R23756 n1_M8_18420_96060 n1_M8_19500_96060 0.001755
R23757 n1_M8_19500_96060 n1_M8_20580_96060 0.001755
R23758 n1_M8_20580_96060 n1_M8_21660_96060 0.001755
R23759 n1_M8_21660_96060 n1_M8_22740_96060 0.001755
R23760 n1_M8_22740_96060 n1_M8_23820_96060 0.001755
R23761 n1_M8_23820_96060 n1_M8_24900_96060 0.001755
R23762 n1_M8_24900_96060 n1_M8_25980_96060 0.001755
R23763 n1_M8_25980_96060 n1_M8_27060_96060 0.001755
R23764 n1_M8_27060_96060 n1_M8_28140_96060 0.001755
R23765 n1_M8_28140_96060 n1_M8_29220_96060 0.001755
R23766 n1_M8_29220_96060 n1_M8_30300_96060 0.001755
R23767 n1_M8_30300_96060 n1_M8_31380_96060 0.001755
R23768 n1_M8_31380_96060 n1_M8_32460_96060 0.001755
R23769 n1_M8_32460_96060 n1_M8_33540_96060 0.001755
R23770 n1_M8_33540_96060 n1_M8_34620_96060 0.001755
R23771 n1_M8_34620_96060 n1_M8_35700_96060 0.001755
R23772 n1_M8_35700_96060 n1_M8_36780_96060 0.001755
R23773 n1_M8_36780_96060 n1_M8_37860_96060 0.001755
R23774 n1_M8_37860_96060 n1_M8_38940_96060 0.001755
R23775 n1_M8_38940_96060 n1_M8_40020_96060 0.001755
R23776 n1_M8_40020_96060 n1_M8_41100_96060 0.001755
R23777 n1_M8_41100_96060 n1_M8_42180_96060 0.001755
R23778 n1_M8_42180_96060 n1_M8_43260_96060 0.001755
R23779 n1_M8_43260_96060 n1_M8_44340_96060 0.001755
R23780 n1_M8_44340_96060 n1_M8_45420_96060 0.001755
R23781 n1_M8_45420_96060 n1_M8_46500_96060 0.001755
R23782 n1_M8_46500_96060 n1_M8_47580_96060 0.001755
R23783 n1_M8_47580_96060 n1_M8_48660_96060 0.001755
R23784 n1_M8_48660_96060 n1_M8_49740_96060 0.001755
R23785 n1_M8_49740_96060 n1_M8_50820_96060 0.001755
R23786 n1_M8_50820_96060 n1_M8_51900_96060 0.001755
R23787 n1_M8_51900_96060 n1_M8_52980_96060 0.001755
R23788 n1_M8_52980_96060 n1_M8_54060_96060 0.001755
R23789 n1_M8_54060_96060 n1_M8_55140_96060 0.001755
R23790 n1_M8_55140_96060 n1_M8_56220_96060 0.001755
R23791 n1_M8_56220_96060 n1_M8_57300_96060 0.001755
R23792 n1_M8_57300_96060 n1_M8_58380_96060 0.001755
R23793 n1_M8_58380_96060 n1_M8_59460_96060 0.001755
R23794 n1_M8_59460_96060 n1_M8_60540_96060 0.001755
R23795 n1_M8_60540_96060 n1_M8_61620_96060 0.001755
R23796 n1_M8_61620_96060 n1_M8_62700_96060 0.001755
R23797 n1_M8_62700_96060 n1_M8_63780_96060 0.001755
R23798 n1_M8_63780_96060 n1_M8_64860_96060 0.001755
R23799 n1_M8_64860_96060 n1_M8_65940_96060 0.001755
R23800 n1_M8_65940_96060 n1_M8_67020_96060 0.001755
R23801 n1_M8_67020_96060 n1_M8_68100_96060 0.001755
R23802 n1_M8_68100_96060 n1_M8_69180_96060 0.001755
R23803 n1_M8_69180_96060 n1_M8_70260_96060 0.001755
R23804 n1_M8_70260_96060 n1_M8_71340_96060 0.001755
R23805 n1_M8_71340_96060 n1_M8_72420_96060 0.001755
R23806 n1_M8_72420_96060 n1_M8_73500_96060 0.001755
R23807 n1_M8_73500_96060 n1_M8_74580_96060 0.001755
R23808 n1_M8_74580_96060 n1_M8_75660_96060 0.001755
R23809 n1_M8_75660_96060 n1_M8_76740_96060 0.001755
R23810 n1_M8_76740_96060 n1_M8_77820_96060 0.001755
R23811 n1_M8_77820_96060 n1_M8_78900_96060 0.001755
R23812 n1_M8_78900_96060 n1_M8_79980_96060 0.001755
R23813 n1_M8_79980_96060 n1_M8_81060_96060 0.001755
R23814 n1_M8_81060_96060 n1_M8_82140_96060 0.001755
R23815 n1_M8_82140_96060 n1_M8_83220_96060 0.001755
R23816 n1_M8_83220_96060 n1_M8_84300_96060 0.001755
R23817 n1_M8_84300_96060 n1_M8_85380_96060 0.001755
R23818 n1_M8_85380_96060 n1_M8_86460_96060 0.001755
R23819 n1_M8_86460_96060 n1_M8_87540_96060 0.001755
R23820 n1_M8_87540_96060 n1_M8_88620_96060 0.001755
R23821 n1_M8_88620_96060 n1_M8_89700_96060 0.001755
R23822 n1_M8_89700_96060 n1_M8_90780_96060 0.001755
R23823 n1_M8_90780_96060 n1_M8_91860_96060 0.001755
R23824 n1_M8_91860_96060 n1_M8_92940_96060 0.001755
R23825 n1_M8_92940_96060 n1_M8_94020_96060 0.001755
R23826 n1_M8_94020_96060 n1_M8_95100_96060 0.001755
R23827 n1_M8_95100_96060 n1_M8_96180_96060 0.001755
R23828 n1_M8_96180_96060 n1_M8_97260_96060 0.001755
R23829 n1_M8_97260_96060 n1_M8_98340_96060 0.001755
R23830 n1_M8_98340_96060 n1_M8_99420_96060 0.001755
R23831 n1_M8_99420_96060 n1_M8_100500_96060 0.001755
R23832 n1_M8_100500_96060 n1_M8_101580_96060 0.001755
R23833 n1_M8_101580_96060 n1_M8_102660_96060 0.001755
R23834 n1_M8_102660_96060 n1_M8_103740_96060 0.001755
R23835 n1_M8_103740_96060 n1_M8_104820_96060 0.001755
R23836 n1_M8_104820_96060 n1_M8_105900_96060 0.001755
R23837 n1_M8_105900_96060 n1_M8_106980_96060 0.001755
R23838 n1_M8_106980_96060 n1_M8_108060_96060 0.001755
R23839 n1_M8_108060_96060 n1_M8_109140_96060 0.001755
R23840 n1_M8_109140_96060 n1_M8_110220_96060 0.001755
R23841 n1_M8_110220_96060 n1_M8_111300_96060 0.001755
R23842 n1_M8_111300_96060 n1_M8_112380_96060 0.001755
R23843 n1_M8_112380_96060 n1_M8_113460_96060 0.001755
R23844 n1_M8_113460_96060 n1_M8_114540_96060 0.001755
R23845 n1_M8_114540_96060 n1_M8_115620_96060 0.001755
R23846 n1_M8_115620_96060 n1_M8_116700_96060 0.001755
R23847 n1_M8_116700_96060 n1_M8_117780_96060 0.001755
R23848 n1_M8_117780_96060 n1_M8_118860_96060 0.001755
R23849 n1_M8_118860_96060 n1_M8_119940_96060 0.001755
R23850 n1_M8_119940_96060 n1_M8_121020_96060 0.001755
R23851 n1_M8_121020_96060 n1_M8_122100_96060 0.001755
R23852 n1_M8_122100_96060 n1_M8_123180_96060 0.001755
R23853 n1_M8_123180_96060 n1_M8_124260_96060 0.001755
R23854 n1_M8_124260_96060 n1_M8_125340_96060 0.001755
R23855 n1_M8_125340_96060 n1_M8_126420_96060 0.001755
R23856 n1_M8_126420_96060 n1_M8_127500_96060 0.001755
R23857 n1_M8_127500_96060 n1_M8_128580_96060 0.001755
R23858 n1_M8_128580_96060 n1_M8_129660_96060 0.001755
R23859 n1_M8_129660_96060 n1_M8_130740_96060 0.001755
R23860 n1_M8_130740_96060 n1_M8_131820_96060 0.001755
R23861 n1_M8_131820_96060 n1_M8_132900_96060 0.001755
R23862 n1_M8_132900_96060 n1_M8_133980_96060 0.001755
R23863 n1_M8_133980_96060 n1_M8_135060_96060 0.001755
R23864 n1_M8_135060_96060 n1_M8_136140_96060 0.001755
R23865 n1_M8_136140_96060 n1_M8_137220_96060 0.001755
R23866 n1_M8_137220_96060 n1_M8_138300_96060 0.001755
R23867 n1_M8_138300_96060 n1_M8_139380_96060 0.001755
R23868 n1_M8_139380_96060 n1_M8_140460_96060 0.001755
R23869 n1_M8_140460_96060 n1_M8_141540_96060 0.001755
R23870 n1_M8_141540_96060 n1_M8_142620_96060 0.001755
R23871 n1_M8_142620_96060 n1_M8_143700_96060 0.001755
R23872 n1_M8_143700_96060 n1_M8_144780_96060 0.001755
R23873 n1_M8_144780_96060 n1_M8_145860_96060 0.001755
R23874 n1_M8_145860_96060 n1_M8_146940_96060 0.001755
R23875 n1_M8_60_102460 n1_M8_1140_102460 0.001755
R23876 n1_M8_1140_102460 n1_M8_2220_102460 0.001755
R23877 n1_M8_2220_102460 n1_M8_3300_102460 0.001755
R23878 n1_M8_3300_102460 n1_M8_4380_102460 0.001755
R23879 n1_M8_4380_102460 n1_M8_5460_102460 0.001755
R23880 n1_M8_5460_102460 n1_M8_6540_102460 0.001755
R23881 n1_M8_6540_102460 n1_M8_7620_102460 0.001755
R23882 n1_M8_7620_102460 n1_M8_8700_102460 0.001755
R23883 n1_M8_8700_102460 n1_M8_9780_102460 0.001755
R23884 n1_M8_9780_102460 n1_M8_10860_102460 0.001755
R23885 n1_M8_10860_102460 n1_M8_11940_102460 0.001755
R23886 n1_M8_11940_102460 n1_M8_13020_102460 0.001755
R23887 n1_M8_13020_102460 n1_M8_14100_102460 0.001755
R23888 n1_M8_14100_102460 n1_M8_15180_102460 0.001755
R23889 n1_M8_15180_102460 n1_M8_16260_102460 0.001755
R23890 n1_M8_16260_102460 n1_M8_17340_102460 0.001755
R23891 n1_M8_17340_102460 n1_M8_18420_102460 0.001755
R23892 n1_M8_18420_102460 n1_M8_19500_102460 0.001755
R23893 n1_M8_19500_102460 n1_M8_20580_102460 0.001755
R23894 n1_M8_20580_102460 n1_M8_21660_102460 0.001755
R23895 n1_M8_21660_102460 n1_M8_22740_102460 0.001755
R23896 n1_M8_22740_102460 n1_M8_23820_102460 0.001755
R23897 n1_M8_23820_102460 n1_M8_24900_102460 0.001755
R23898 n1_M8_24900_102460 n1_M8_25980_102460 0.001755
R23899 n1_M8_25980_102460 n1_M8_27060_102460 0.001755
R23900 n1_M8_27060_102460 n1_M8_28140_102460 0.001755
R23901 n1_M8_28140_102460 n1_M8_29220_102460 0.001755
R23902 n1_M8_29220_102460 n1_M8_30300_102460 0.001755
R23903 n1_M8_30300_102460 n1_M8_31380_102460 0.001755
R23904 n1_M8_31380_102460 n1_M8_32460_102460 0.001755
R23905 n1_M8_32460_102460 n1_M8_33540_102460 0.001755
R23906 n1_M8_33540_102460 n1_M8_34620_102460 0.001755
R23907 n1_M8_34620_102460 n1_M8_35700_102460 0.001755
R23908 n1_M8_35700_102460 n1_M8_36780_102460 0.001755
R23909 n1_M8_36780_102460 n1_M8_37860_102460 0.001755
R23910 n1_M8_37860_102460 n1_M8_38940_102460 0.001755
R23911 n1_M8_38940_102460 n1_M8_40020_102460 0.001755
R23912 n1_M8_40020_102460 n1_M8_41100_102460 0.001755
R23913 n1_M8_41100_102460 n1_M8_42180_102460 0.001755
R23914 n1_M8_42180_102460 n1_M8_43260_102460 0.001755
R23915 n1_M8_43260_102460 n1_M8_44340_102460 0.001755
R23916 n1_M8_44340_102460 n1_M8_45420_102460 0.001755
R23917 n1_M8_45420_102460 n1_M8_46500_102460 0.001755
R23918 n1_M8_46500_102460 n1_M8_47580_102460 0.001755
R23919 n1_M8_47580_102460 n1_M8_48660_102460 0.001755
R23920 n1_M8_48660_102460 n1_M8_49740_102460 0.001755
R23921 n1_M8_49740_102460 n1_M8_50820_102460 0.001755
R23922 n1_M8_50820_102460 n1_M8_51900_102460 0.001755
R23923 n1_M8_51900_102460 n1_M8_52980_102460 0.001755
R23924 n1_M8_52980_102460 n1_M8_54060_102460 0.001755
R23925 n1_M8_54060_102460 n1_M8_55140_102460 0.001755
R23926 n1_M8_55140_102460 n1_M8_56220_102460 0.001755
R23927 n1_M8_56220_102460 n1_M8_57300_102460 0.001755
R23928 n1_M8_57300_102460 n1_M8_58380_102460 0.001755
R23929 n1_M8_58380_102460 n1_M8_59460_102460 0.001755
R23930 n1_M8_59460_102460 n1_M8_60540_102460 0.001755
R23931 n1_M8_60540_102460 n1_M8_61620_102460 0.001755
R23932 n1_M8_61620_102460 n1_M8_62700_102460 0.001755
R23933 n1_M8_62700_102460 n1_M8_63780_102460 0.001755
R23934 n1_M8_63780_102460 n1_M8_64860_102460 0.001755
R23935 n1_M8_64860_102460 n1_M8_65940_102460 0.001755
R23936 n1_M8_65940_102460 n1_M8_67020_102460 0.001755
R23937 n1_M8_67020_102460 n1_M8_68100_102460 0.001755
R23938 n1_M8_68100_102460 n1_M8_69180_102460 0.001755
R23939 n1_M8_69180_102460 n1_M8_70260_102460 0.001755
R23940 n1_M8_70260_102460 n1_M8_71340_102460 0.001755
R23941 n1_M8_71340_102460 n1_M8_72420_102460 0.001755
R23942 n1_M8_72420_102460 n1_M8_73500_102460 0.001755
R23943 n1_M8_73500_102460 n1_M8_74580_102460 0.001755
R23944 n1_M8_74580_102460 n1_M8_75660_102460 0.001755
R23945 n1_M8_75660_102460 n1_M8_76740_102460 0.001755
R23946 n1_M8_76740_102460 n1_M8_77820_102460 0.001755
R23947 n1_M8_77820_102460 n1_M8_78900_102460 0.001755
R23948 n1_M8_78900_102460 n1_M8_79980_102460 0.001755
R23949 n1_M8_79980_102460 n1_M8_81060_102460 0.001755
R23950 n1_M8_81060_102460 n1_M8_82140_102460 0.001755
R23951 n1_M8_82140_102460 n1_M8_83220_102460 0.001755
R23952 n1_M8_83220_102460 n1_M8_84300_102460 0.001755
R23953 n1_M8_84300_102460 n1_M8_85380_102460 0.001755
R23954 n1_M8_85380_102460 n1_M8_86460_102460 0.001755
R23955 n1_M8_86460_102460 n1_M8_87540_102460 0.001755
R23956 n1_M8_87540_102460 n1_M8_88620_102460 0.001755
R23957 n1_M8_88620_102460 n1_M8_89700_102460 0.001755
R23958 n1_M8_89700_102460 n1_M8_90780_102460 0.001755
R23959 n1_M8_90780_102460 n1_M8_91860_102460 0.001755
R23960 n1_M8_91860_102460 n1_M8_92940_102460 0.001755
R23961 n1_M8_92940_102460 n1_M8_94020_102460 0.001755
R23962 n1_M8_94020_102460 n1_M8_95100_102460 0.001755
R23963 n1_M8_95100_102460 n1_M8_96180_102460 0.001755
R23964 n1_M8_96180_102460 n1_M8_97260_102460 0.001755
R23965 n1_M8_97260_102460 n1_M8_98340_102460 0.001755
R23966 n1_M8_98340_102460 n1_M8_99420_102460 0.001755
R23967 n1_M8_99420_102460 n1_M8_100500_102460 0.001755
R23968 n1_M8_100500_102460 n1_M8_101580_102460 0.001755
R23969 n1_M8_101580_102460 n1_M8_102660_102460 0.001755
R23970 n1_M8_102660_102460 n1_M8_103740_102460 0.001755
R23971 n1_M8_103740_102460 n1_M8_104820_102460 0.001755
R23972 n1_M8_104820_102460 n1_M8_105900_102460 0.001755
R23973 n1_M8_105900_102460 n1_M8_106980_102460 0.001755
R23974 n1_M8_106980_102460 n1_M8_108060_102460 0.001755
R23975 n1_M8_108060_102460 n1_M8_109140_102460 0.001755
R23976 n1_M8_109140_102460 n1_M8_110220_102460 0.001755
R23977 n1_M8_110220_102460 n1_M8_111300_102460 0.001755
R23978 n1_M8_111300_102460 n1_M8_112380_102460 0.001755
R23979 n1_M8_112380_102460 n1_M8_113460_102460 0.001755
R23980 n1_M8_113460_102460 n1_M8_114540_102460 0.001755
R23981 n1_M8_114540_102460 n1_M8_115620_102460 0.001755
R23982 n1_M8_115620_102460 n1_M8_116700_102460 0.001755
R23983 n1_M8_116700_102460 n1_M8_117780_102460 0.001755
R23984 n1_M8_117780_102460 n1_M8_118860_102460 0.001755
R23985 n1_M8_118860_102460 n1_M8_119940_102460 0.001755
R23986 n1_M8_119940_102460 n1_M8_121020_102460 0.001755
R23987 n1_M8_121020_102460 n1_M8_122100_102460 0.001755
R23988 n1_M8_122100_102460 n1_M8_123180_102460 0.001755
R23989 n1_M8_123180_102460 n1_M8_124260_102460 0.001755
R23990 n1_M8_124260_102460 n1_M8_125340_102460 0.001755
R23991 n1_M8_125340_102460 n1_M8_126420_102460 0.001755
R23992 n1_M8_126420_102460 n1_M8_127500_102460 0.001755
R23993 n1_M8_127500_102460 n1_M8_128580_102460 0.001755
R23994 n1_M8_128580_102460 n1_M8_129660_102460 0.001755
R23995 n1_M8_129660_102460 n1_M8_130740_102460 0.001755
R23996 n1_M8_130740_102460 n1_M8_131820_102460 0.001755
R23997 n1_M8_131820_102460 n1_M8_132900_102460 0.001755
R23998 n1_M8_132900_102460 n1_M8_133980_102460 0.001755
R23999 n1_M8_133980_102460 n1_M8_135060_102460 0.001755
R24000 n1_M8_135060_102460 n1_M8_136140_102460 0.001755
R24001 n1_M8_136140_102460 n1_M8_137220_102460 0.001755
R24002 n1_M8_137220_102460 n1_M8_138300_102460 0.001755
R24003 n1_M8_138300_102460 n1_M8_139380_102460 0.001755
R24004 n1_M8_139380_102460 n1_M8_140460_102460 0.001755
R24005 n1_M8_140460_102460 n1_M8_141540_102460 0.001755
R24006 n1_M8_141540_102460 n1_M8_142620_102460 0.001755
R24007 n1_M8_142620_102460 n1_M8_143700_102460 0.001755
R24008 n1_M8_143700_102460 n1_M8_144780_102460 0.001755
R24009 n1_M8_144780_102460 n1_M8_145860_102460 0.001755
R24010 n1_M8_145860_102460 n1_M8_146940_102460 0.001755
R24011 n1_M8_60_108860 n1_M8_1140_108860 0.001755
R24012 n1_M8_1140_108860 n1_M8_2220_108860 0.001755
R24013 n1_M8_2220_108860 n1_M8_3300_108860 0.001755
R24014 n1_M8_3300_108860 n1_M8_4380_108860 0.001755
R24015 n1_M8_4380_108860 n1_M8_5460_108860 0.001755
R24016 n1_M8_5460_108860 n1_M8_6540_108860 0.001755
R24017 n1_M8_6540_108860 n1_M8_7620_108860 0.001755
R24018 n1_M8_7620_108860 n1_M8_8700_108860 0.001755
R24019 n1_M8_8700_108860 n1_M8_9780_108860 0.001755
R24020 n1_M8_9780_108860 n1_M8_10860_108860 0.001755
R24021 n1_M8_10860_108860 n1_M8_11940_108860 0.001755
R24022 n1_M8_11940_108860 n1_M8_13020_108860 0.001755
R24023 n1_M8_13020_108860 n1_M8_14100_108860 0.001755
R24024 n1_M8_14100_108860 n1_M8_15180_108860 0.001755
R24025 n1_M8_15180_108860 n1_M8_16260_108860 0.001755
R24026 n1_M8_16260_108860 n1_M8_17340_108860 0.001755
R24027 n1_M8_17340_108860 n1_M8_18420_108860 0.001755
R24028 n1_M8_18420_108860 n1_M8_19500_108860 0.001755
R24029 n1_M8_19500_108860 n1_M8_20580_108860 0.001755
R24030 n1_M8_20580_108860 n1_M8_21660_108860 0.001755
R24031 n1_M8_21660_108860 n1_M8_22740_108860 0.001755
R24032 n1_M8_22740_108860 n1_M8_23820_108860 0.001755
R24033 n1_M8_23820_108860 n1_M8_24900_108860 0.001755
R24034 n1_M8_24900_108860 n1_M8_25980_108860 0.001755
R24035 n1_M8_25980_108860 n1_M8_27060_108860 0.001755
R24036 n1_M8_27060_108860 n1_M8_28140_108860 0.001755
R24037 n1_M8_28140_108860 n1_M8_29220_108860 0.001755
R24038 n1_M8_29220_108860 n1_M8_30300_108860 0.001755
R24039 n1_M8_30300_108860 n1_M8_31380_108860 0.001755
R24040 n1_M8_31380_108860 n1_M8_32460_108860 0.001755
R24041 n1_M8_32460_108860 n1_M8_33540_108860 0.001755
R24042 n1_M8_33540_108860 n1_M8_34620_108860 0.001755
R24043 n1_M8_34620_108860 n1_M8_35700_108860 0.001755
R24044 n1_M8_35700_108860 n1_M8_36780_108860 0.001755
R24045 n1_M8_36780_108860 n1_M8_37860_108860 0.001755
R24046 n1_M8_37860_108860 n1_M8_38940_108860 0.001755
R24047 n1_M8_38940_108860 n1_M8_40020_108860 0.001755
R24048 n1_M8_40020_108860 n1_M8_41100_108860 0.001755
R24049 n1_M8_41100_108860 n1_M8_42180_108860 0.001755
R24050 n1_M8_42180_108860 n1_M8_43260_108860 0.001755
R24051 n1_M8_43260_108860 n1_M8_44340_108860 0.001755
R24052 n1_M8_44340_108860 n1_M8_45420_108860 0.001755
R24053 n1_M8_45420_108860 n1_M8_46500_108860 0.001755
R24054 n1_M8_46500_108860 n1_M8_47580_108860 0.001755
R24055 n1_M8_47580_108860 n1_M8_48660_108860 0.001755
R24056 n1_M8_48660_108860 n1_M8_49740_108860 0.001755
R24057 n1_M8_49740_108860 n1_M8_50820_108860 0.001755
R24058 n1_M8_50820_108860 n1_M8_51900_108860 0.001755
R24059 n1_M8_51900_108860 n1_M8_52980_108860 0.001755
R24060 n1_M8_52980_108860 n1_M8_54060_108860 0.001755
R24061 n1_M8_54060_108860 n1_M8_55140_108860 0.001755
R24062 n1_M8_55140_108860 n1_M8_56220_108860 0.001755
R24063 n1_M8_56220_108860 n1_M8_57300_108860 0.001755
R24064 n1_M8_57300_108860 n1_M8_58380_108860 0.001755
R24065 n1_M8_58380_108860 n1_M8_59460_108860 0.001755
R24066 n1_M8_59460_108860 n1_M8_60540_108860 0.001755
R24067 n1_M8_60540_108860 n1_M8_61620_108860 0.001755
R24068 n1_M8_61620_108860 n1_M8_62700_108860 0.001755
R24069 n1_M8_62700_108860 n1_M8_63780_108860 0.001755
R24070 n1_M8_63780_108860 n1_M8_64860_108860 0.001755
R24071 n1_M8_64860_108860 n1_M8_65940_108860 0.001755
R24072 n1_M8_65940_108860 n1_M8_67020_108860 0.001755
R24073 n1_M8_67020_108860 n1_M8_68100_108860 0.001755
R24074 n1_M8_68100_108860 n1_M8_69180_108860 0.001755
R24075 n1_M8_69180_108860 n1_M8_70260_108860 0.001755
R24076 n1_M8_70260_108860 n1_M8_71340_108860 0.001755
R24077 n1_M8_71340_108860 n1_M8_72420_108860 0.001755
R24078 n1_M8_72420_108860 n1_M8_73500_108860 0.001755
R24079 n1_M8_73500_108860 n1_M8_74580_108860 0.001755
R24080 n1_M8_74580_108860 n1_M8_75660_108860 0.001755
R24081 n1_M8_75660_108860 n1_M8_76740_108860 0.001755
R24082 n1_M8_76740_108860 n1_M8_77820_108860 0.001755
R24083 n1_M8_77820_108860 n1_M8_78900_108860 0.001755
R24084 n1_M8_78900_108860 n1_M8_79980_108860 0.001755
R24085 n1_M8_79980_108860 n1_M8_81060_108860 0.001755
R24086 n1_M8_81060_108860 n1_M8_82140_108860 0.001755
R24087 n1_M8_82140_108860 n1_M8_83220_108860 0.001755
R24088 n1_M8_83220_108860 n1_M8_84300_108860 0.001755
R24089 n1_M8_84300_108860 n1_M8_85380_108860 0.001755
R24090 n1_M8_85380_108860 n1_M8_86460_108860 0.001755
R24091 n1_M8_86460_108860 n1_M8_87540_108860 0.001755
R24092 n1_M8_87540_108860 n1_M8_88620_108860 0.001755
R24093 n1_M8_88620_108860 n1_M8_89700_108860 0.001755
R24094 n1_M8_89700_108860 n1_M8_90780_108860 0.001755
R24095 n1_M8_90780_108860 n1_M8_91860_108860 0.001755
R24096 n1_M8_91860_108860 n1_M8_92940_108860 0.001755
R24097 n1_M8_92940_108860 n1_M8_94020_108860 0.001755
R24098 n1_M8_94020_108860 n1_M8_95100_108860 0.001755
R24099 n1_M8_95100_108860 n1_M8_96180_108860 0.001755
R24100 n1_M8_96180_108860 n1_M8_97260_108860 0.001755
R24101 n1_M8_97260_108860 n1_M8_98340_108860 0.001755
R24102 n1_M8_98340_108860 n1_M8_99420_108860 0.001755
R24103 n1_M8_99420_108860 n1_M8_100500_108860 0.001755
R24104 n1_M8_100500_108860 n1_M8_101580_108860 0.001755
R24105 n1_M8_101580_108860 n1_M8_102660_108860 0.001755
R24106 n1_M8_102660_108860 n1_M8_103740_108860 0.001755
R24107 n1_M8_103740_108860 n1_M8_104820_108860 0.001755
R24108 n1_M8_104820_108860 n1_M8_105900_108860 0.001755
R24109 n1_M8_105900_108860 n1_M8_106980_108860 0.001755
R24110 n1_M8_106980_108860 n1_M8_108060_108860 0.001755
R24111 n1_M8_108060_108860 n1_M8_109140_108860 0.001755
R24112 n1_M8_109140_108860 n1_M8_110220_108860 0.001755
R24113 n1_M8_110220_108860 n1_M8_111300_108860 0.001755
R24114 n1_M8_111300_108860 n1_M8_112380_108860 0.001755
R24115 n1_M8_112380_108860 n1_M8_113460_108860 0.001755
R24116 n1_M8_113460_108860 n1_M8_114540_108860 0.001755
R24117 n1_M8_114540_108860 n1_M8_115620_108860 0.001755
R24118 n1_M8_115620_108860 n1_M8_116700_108860 0.001755
R24119 n1_M8_116700_108860 n1_M8_117780_108860 0.001755
R24120 n1_M8_117780_108860 n1_M8_118860_108860 0.001755
R24121 n1_M8_118860_108860 n1_M8_119940_108860 0.001755
R24122 n1_M8_119940_108860 n1_M8_121020_108860 0.001755
R24123 n1_M8_121020_108860 n1_M8_122100_108860 0.001755
R24124 n1_M8_122100_108860 n1_M8_123180_108860 0.001755
R24125 n1_M8_123180_108860 n1_M8_124260_108860 0.001755
R24126 n1_M8_124260_108860 n1_M8_125340_108860 0.001755
R24127 n1_M8_125340_108860 n1_M8_126420_108860 0.001755
R24128 n1_M8_126420_108860 n1_M8_127500_108860 0.001755
R24129 n1_M8_127500_108860 n1_M8_128580_108860 0.001755
R24130 n1_M8_128580_108860 n1_M8_129660_108860 0.001755
R24131 n1_M8_129660_108860 n1_M8_130740_108860 0.001755
R24132 n1_M8_130740_108860 n1_M8_131820_108860 0.001755
R24133 n1_M8_131820_108860 n1_M8_132900_108860 0.001755
R24134 n1_M8_132900_108860 n1_M8_133980_108860 0.001755
R24135 n1_M8_133980_108860 n1_M8_135060_108860 0.001755
R24136 n1_M8_135060_108860 n1_M8_136140_108860 0.001755
R24137 n1_M8_136140_108860 n1_M8_137220_108860 0.001755
R24138 n1_M8_137220_108860 n1_M8_138300_108860 0.001755
R24139 n1_M8_138300_108860 n1_M8_139380_108860 0.001755
R24140 n1_M8_139380_108860 n1_M8_140460_108860 0.001755
R24141 n1_M8_140460_108860 n1_M8_141540_108860 0.001755
R24142 n1_M8_141540_108860 n1_M8_142620_108860 0.001755
R24143 n1_M8_142620_108860 n1_M8_143700_108860 0.001755
R24144 n1_M8_143700_108860 n1_M8_144780_108860 0.001755
R24145 n1_M8_144780_108860 n1_M8_145860_108860 0.001755
R24146 n1_M8_145860_108860 n1_M8_146940_108860 0.001755
R24147 n1_M8_60_115260 n1_M8_1140_115260 0.001755
R24148 n1_M8_1140_115260 n1_M8_2220_115260 0.001755
R24149 n1_M8_2220_115260 n1_M8_3300_115260 0.001755
R24150 n1_M8_3300_115260 n1_M8_4380_115260 0.001755
R24151 n1_M8_4380_115260 n1_M8_5460_115260 0.001755
R24152 n1_M8_5460_115260 n1_M8_6540_115260 0.001755
R24153 n1_M8_6540_115260 n1_M8_7620_115260 0.001755
R24154 n1_M8_7620_115260 n1_M8_8700_115260 0.001755
R24155 n1_M8_8700_115260 n1_M8_9780_115260 0.001755
R24156 n1_M8_9780_115260 n1_M8_10860_115260 0.001755
R24157 n1_M8_10860_115260 n1_M8_11940_115260 0.001755
R24158 n1_M8_11940_115260 n1_M8_13020_115260 0.001755
R24159 n1_M8_13020_115260 n1_M8_14100_115260 0.001755
R24160 n1_M8_14100_115260 n1_M8_15180_115260 0.001755
R24161 n1_M8_15180_115260 n1_M8_16260_115260 0.001755
R24162 n1_M8_16260_115260 n1_M8_17340_115260 0.001755
R24163 n1_M8_17340_115260 n1_M8_18420_115260 0.001755
R24164 n1_M8_18420_115260 n1_M8_19500_115260 0.001755
R24165 n1_M8_19500_115260 n1_M8_20580_115260 0.001755
R24166 n1_M8_20580_115260 n1_M8_21660_115260 0.001755
R24167 n1_M8_21660_115260 n1_M8_22740_115260 0.001755
R24168 n1_M8_22740_115260 n1_M8_23820_115260 0.001755
R24169 n1_M8_23820_115260 n1_M8_24900_115260 0.001755
R24170 n1_M8_24900_115260 n1_M8_25980_115260 0.001755
R24171 n1_M8_25980_115260 n1_M8_27060_115260 0.001755
R24172 n1_M8_27060_115260 n1_M8_28140_115260 0.001755
R24173 n1_M8_28140_115260 n1_M8_29220_115260 0.001755
R24174 n1_M8_29220_115260 n1_M8_30300_115260 0.001755
R24175 n1_M8_30300_115260 n1_M8_31380_115260 0.001755
R24176 n1_M8_31380_115260 n1_M8_32460_115260 0.001755
R24177 n1_M8_32460_115260 n1_M8_33540_115260 0.001755
R24178 n1_M8_33540_115260 n1_M8_34620_115260 0.001755
R24179 n1_M8_34620_115260 n1_M8_35700_115260 0.001755
R24180 n1_M8_35700_115260 n1_M8_36780_115260 0.001755
R24181 n1_M8_36780_115260 n1_M8_37860_115260 0.001755
R24182 n1_M8_37860_115260 n1_M8_38940_115260 0.001755
R24183 n1_M8_38940_115260 n1_M8_40020_115260 0.001755
R24184 n1_M8_40020_115260 n1_M8_41100_115260 0.001755
R24185 n1_M8_41100_115260 n1_M8_42180_115260 0.001755
R24186 n1_M8_42180_115260 n1_M8_43260_115260 0.001755
R24187 n1_M8_43260_115260 n1_M8_44340_115260 0.001755
R24188 n1_M8_44340_115260 n1_M8_45420_115260 0.001755
R24189 n1_M8_45420_115260 n1_M8_46500_115260 0.001755
R24190 n1_M8_46500_115260 n1_M8_47580_115260 0.001755
R24191 n1_M8_47580_115260 n1_M8_48660_115260 0.001755
R24192 n1_M8_48660_115260 n1_M8_49740_115260 0.001755
R24193 n1_M8_49740_115260 n1_M8_50820_115260 0.001755
R24194 n1_M8_50820_115260 n1_M8_51900_115260 0.001755
R24195 n1_M8_51900_115260 n1_M8_52980_115260 0.001755
R24196 n1_M8_52980_115260 n1_M8_54060_115260 0.001755
R24197 n1_M8_54060_115260 n1_M8_55140_115260 0.001755
R24198 n1_M8_55140_115260 n1_M8_56220_115260 0.001755
R24199 n1_M8_56220_115260 n1_M8_57300_115260 0.001755
R24200 n1_M8_57300_115260 n1_M8_58380_115260 0.001755
R24201 n1_M8_58380_115260 n1_M8_59460_115260 0.001755
R24202 n1_M8_59460_115260 n1_M8_60540_115260 0.001755
R24203 n1_M8_60540_115260 n1_M8_61620_115260 0.001755
R24204 n1_M8_61620_115260 n1_M8_62700_115260 0.001755
R24205 n1_M8_62700_115260 n1_M8_63780_115260 0.001755
R24206 n1_M8_63780_115260 n1_M8_64860_115260 0.001755
R24207 n1_M8_64860_115260 n1_M8_65940_115260 0.001755
R24208 n1_M8_65940_115260 n1_M8_67020_115260 0.001755
R24209 n1_M8_67020_115260 n1_M8_68100_115260 0.001755
R24210 n1_M8_68100_115260 n1_M8_69180_115260 0.001755
R24211 n1_M8_69180_115260 n1_M8_70260_115260 0.001755
R24212 n1_M8_70260_115260 n1_M8_71340_115260 0.001755
R24213 n1_M8_71340_115260 n1_M8_72420_115260 0.001755
R24214 n1_M8_72420_115260 n1_M8_73500_115260 0.001755
R24215 n1_M8_73500_115260 n1_M8_74580_115260 0.001755
R24216 n1_M8_74580_115260 n1_M8_75660_115260 0.001755
R24217 n1_M8_75660_115260 n1_M8_76740_115260 0.001755
R24218 n1_M8_76740_115260 n1_M8_77820_115260 0.001755
R24219 n1_M8_77820_115260 n1_M8_78900_115260 0.001755
R24220 n1_M8_78900_115260 n1_M8_79980_115260 0.001755
R24221 n1_M8_79980_115260 n1_M8_81060_115260 0.001755
R24222 n1_M8_81060_115260 n1_M8_82140_115260 0.001755
R24223 n1_M8_82140_115260 n1_M8_83220_115260 0.001755
R24224 n1_M8_83220_115260 n1_M8_84300_115260 0.001755
R24225 n1_M8_84300_115260 n1_M8_85380_115260 0.001755
R24226 n1_M8_85380_115260 n1_M8_86460_115260 0.001755
R24227 n1_M8_86460_115260 n1_M8_87540_115260 0.001755
R24228 n1_M8_87540_115260 n1_M8_88620_115260 0.001755
R24229 n1_M8_88620_115260 n1_M8_89700_115260 0.001755
R24230 n1_M8_89700_115260 n1_M8_90780_115260 0.001755
R24231 n1_M8_90780_115260 n1_M8_91860_115260 0.001755
R24232 n1_M8_91860_115260 n1_M8_92940_115260 0.001755
R24233 n1_M8_92940_115260 n1_M8_94020_115260 0.001755
R24234 n1_M8_94020_115260 n1_M8_95100_115260 0.001755
R24235 n1_M8_95100_115260 n1_M8_96180_115260 0.001755
R24236 n1_M8_96180_115260 n1_M8_97260_115260 0.001755
R24237 n1_M8_97260_115260 n1_M8_98340_115260 0.001755
R24238 n1_M8_98340_115260 n1_M8_99420_115260 0.001755
R24239 n1_M8_99420_115260 n1_M8_100500_115260 0.001755
R24240 n1_M8_100500_115260 n1_M8_101580_115260 0.001755
R24241 n1_M8_101580_115260 n1_M8_102660_115260 0.001755
R24242 n1_M8_102660_115260 n1_M8_103740_115260 0.001755
R24243 n1_M8_103740_115260 n1_M8_104820_115260 0.001755
R24244 n1_M8_104820_115260 n1_M8_105900_115260 0.001755
R24245 n1_M8_105900_115260 n1_M8_106980_115260 0.001755
R24246 n1_M8_106980_115260 n1_M8_108060_115260 0.001755
R24247 n1_M8_108060_115260 n1_M8_109140_115260 0.001755
R24248 n1_M8_109140_115260 n1_M8_110220_115260 0.001755
R24249 n1_M8_110220_115260 n1_M8_111300_115260 0.001755
R24250 n1_M8_111300_115260 n1_M8_112380_115260 0.001755
R24251 n1_M8_112380_115260 n1_M8_113460_115260 0.001755
R24252 n1_M8_113460_115260 n1_M8_114540_115260 0.001755
R24253 n1_M8_114540_115260 n1_M8_115620_115260 0.001755
R24254 n1_M8_115620_115260 n1_M8_116700_115260 0.001755
R24255 n1_M8_116700_115260 n1_M8_117780_115260 0.001755
R24256 n1_M8_117780_115260 n1_M8_118860_115260 0.001755
R24257 n1_M8_118860_115260 n1_M8_119940_115260 0.001755
R24258 n1_M8_119940_115260 n1_M8_121020_115260 0.001755
R24259 n1_M8_121020_115260 n1_M8_122100_115260 0.001755
R24260 n1_M8_122100_115260 n1_M8_123180_115260 0.001755
R24261 n1_M8_123180_115260 n1_M8_124260_115260 0.001755
R24262 n1_M8_124260_115260 n1_M8_125340_115260 0.001755
R24263 n1_M8_125340_115260 n1_M8_126420_115260 0.001755
R24264 n1_M8_126420_115260 n1_M8_127500_115260 0.001755
R24265 n1_M8_127500_115260 n1_M8_128580_115260 0.001755
R24266 n1_M8_128580_115260 n1_M8_129660_115260 0.001755
R24267 n1_M8_129660_115260 n1_M8_130740_115260 0.001755
R24268 n1_M8_130740_115260 n1_M8_131820_115260 0.001755
R24269 n1_M8_131820_115260 n1_M8_132900_115260 0.001755
R24270 n1_M8_132900_115260 n1_M8_133980_115260 0.001755
R24271 n1_M8_133980_115260 n1_M8_135060_115260 0.001755
R24272 n1_M8_135060_115260 n1_M8_136140_115260 0.001755
R24273 n1_M8_136140_115260 n1_M8_137220_115260 0.001755
R24274 n1_M8_137220_115260 n1_M8_138300_115260 0.001755
R24275 n1_M8_138300_115260 n1_M8_139380_115260 0.001755
R24276 n1_M8_139380_115260 n1_M8_140460_115260 0.001755
R24277 n1_M8_140460_115260 n1_M8_141540_115260 0.001755
R24278 n1_M8_141540_115260 n1_M8_142620_115260 0.001755
R24279 n1_M8_142620_115260 n1_M8_143700_115260 0.001755
R24280 n1_M8_143700_115260 n1_M8_144780_115260 0.001755
R24281 n1_M8_144780_115260 n1_M8_145860_115260 0.001755
R24282 n1_M8_145860_115260 n1_M8_146940_115260 0.001755
R24283 n1_M8_60_121660 n1_M8_1140_121660 0.001755
R24284 n1_M8_1140_121660 n1_M8_2220_121660 0.001755
R24285 n1_M8_2220_121660 n1_M8_3300_121660 0.001755
R24286 n1_M8_3300_121660 n1_M8_4380_121660 0.001755
R24287 n1_M8_4380_121660 n1_M8_5460_121660 0.001755
R24288 n1_M8_5460_121660 n1_M8_6540_121660 0.001755
R24289 n1_M8_6540_121660 n1_M8_7620_121660 0.001755
R24290 n1_M8_7620_121660 n1_M8_8700_121660 0.001755
R24291 n1_M8_8700_121660 n1_M8_9780_121660 0.001755
R24292 n1_M8_9780_121660 n1_M8_10860_121660 0.001755
R24293 n1_M8_10860_121660 n1_M8_11940_121660 0.001755
R24294 n1_M8_11940_121660 n1_M8_13020_121660 0.001755
R24295 n1_M8_13020_121660 n1_M8_14100_121660 0.001755
R24296 n1_M8_14100_121660 n1_M8_15180_121660 0.001755
R24297 n1_M8_15180_121660 n1_M8_16260_121660 0.001755
R24298 n1_M8_16260_121660 n1_M8_17340_121660 0.001755
R24299 n1_M8_17340_121660 n1_M8_18420_121660 0.001755
R24300 n1_M8_18420_121660 n1_M8_19500_121660 0.001755
R24301 n1_M8_19500_121660 n1_M8_20580_121660 0.001755
R24302 n1_M8_20580_121660 n1_M8_21660_121660 0.001755
R24303 n1_M8_21660_121660 n1_M8_22740_121660 0.001755
R24304 n1_M8_22740_121660 n1_M8_23820_121660 0.001755
R24305 n1_M8_23820_121660 n1_M8_24900_121660 0.001755
R24306 n1_M8_24900_121660 n1_M8_25980_121660 0.001755
R24307 n1_M8_25980_121660 n1_M8_27060_121660 0.001755
R24308 n1_M8_27060_121660 n1_M8_28140_121660 0.001755
R24309 n1_M8_28140_121660 n1_M8_29220_121660 0.001755
R24310 n1_M8_29220_121660 n1_M8_30300_121660 0.001755
R24311 n1_M8_30300_121660 n1_M8_31380_121660 0.001755
R24312 n1_M8_31380_121660 n1_M8_32460_121660 0.001755
R24313 n1_M8_32460_121660 n1_M8_33540_121660 0.001755
R24314 n1_M8_33540_121660 n1_M8_34620_121660 0.001755
R24315 n1_M8_34620_121660 n1_M8_35700_121660 0.001755
R24316 n1_M8_35700_121660 n1_M8_36780_121660 0.001755
R24317 n1_M8_36780_121660 n1_M8_37860_121660 0.001755
R24318 n1_M8_37860_121660 n1_M8_38940_121660 0.001755
R24319 n1_M8_38940_121660 n1_M8_40020_121660 0.001755
R24320 n1_M8_40020_121660 n1_M8_41100_121660 0.001755
R24321 n1_M8_41100_121660 n1_M8_42180_121660 0.001755
R24322 n1_M8_42180_121660 n1_M8_43260_121660 0.001755
R24323 n1_M8_43260_121660 n1_M8_44340_121660 0.001755
R24324 n1_M8_44340_121660 n1_M8_45420_121660 0.001755
R24325 n1_M8_45420_121660 n1_M8_46500_121660 0.001755
R24326 n1_M8_46500_121660 n1_M8_47580_121660 0.001755
R24327 n1_M8_47580_121660 n1_M8_48660_121660 0.001755
R24328 n1_M8_48660_121660 n1_M8_49740_121660 0.001755
R24329 n1_M8_49740_121660 n1_M8_50820_121660 0.001755
R24330 n1_M8_50820_121660 n1_M8_51900_121660 0.001755
R24331 n1_M8_51900_121660 n1_M8_52980_121660 0.001755
R24332 n1_M8_52980_121660 n1_M8_54060_121660 0.001755
R24333 n1_M8_54060_121660 n1_M8_55140_121660 0.001755
R24334 n1_M8_55140_121660 n1_M8_56220_121660 0.001755
R24335 n1_M8_56220_121660 n1_M8_57300_121660 0.001755
R24336 n1_M8_57300_121660 n1_M8_58380_121660 0.001755
R24337 n1_M8_58380_121660 n1_M8_59460_121660 0.001755
R24338 n1_M8_59460_121660 n1_M8_60540_121660 0.001755
R24339 n1_M8_60540_121660 n1_M8_61620_121660 0.001755
R24340 n1_M8_61620_121660 n1_M8_62700_121660 0.001755
R24341 n1_M8_62700_121660 n1_M8_63780_121660 0.001755
R24342 n1_M8_63780_121660 n1_M8_64860_121660 0.001755
R24343 n1_M8_64860_121660 n1_M8_65940_121660 0.001755
R24344 n1_M8_65940_121660 n1_M8_67020_121660 0.001755
R24345 n1_M8_67020_121660 n1_M8_68100_121660 0.001755
R24346 n1_M8_68100_121660 n1_M8_69180_121660 0.001755
R24347 n1_M8_69180_121660 n1_M8_70260_121660 0.001755
R24348 n1_M8_70260_121660 n1_M8_71340_121660 0.001755
R24349 n1_M8_71340_121660 n1_M8_72420_121660 0.001755
R24350 n1_M8_72420_121660 n1_M8_73500_121660 0.001755
R24351 n1_M8_73500_121660 n1_M8_74580_121660 0.001755
R24352 n1_M8_74580_121660 n1_M8_75660_121660 0.001755
R24353 n1_M8_75660_121660 n1_M8_76740_121660 0.001755
R24354 n1_M8_76740_121660 n1_M8_77820_121660 0.001755
R24355 n1_M8_77820_121660 n1_M8_78900_121660 0.001755
R24356 n1_M8_78900_121660 n1_M8_79980_121660 0.001755
R24357 n1_M8_79980_121660 n1_M8_81060_121660 0.001755
R24358 n1_M8_81060_121660 n1_M8_82140_121660 0.001755
R24359 n1_M8_82140_121660 n1_M8_83220_121660 0.001755
R24360 n1_M8_83220_121660 n1_M8_84300_121660 0.001755
R24361 n1_M8_84300_121660 n1_M8_85380_121660 0.001755
R24362 n1_M8_85380_121660 n1_M8_86460_121660 0.001755
R24363 n1_M8_86460_121660 n1_M8_87540_121660 0.001755
R24364 n1_M8_87540_121660 n1_M8_88620_121660 0.001755
R24365 n1_M8_88620_121660 n1_M8_89700_121660 0.001755
R24366 n1_M8_89700_121660 n1_M8_90780_121660 0.001755
R24367 n1_M8_90780_121660 n1_M8_91860_121660 0.001755
R24368 n1_M8_91860_121660 n1_M8_92940_121660 0.001755
R24369 n1_M8_92940_121660 n1_M8_94020_121660 0.001755
R24370 n1_M8_94020_121660 n1_M8_95100_121660 0.001755
R24371 n1_M8_95100_121660 n1_M8_96180_121660 0.001755
R24372 n1_M8_96180_121660 n1_M8_97260_121660 0.001755
R24373 n1_M8_97260_121660 n1_M8_98340_121660 0.001755
R24374 n1_M8_98340_121660 n1_M8_99420_121660 0.001755
R24375 n1_M8_99420_121660 n1_M8_100500_121660 0.001755
R24376 n1_M8_100500_121660 n1_M8_101580_121660 0.001755
R24377 n1_M8_101580_121660 n1_M8_102660_121660 0.001755
R24378 n1_M8_102660_121660 n1_M8_103740_121660 0.001755
R24379 n1_M8_103740_121660 n1_M8_104820_121660 0.001755
R24380 n1_M8_104820_121660 n1_M8_105900_121660 0.001755
R24381 n1_M8_105900_121660 n1_M8_106980_121660 0.001755
R24382 n1_M8_106980_121660 n1_M8_108060_121660 0.001755
R24383 n1_M8_108060_121660 n1_M8_109140_121660 0.001755
R24384 n1_M8_109140_121660 n1_M8_110220_121660 0.001755
R24385 n1_M8_110220_121660 n1_M8_111300_121660 0.001755
R24386 n1_M8_111300_121660 n1_M8_112380_121660 0.001755
R24387 n1_M8_112380_121660 n1_M8_113460_121660 0.001755
R24388 n1_M8_113460_121660 n1_M8_114540_121660 0.001755
R24389 n1_M8_114540_121660 n1_M8_115620_121660 0.001755
R24390 n1_M8_115620_121660 n1_M8_116700_121660 0.001755
R24391 n1_M8_116700_121660 n1_M8_117780_121660 0.001755
R24392 n1_M8_117780_121660 n1_M8_118860_121660 0.001755
R24393 n1_M8_118860_121660 n1_M8_119940_121660 0.001755
R24394 n1_M8_119940_121660 n1_M8_121020_121660 0.001755
R24395 n1_M8_121020_121660 n1_M8_122100_121660 0.001755
R24396 n1_M8_122100_121660 n1_M8_123180_121660 0.001755
R24397 n1_M8_123180_121660 n1_M8_124260_121660 0.001755
R24398 n1_M8_124260_121660 n1_M8_125340_121660 0.001755
R24399 n1_M8_125340_121660 n1_M8_126420_121660 0.001755
R24400 n1_M8_126420_121660 n1_M8_127500_121660 0.001755
R24401 n1_M8_127500_121660 n1_M8_128580_121660 0.001755
R24402 n1_M8_128580_121660 n1_M8_129660_121660 0.001755
R24403 n1_M8_129660_121660 n1_M8_130740_121660 0.001755
R24404 n1_M8_130740_121660 n1_M8_131820_121660 0.001755
R24405 n1_M8_131820_121660 n1_M8_132900_121660 0.001755
R24406 n1_M8_132900_121660 n1_M8_133980_121660 0.001755
R24407 n1_M8_133980_121660 n1_M8_135060_121660 0.001755
R24408 n1_M8_135060_121660 n1_M8_136140_121660 0.001755
R24409 n1_M8_136140_121660 n1_M8_137220_121660 0.001755
R24410 n1_M8_137220_121660 n1_M8_138300_121660 0.001755
R24411 n1_M8_138300_121660 n1_M8_139380_121660 0.001755
R24412 n1_M8_139380_121660 n1_M8_140460_121660 0.001755
R24413 n1_M8_140460_121660 n1_M8_141540_121660 0.001755
R24414 n1_M8_141540_121660 n1_M8_142620_121660 0.001755
R24415 n1_M8_142620_121660 n1_M8_143700_121660 0.001755
R24416 n1_M8_143700_121660 n1_M8_144780_121660 0.001755
R24417 n1_M8_144780_121660 n1_M8_145860_121660 0.001755
R24418 n1_M8_145860_121660 n1_M8_146940_121660 0.001755
R24419 n1_M8_60_128060 n1_M8_1140_128060 0.001755
R24420 n1_M8_1140_128060 n1_M8_2220_128060 0.001755
R24421 n1_M8_2220_128060 n1_M8_3300_128060 0.001755
R24422 n1_M8_3300_128060 n1_M8_4380_128060 0.001755
R24423 n1_M8_4380_128060 n1_M8_5460_128060 0.001755
R24424 n1_M8_5460_128060 n1_M8_6540_128060 0.001755
R24425 n1_M8_6540_128060 n1_M8_7620_128060 0.001755
R24426 n1_M8_7620_128060 n1_M8_8700_128060 0.001755
R24427 n1_M8_8700_128060 n1_M8_9780_128060 0.001755
R24428 n1_M8_9780_128060 n1_M8_10860_128060 0.001755
R24429 n1_M8_10860_128060 n1_M8_11940_128060 0.001755
R24430 n1_M8_11940_128060 n1_M8_13020_128060 0.001755
R24431 n1_M8_13020_128060 n1_M8_14100_128060 0.001755
R24432 n1_M8_14100_128060 n1_M8_15180_128060 0.001755
R24433 n1_M8_15180_128060 n1_M8_16260_128060 0.001755
R24434 n1_M8_16260_128060 n1_M8_17340_128060 0.001755
R24435 n1_M8_17340_128060 n1_M8_18420_128060 0.001755
R24436 n1_M8_18420_128060 n1_M8_19500_128060 0.001755
R24437 n1_M8_19500_128060 n1_M8_20580_128060 0.001755
R24438 n1_M8_20580_128060 n1_M8_21660_128060 0.001755
R24439 n1_M8_21660_128060 n1_M8_22740_128060 0.001755
R24440 n1_M8_22740_128060 n1_M8_23820_128060 0.001755
R24441 n1_M8_23820_128060 n1_M8_24900_128060 0.001755
R24442 n1_M8_24900_128060 n1_M8_25980_128060 0.001755
R24443 n1_M8_25980_128060 n1_M8_27060_128060 0.001755
R24444 n1_M8_27060_128060 n1_M8_28140_128060 0.001755
R24445 n1_M8_28140_128060 n1_M8_29220_128060 0.001755
R24446 n1_M8_29220_128060 n1_M8_30300_128060 0.001755
R24447 n1_M8_30300_128060 n1_M8_31380_128060 0.001755
R24448 n1_M8_31380_128060 n1_M8_32460_128060 0.001755
R24449 n1_M8_32460_128060 n1_M8_33540_128060 0.001755
R24450 n1_M8_33540_128060 n1_M8_34620_128060 0.001755
R24451 n1_M8_34620_128060 n1_M8_35700_128060 0.001755
R24452 n1_M8_35700_128060 n1_M8_36780_128060 0.001755
R24453 n1_M8_36780_128060 n1_M8_37860_128060 0.001755
R24454 n1_M8_37860_128060 n1_M8_38940_128060 0.001755
R24455 n1_M8_38940_128060 n1_M8_40020_128060 0.001755
R24456 n1_M8_40020_128060 n1_M8_41100_128060 0.001755
R24457 n1_M8_41100_128060 n1_M8_42180_128060 0.001755
R24458 n1_M8_42180_128060 n1_M8_43260_128060 0.001755
R24459 n1_M8_43260_128060 n1_M8_44340_128060 0.001755
R24460 n1_M8_44340_128060 n1_M8_45420_128060 0.001755
R24461 n1_M8_45420_128060 n1_M8_46500_128060 0.001755
R24462 n1_M8_46500_128060 n1_M8_47580_128060 0.001755
R24463 n1_M8_47580_128060 n1_M8_48660_128060 0.001755
R24464 n1_M8_48660_128060 n1_M8_49740_128060 0.001755
R24465 n1_M8_49740_128060 n1_M8_50820_128060 0.001755
R24466 n1_M8_50820_128060 n1_M8_51900_128060 0.001755
R24467 n1_M8_51900_128060 n1_M8_52980_128060 0.001755
R24468 n1_M8_52980_128060 n1_M8_54060_128060 0.001755
R24469 n1_M8_54060_128060 n1_M8_55140_128060 0.001755
R24470 n1_M8_55140_128060 n1_M8_56220_128060 0.001755
R24471 n1_M8_56220_128060 n1_M8_57300_128060 0.001755
R24472 n1_M8_57300_128060 n1_M8_58380_128060 0.001755
R24473 n1_M8_58380_128060 n1_M8_59460_128060 0.001755
R24474 n1_M8_59460_128060 n1_M8_60540_128060 0.001755
R24475 n1_M8_60540_128060 n1_M8_61620_128060 0.001755
R24476 n1_M8_61620_128060 n1_M8_62700_128060 0.001755
R24477 n1_M8_62700_128060 n1_M8_63780_128060 0.001755
R24478 n1_M8_63780_128060 n1_M8_64860_128060 0.001755
R24479 n1_M8_64860_128060 n1_M8_65940_128060 0.001755
R24480 n1_M8_65940_128060 n1_M8_67020_128060 0.001755
R24481 n1_M8_67020_128060 n1_M8_68100_128060 0.001755
R24482 n1_M8_68100_128060 n1_M8_69180_128060 0.001755
R24483 n1_M8_69180_128060 n1_M8_70260_128060 0.001755
R24484 n1_M8_70260_128060 n1_M8_71340_128060 0.001755
R24485 n1_M8_71340_128060 n1_M8_72420_128060 0.001755
R24486 n1_M8_72420_128060 n1_M8_73500_128060 0.001755
R24487 n1_M8_73500_128060 n1_M8_74580_128060 0.001755
R24488 n1_M8_74580_128060 n1_M8_75660_128060 0.001755
R24489 n1_M8_75660_128060 n1_M8_76740_128060 0.001755
R24490 n1_M8_76740_128060 n1_M8_77820_128060 0.001755
R24491 n1_M8_77820_128060 n1_M8_78900_128060 0.001755
R24492 n1_M8_78900_128060 n1_M8_79980_128060 0.001755
R24493 n1_M8_79980_128060 n1_M8_81060_128060 0.001755
R24494 n1_M8_81060_128060 n1_M8_82140_128060 0.001755
R24495 n1_M8_82140_128060 n1_M8_83220_128060 0.001755
R24496 n1_M8_83220_128060 n1_M8_84300_128060 0.001755
R24497 n1_M8_84300_128060 n1_M8_85380_128060 0.001755
R24498 n1_M8_85380_128060 n1_M8_86460_128060 0.001755
R24499 n1_M8_86460_128060 n1_M8_87540_128060 0.001755
R24500 n1_M8_87540_128060 n1_M8_88620_128060 0.001755
R24501 n1_M8_88620_128060 n1_M8_89700_128060 0.001755
R24502 n1_M8_89700_128060 n1_M8_90780_128060 0.001755
R24503 n1_M8_90780_128060 n1_M8_91860_128060 0.001755
R24504 n1_M8_91860_128060 n1_M8_92940_128060 0.001755
R24505 n1_M8_92940_128060 n1_M8_94020_128060 0.001755
R24506 n1_M8_94020_128060 n1_M8_95100_128060 0.001755
R24507 n1_M8_95100_128060 n1_M8_96180_128060 0.001755
R24508 n1_M8_96180_128060 n1_M8_97260_128060 0.001755
R24509 n1_M8_97260_128060 n1_M8_98340_128060 0.001755
R24510 n1_M8_98340_128060 n1_M8_99420_128060 0.001755
R24511 n1_M8_99420_128060 n1_M8_100500_128060 0.001755
R24512 n1_M8_100500_128060 n1_M8_101580_128060 0.001755
R24513 n1_M8_101580_128060 n1_M8_102660_128060 0.001755
R24514 n1_M8_102660_128060 n1_M8_103740_128060 0.001755
R24515 n1_M8_103740_128060 n1_M8_104820_128060 0.001755
R24516 n1_M8_104820_128060 n1_M8_105900_128060 0.001755
R24517 n1_M8_105900_128060 n1_M8_106980_128060 0.001755
R24518 n1_M8_106980_128060 n1_M8_108060_128060 0.001755
R24519 n1_M8_108060_128060 n1_M8_109140_128060 0.001755
R24520 n1_M8_109140_128060 n1_M8_110220_128060 0.001755
R24521 n1_M8_110220_128060 n1_M8_111300_128060 0.001755
R24522 n1_M8_111300_128060 n1_M8_112380_128060 0.001755
R24523 n1_M8_112380_128060 n1_M8_113460_128060 0.001755
R24524 n1_M8_113460_128060 n1_M8_114540_128060 0.001755
R24525 n1_M8_114540_128060 n1_M8_115620_128060 0.001755
R24526 n1_M8_115620_128060 n1_M8_116700_128060 0.001755
R24527 n1_M8_116700_128060 n1_M8_117780_128060 0.001755
R24528 n1_M8_117780_128060 n1_M8_118860_128060 0.001755
R24529 n1_M8_118860_128060 n1_M8_119940_128060 0.001755
R24530 n1_M8_119940_128060 n1_M8_121020_128060 0.001755
R24531 n1_M8_121020_128060 n1_M8_122100_128060 0.001755
R24532 n1_M8_122100_128060 n1_M8_123180_128060 0.001755
R24533 n1_M8_123180_128060 n1_M8_124260_128060 0.001755
R24534 n1_M8_124260_128060 n1_M8_125340_128060 0.001755
R24535 n1_M8_125340_128060 n1_M8_126420_128060 0.001755
R24536 n1_M8_126420_128060 n1_M8_127500_128060 0.001755
R24537 n1_M8_127500_128060 n1_M8_128580_128060 0.001755
R24538 n1_M8_128580_128060 n1_M8_129660_128060 0.001755
R24539 n1_M8_129660_128060 n1_M8_130740_128060 0.001755
R24540 n1_M8_130740_128060 n1_M8_131820_128060 0.001755
R24541 n1_M8_131820_128060 n1_M8_132900_128060 0.001755
R24542 n1_M8_132900_128060 n1_M8_133980_128060 0.001755
R24543 n1_M8_133980_128060 n1_M8_135060_128060 0.001755
R24544 n1_M8_135060_128060 n1_M8_136140_128060 0.001755
R24545 n1_M8_136140_128060 n1_M8_137220_128060 0.001755
R24546 n1_M8_137220_128060 n1_M8_138300_128060 0.001755
R24547 n1_M8_138300_128060 n1_M8_139380_128060 0.001755
R24548 n1_M8_139380_128060 n1_M8_140460_128060 0.001755
R24549 n1_M8_140460_128060 n1_M8_141540_128060 0.001755
R24550 n1_M8_141540_128060 n1_M8_142620_128060 0.001755
R24551 n1_M8_142620_128060 n1_M8_143700_128060 0.001755
R24552 n1_M8_143700_128060 n1_M8_144780_128060 0.001755
R24553 n1_M8_144780_128060 n1_M8_145860_128060 0.001755
R24554 n1_M8_145860_128060 n1_M8_146940_128060 0.001755
R24555 n1_M8_60_134460 n1_M8_1140_134460 0.001755
R24556 n1_M8_1140_134460 n1_M8_2220_134460 0.001755
R24557 n1_M8_2220_134460 n1_M8_3300_134460 0.001755
R24558 n1_M8_3300_134460 n1_M8_4380_134460 0.001755
R24559 n1_M8_4380_134460 n1_M8_5460_134460 0.001755
R24560 n1_M8_5460_134460 n1_M8_6540_134460 0.001755
R24561 n1_M8_6540_134460 n1_M8_7620_134460 0.001755
R24562 n1_M8_7620_134460 n1_M8_8700_134460 0.001755
R24563 n1_M8_8700_134460 n1_M8_9780_134460 0.001755
R24564 n1_M8_9780_134460 n1_M8_10860_134460 0.001755
R24565 n1_M8_10860_134460 n1_M8_11940_134460 0.001755
R24566 n1_M8_11940_134460 n1_M8_13020_134460 0.001755
R24567 n1_M8_13020_134460 n1_M8_14100_134460 0.001755
R24568 n1_M8_14100_134460 n1_M8_15180_134460 0.001755
R24569 n1_M8_15180_134460 n1_M8_16260_134460 0.001755
R24570 n1_M8_16260_134460 n1_M8_17340_134460 0.001755
R24571 n1_M8_17340_134460 n1_M8_18420_134460 0.001755
R24572 n1_M8_18420_134460 n1_M8_19500_134460 0.001755
R24573 n1_M8_19500_134460 n1_M8_20580_134460 0.001755
R24574 n1_M8_20580_134460 n1_M8_21660_134460 0.001755
R24575 n1_M8_21660_134460 n1_M8_22740_134460 0.001755
R24576 n1_M8_22740_134460 n1_M8_23820_134460 0.001755
R24577 n1_M8_23820_134460 n1_M8_24900_134460 0.001755
R24578 n1_M8_24900_134460 n1_M8_25980_134460 0.001755
R24579 n1_M8_25980_134460 n1_M8_27060_134460 0.001755
R24580 n1_M8_27060_134460 n1_M8_28140_134460 0.001755
R24581 n1_M8_28140_134460 n1_M8_29220_134460 0.001755
R24582 n1_M8_29220_134460 n1_M8_30300_134460 0.001755
R24583 n1_M8_30300_134460 n1_M8_31380_134460 0.001755
R24584 n1_M8_31380_134460 n1_M8_32460_134460 0.001755
R24585 n1_M8_32460_134460 n1_M8_33540_134460 0.001755
R24586 n1_M8_33540_134460 n1_M8_34620_134460 0.001755
R24587 n1_M8_34620_134460 n1_M8_35700_134460 0.001755
R24588 n1_M8_35700_134460 n1_M8_36780_134460 0.001755
R24589 n1_M8_36780_134460 n1_M8_37860_134460 0.001755
R24590 n1_M8_37860_134460 n1_M8_38940_134460 0.001755
R24591 n1_M8_38940_134460 n1_M8_40020_134460 0.001755
R24592 n1_M8_40020_134460 n1_M8_41100_134460 0.001755
R24593 n1_M8_41100_134460 n1_M8_42180_134460 0.001755
R24594 n1_M8_42180_134460 n1_M8_43260_134460 0.001755
R24595 n1_M8_43260_134460 n1_M8_44340_134460 0.001755
R24596 n1_M8_44340_134460 n1_M8_45420_134460 0.001755
R24597 n1_M8_45420_134460 n1_M8_46500_134460 0.001755
R24598 n1_M8_46500_134460 n1_M8_47580_134460 0.001755
R24599 n1_M8_47580_134460 n1_M8_48660_134460 0.001755
R24600 n1_M8_48660_134460 n1_M8_49740_134460 0.001755
R24601 n1_M8_49740_134460 n1_M8_50820_134460 0.001755
R24602 n1_M8_50820_134460 n1_M8_51900_134460 0.001755
R24603 n1_M8_51900_134460 n1_M8_52980_134460 0.001755
R24604 n1_M8_52980_134460 n1_M8_54060_134460 0.001755
R24605 n1_M8_54060_134460 n1_M8_55140_134460 0.001755
R24606 n1_M8_55140_134460 n1_M8_56220_134460 0.001755
R24607 n1_M8_56220_134460 n1_M8_57300_134460 0.001755
R24608 n1_M8_57300_134460 n1_M8_58380_134460 0.001755
R24609 n1_M8_58380_134460 n1_M8_59460_134460 0.001755
R24610 n1_M8_59460_134460 n1_M8_60540_134460 0.001755
R24611 n1_M8_60540_134460 n1_M8_61620_134460 0.001755
R24612 n1_M8_61620_134460 n1_M8_62700_134460 0.001755
R24613 n1_M8_62700_134460 n1_M8_63780_134460 0.001755
R24614 n1_M8_63780_134460 n1_M8_64860_134460 0.001755
R24615 n1_M8_64860_134460 n1_M8_65940_134460 0.001755
R24616 n1_M8_65940_134460 n1_M8_67020_134460 0.001755
R24617 n1_M8_67020_134460 n1_M8_68100_134460 0.001755
R24618 n1_M8_68100_134460 n1_M8_69180_134460 0.001755
R24619 n1_M8_69180_134460 n1_M8_70260_134460 0.001755
R24620 n1_M8_70260_134460 n1_M8_71340_134460 0.001755
R24621 n1_M8_71340_134460 n1_M8_72420_134460 0.001755
R24622 n1_M8_72420_134460 n1_M8_73500_134460 0.001755
R24623 n1_M8_73500_134460 n1_M8_74580_134460 0.001755
R24624 n1_M8_74580_134460 n1_M8_75660_134460 0.001755
R24625 n1_M8_75660_134460 n1_M8_76740_134460 0.001755
R24626 n1_M8_76740_134460 n1_M8_77820_134460 0.001755
R24627 n1_M8_77820_134460 n1_M8_78900_134460 0.001755
R24628 n1_M8_78900_134460 n1_M8_79980_134460 0.001755
R24629 n1_M8_79980_134460 n1_M8_81060_134460 0.001755
R24630 n1_M8_81060_134460 n1_M8_82140_134460 0.001755
R24631 n1_M8_82140_134460 n1_M8_83220_134460 0.001755
R24632 n1_M8_83220_134460 n1_M8_84300_134460 0.001755
R24633 n1_M8_84300_134460 n1_M8_85380_134460 0.001755
R24634 n1_M8_85380_134460 n1_M8_86460_134460 0.001755
R24635 n1_M8_86460_134460 n1_M8_87540_134460 0.001755
R24636 n1_M8_87540_134460 n1_M8_88620_134460 0.001755
R24637 n1_M8_88620_134460 n1_M8_89700_134460 0.001755
R24638 n1_M8_89700_134460 n1_M8_90780_134460 0.001755
R24639 n1_M8_90780_134460 n1_M8_91860_134460 0.001755
R24640 n1_M8_91860_134460 n1_M8_92940_134460 0.001755
R24641 n1_M8_92940_134460 n1_M8_94020_134460 0.001755
R24642 n1_M8_94020_134460 n1_M8_95100_134460 0.001755
R24643 n1_M8_95100_134460 n1_M8_96180_134460 0.001755
R24644 n1_M8_96180_134460 n1_M8_97260_134460 0.001755
R24645 n1_M8_97260_134460 n1_M8_98340_134460 0.001755
R24646 n1_M8_98340_134460 n1_M8_99420_134460 0.001755
R24647 n1_M8_99420_134460 n1_M8_100500_134460 0.001755
R24648 n1_M8_100500_134460 n1_M8_101580_134460 0.001755
R24649 n1_M8_101580_134460 n1_M8_102660_134460 0.001755
R24650 n1_M8_102660_134460 n1_M8_103740_134460 0.001755
R24651 n1_M8_103740_134460 n1_M8_104820_134460 0.001755
R24652 n1_M8_104820_134460 n1_M8_105900_134460 0.001755
R24653 n1_M8_105900_134460 n1_M8_106980_134460 0.001755
R24654 n1_M8_106980_134460 n1_M8_108060_134460 0.001755
R24655 n1_M8_108060_134460 n1_M8_109140_134460 0.001755
R24656 n1_M8_109140_134460 n1_M8_110220_134460 0.001755
R24657 n1_M8_110220_134460 n1_M8_111300_134460 0.001755
R24658 n1_M8_111300_134460 n1_M8_112380_134460 0.001755
R24659 n1_M8_112380_134460 n1_M8_113460_134460 0.001755
R24660 n1_M8_113460_134460 n1_M8_114540_134460 0.001755
R24661 n1_M8_114540_134460 n1_M8_115620_134460 0.001755
R24662 n1_M8_115620_134460 n1_M8_116700_134460 0.001755
R24663 n1_M8_116700_134460 n1_M8_117780_134460 0.001755
R24664 n1_M8_117780_134460 n1_M8_118860_134460 0.001755
R24665 n1_M8_118860_134460 n1_M8_119940_134460 0.001755
R24666 n1_M8_119940_134460 n1_M8_121020_134460 0.001755
R24667 n1_M8_121020_134460 n1_M8_122100_134460 0.001755
R24668 n1_M8_122100_134460 n1_M8_123180_134460 0.001755
R24669 n1_M8_123180_134460 n1_M8_124260_134460 0.001755
R24670 n1_M8_124260_134460 n1_M8_125340_134460 0.001755
R24671 n1_M8_125340_134460 n1_M8_126420_134460 0.001755
R24672 n1_M8_126420_134460 n1_M8_127500_134460 0.001755
R24673 n1_M8_127500_134460 n1_M8_128580_134460 0.001755
R24674 n1_M8_128580_134460 n1_M8_129660_134460 0.001755
R24675 n1_M8_129660_134460 n1_M8_130740_134460 0.001755
R24676 n1_M8_130740_134460 n1_M8_131820_134460 0.001755
R24677 n1_M8_131820_134460 n1_M8_132900_134460 0.001755
R24678 n1_M8_132900_134460 n1_M8_133980_134460 0.001755
R24679 n1_M8_133980_134460 n1_M8_135060_134460 0.001755
R24680 n1_M8_135060_134460 n1_M8_136140_134460 0.001755
R24681 n1_M8_136140_134460 n1_M8_137220_134460 0.001755
R24682 n1_M8_137220_134460 n1_M8_138300_134460 0.001755
R24683 n1_M8_138300_134460 n1_M8_139380_134460 0.001755
R24684 n1_M8_139380_134460 n1_M8_140460_134460 0.001755
R24685 n1_M8_140460_134460 n1_M8_141540_134460 0.001755
R24686 n1_M8_141540_134460 n1_M8_142620_134460 0.001755
R24687 n1_M8_142620_134460 n1_M8_143700_134460 0.001755
R24688 n1_M8_143700_134460 n1_M8_144780_134460 0.001755
R24689 n1_M8_144780_134460 n1_M8_145860_134460 0.001755
R24690 n1_M8_145860_134460 n1_M8_146940_134460 0.001755
R24691 n1_M8_60_140860 n1_M8_1140_140860 0.001755
R24692 n1_M8_1140_140860 n1_M8_2220_140860 0.001755
R24693 n1_M8_2220_140860 n1_M8_3300_140860 0.001755
R24694 n1_M8_3300_140860 n1_M8_4380_140860 0.001755
R24695 n1_M8_4380_140860 n1_M8_5460_140860 0.001755
R24696 n1_M8_5460_140860 n1_M8_6540_140860 0.001755
R24697 n1_M8_6540_140860 n1_M8_7620_140860 0.001755
R24698 n1_M8_7620_140860 n1_M8_8700_140860 0.001755
R24699 n1_M8_8700_140860 n1_M8_9780_140860 0.001755
R24700 n1_M8_9780_140860 n1_M8_10860_140860 0.001755
R24701 n1_M8_10860_140860 n1_M8_11940_140860 0.001755
R24702 n1_M8_11940_140860 n1_M8_13020_140860 0.001755
R24703 n1_M8_13020_140860 n1_M8_14100_140860 0.001755
R24704 n1_M8_14100_140860 n1_M8_15180_140860 0.001755
R24705 n1_M8_15180_140860 n1_M8_16260_140860 0.001755
R24706 n1_M8_16260_140860 n1_M8_17340_140860 0.001755
R24707 n1_M8_17340_140860 n1_M8_18420_140860 0.001755
R24708 n1_M8_18420_140860 n1_M8_19500_140860 0.001755
R24709 n1_M8_19500_140860 n1_M8_20580_140860 0.001755
R24710 n1_M8_20580_140860 n1_M8_21660_140860 0.001755
R24711 n1_M8_21660_140860 n1_M8_22740_140860 0.001755
R24712 n1_M8_22740_140860 n1_M8_23820_140860 0.001755
R24713 n1_M8_23820_140860 n1_M8_24900_140860 0.001755
R24714 n1_M8_24900_140860 n1_M8_25980_140860 0.001755
R24715 n1_M8_25980_140860 n1_M8_27060_140860 0.001755
R24716 n1_M8_27060_140860 n1_M8_28140_140860 0.001755
R24717 n1_M8_28140_140860 n1_M8_29220_140860 0.001755
R24718 n1_M8_29220_140860 n1_M8_30300_140860 0.001755
R24719 n1_M8_30300_140860 n1_M8_31380_140860 0.001755
R24720 n1_M8_31380_140860 n1_M8_32460_140860 0.001755
R24721 n1_M8_32460_140860 n1_M8_33540_140860 0.001755
R24722 n1_M8_33540_140860 n1_M8_34620_140860 0.001755
R24723 n1_M8_34620_140860 n1_M8_35700_140860 0.001755
R24724 n1_M8_35700_140860 n1_M8_36780_140860 0.001755
R24725 n1_M8_36780_140860 n1_M8_37860_140860 0.001755
R24726 n1_M8_37860_140860 n1_M8_38940_140860 0.001755
R24727 n1_M8_38940_140860 n1_M8_40020_140860 0.001755
R24728 n1_M8_40020_140860 n1_M8_41100_140860 0.001755
R24729 n1_M8_41100_140860 n1_M8_42180_140860 0.001755
R24730 n1_M8_42180_140860 n1_M8_43260_140860 0.001755
R24731 n1_M8_43260_140860 n1_M8_44340_140860 0.001755
R24732 n1_M8_44340_140860 n1_M8_45420_140860 0.001755
R24733 n1_M8_45420_140860 n1_M8_46500_140860 0.001755
R24734 n1_M8_46500_140860 n1_M8_47580_140860 0.001755
R24735 n1_M8_47580_140860 n1_M8_48660_140860 0.001755
R24736 n1_M8_48660_140860 n1_M8_49740_140860 0.001755
R24737 n1_M8_49740_140860 n1_M8_50820_140860 0.001755
R24738 n1_M8_50820_140860 n1_M8_51900_140860 0.001755
R24739 n1_M8_51900_140860 n1_M8_52980_140860 0.001755
R24740 n1_M8_52980_140860 n1_M8_54060_140860 0.001755
R24741 n1_M8_54060_140860 n1_M8_55140_140860 0.001755
R24742 n1_M8_55140_140860 n1_M8_56220_140860 0.001755
R24743 n1_M8_56220_140860 n1_M8_57300_140860 0.001755
R24744 n1_M8_57300_140860 n1_M8_58380_140860 0.001755
R24745 n1_M8_58380_140860 n1_M8_59460_140860 0.001755
R24746 n1_M8_59460_140860 n1_M8_60540_140860 0.001755
R24747 n1_M8_60540_140860 n1_M8_61620_140860 0.001755
R24748 n1_M8_61620_140860 n1_M8_62700_140860 0.001755
R24749 n1_M8_62700_140860 n1_M8_63780_140860 0.001755
R24750 n1_M8_63780_140860 n1_M8_64860_140860 0.001755
R24751 n1_M8_64860_140860 n1_M8_65940_140860 0.001755
R24752 n1_M8_65940_140860 n1_M8_67020_140860 0.001755
R24753 n1_M8_67020_140860 n1_M8_68100_140860 0.001755
R24754 n1_M8_68100_140860 n1_M8_69180_140860 0.001755
R24755 n1_M8_69180_140860 n1_M8_70260_140860 0.001755
R24756 n1_M8_70260_140860 n1_M8_71340_140860 0.001755
R24757 n1_M8_71340_140860 n1_M8_72420_140860 0.001755
R24758 n1_M8_72420_140860 n1_M8_73500_140860 0.001755
R24759 n1_M8_73500_140860 n1_M8_74580_140860 0.001755
R24760 n1_M8_74580_140860 n1_M8_75660_140860 0.001755
R24761 n1_M8_75660_140860 n1_M8_76740_140860 0.001755
R24762 n1_M8_76740_140860 n1_M8_77820_140860 0.001755
R24763 n1_M8_77820_140860 n1_M8_78900_140860 0.001755
R24764 n1_M8_78900_140860 n1_M8_79980_140860 0.001755
R24765 n1_M8_79980_140860 n1_M8_81060_140860 0.001755
R24766 n1_M8_81060_140860 n1_M8_82140_140860 0.001755
R24767 n1_M8_82140_140860 n1_M8_83220_140860 0.001755
R24768 n1_M8_83220_140860 n1_M8_84300_140860 0.001755
R24769 n1_M8_84300_140860 n1_M8_85380_140860 0.001755
R24770 n1_M8_85380_140860 n1_M8_86460_140860 0.001755
R24771 n1_M8_86460_140860 n1_M8_87540_140860 0.001755
R24772 n1_M8_87540_140860 n1_M8_88620_140860 0.001755
R24773 n1_M8_88620_140860 n1_M8_89700_140860 0.001755
R24774 n1_M8_89700_140860 n1_M8_90780_140860 0.001755
R24775 n1_M8_90780_140860 n1_M8_91860_140860 0.001755
R24776 n1_M8_91860_140860 n1_M8_92940_140860 0.001755
R24777 n1_M8_92940_140860 n1_M8_94020_140860 0.001755
R24778 n1_M8_94020_140860 n1_M8_95100_140860 0.001755
R24779 n1_M8_95100_140860 n1_M8_96180_140860 0.001755
R24780 n1_M8_96180_140860 n1_M8_97260_140860 0.001755
R24781 n1_M8_97260_140860 n1_M8_98340_140860 0.001755
R24782 n1_M8_98340_140860 n1_M8_99420_140860 0.001755
R24783 n1_M8_99420_140860 n1_M8_100500_140860 0.001755
R24784 n1_M8_100500_140860 n1_M8_101580_140860 0.001755
R24785 n1_M8_101580_140860 n1_M8_102660_140860 0.001755
R24786 n1_M8_102660_140860 n1_M8_103740_140860 0.001755
R24787 n1_M8_103740_140860 n1_M8_104820_140860 0.001755
R24788 n1_M8_104820_140860 n1_M8_105900_140860 0.001755
R24789 n1_M8_105900_140860 n1_M8_106980_140860 0.001755
R24790 n1_M8_106980_140860 n1_M8_108060_140860 0.001755
R24791 n1_M8_108060_140860 n1_M8_109140_140860 0.001755
R24792 n1_M8_109140_140860 n1_M8_110220_140860 0.001755
R24793 n1_M8_110220_140860 n1_M8_111300_140860 0.001755
R24794 n1_M8_111300_140860 n1_M8_112380_140860 0.001755
R24795 n1_M8_112380_140860 n1_M8_113460_140860 0.001755
R24796 n1_M8_113460_140860 n1_M8_114540_140860 0.001755
R24797 n1_M8_114540_140860 n1_M8_115620_140860 0.001755
R24798 n1_M8_115620_140860 n1_M8_116700_140860 0.001755
R24799 n1_M8_116700_140860 n1_M8_117780_140860 0.001755
R24800 n1_M8_117780_140860 n1_M8_118860_140860 0.001755
R24801 n1_M8_118860_140860 n1_M8_119940_140860 0.001755
R24802 n1_M8_119940_140860 n1_M8_121020_140860 0.001755
R24803 n1_M8_121020_140860 n1_M8_122100_140860 0.001755
R24804 n1_M8_122100_140860 n1_M8_123180_140860 0.001755
R24805 n1_M8_123180_140860 n1_M8_124260_140860 0.001755
R24806 n1_M8_124260_140860 n1_M8_125340_140860 0.001755
R24807 n1_M8_125340_140860 n1_M8_126420_140860 0.001755
R24808 n1_M8_126420_140860 n1_M8_127500_140860 0.001755
R24809 n1_M8_127500_140860 n1_M8_128580_140860 0.001755
R24810 n1_M8_128580_140860 n1_M8_129660_140860 0.001755
R24811 n1_M8_129660_140860 n1_M8_130740_140860 0.001755
R24812 n1_M8_130740_140860 n1_M8_131820_140860 0.001755
R24813 n1_M8_131820_140860 n1_M8_132900_140860 0.001755
R24814 n1_M8_132900_140860 n1_M8_133980_140860 0.001755
R24815 n1_M8_133980_140860 n1_M8_135060_140860 0.001755
R24816 n1_M8_135060_140860 n1_M8_136140_140860 0.001755
R24817 n1_M8_136140_140860 n1_M8_137220_140860 0.001755
R24818 n1_M8_137220_140860 n1_M8_138300_140860 0.001755
R24819 n1_M8_138300_140860 n1_M8_139380_140860 0.001755
R24820 n1_M8_139380_140860 n1_M8_140460_140860 0.001755
R24821 n1_M8_140460_140860 n1_M8_141540_140860 0.001755
R24822 n1_M8_141540_140860 n1_M8_142620_140860 0.001755
R24823 n1_M8_142620_140860 n1_M8_143700_140860 0.001755
R24824 n1_M8_143700_140860 n1_M8_144780_140860 0.001755
R24825 n1_M8_144780_140860 n1_M8_145860_140860 0.001755
R24826 n1_M8_145860_140860 n1_M8_146940_140860 0.001755
R24827 n1_M8_60_147260 n1_M8_1140_147260 0.001755
R24828 n1_M8_1140_147260 n1_M8_2220_147260 0.001755
R24829 n1_M8_2220_147260 n1_M8_3300_147260 0.001755
R24830 n1_M8_3300_147260 n1_M8_4380_147260 0.001755
R24831 n1_M8_4380_147260 n1_M8_5460_147260 0.001755
R24832 n1_M8_5460_147260 n1_M8_6540_147260 0.001755
R24833 n1_M8_6540_147260 n1_M8_7620_147260 0.001755
R24834 n1_M8_7620_147260 n1_M8_8700_147260 0.001755
R24835 n1_M8_8700_147260 n1_M8_9780_147260 0.001755
R24836 n1_M8_9780_147260 n1_M8_10860_147260 0.001755
R24837 n1_M8_10860_147260 n1_M8_11940_147260 0.001755
R24838 n1_M8_11940_147260 n1_M8_13020_147260 0.001755
R24839 n1_M8_13020_147260 n1_M8_14100_147260 0.001755
R24840 n1_M8_14100_147260 n1_M8_15180_147260 0.001755
R24841 n1_M8_15180_147260 n1_M8_16260_147260 0.001755
R24842 n1_M8_16260_147260 n1_M8_17340_147260 0.001755
R24843 n1_M8_17340_147260 n1_M8_18420_147260 0.001755
R24844 n1_M8_18420_147260 n1_M8_19500_147260 0.001755
R24845 n1_M8_19500_147260 n1_M8_20580_147260 0.001755
R24846 n1_M8_20580_147260 n1_M8_21660_147260 0.001755
R24847 n1_M8_21660_147260 n1_M8_22740_147260 0.001755
R24848 n1_M8_22740_147260 n1_M8_23820_147260 0.001755
R24849 n1_M8_23820_147260 n1_M8_24900_147260 0.001755
R24850 n1_M8_24900_147260 n1_M8_25980_147260 0.001755
R24851 n1_M8_25980_147260 n1_M8_27060_147260 0.001755
R24852 n1_M8_27060_147260 n1_M8_28140_147260 0.001755
R24853 n1_M8_28140_147260 n1_M8_29220_147260 0.001755
R24854 n1_M8_29220_147260 n1_M8_30300_147260 0.001755
R24855 n1_M8_30300_147260 n1_M8_31380_147260 0.001755
R24856 n1_M8_31380_147260 n1_M8_32460_147260 0.001755
R24857 n1_M8_32460_147260 n1_M8_33540_147260 0.001755
R24858 n1_M8_33540_147260 n1_M8_34620_147260 0.001755
R24859 n1_M8_34620_147260 n1_M8_35700_147260 0.001755
R24860 n1_M8_35700_147260 n1_M8_36780_147260 0.001755
R24861 n1_M8_36780_147260 n1_M8_37860_147260 0.001755
R24862 n1_M8_37860_147260 n1_M8_38940_147260 0.001755
R24863 n1_M8_38940_147260 n1_M8_40020_147260 0.001755
R24864 n1_M8_40020_147260 n1_M8_41100_147260 0.001755
R24865 n1_M8_41100_147260 n1_M8_42180_147260 0.001755
R24866 n1_M8_42180_147260 n1_M8_43260_147260 0.001755
R24867 n1_M8_43260_147260 n1_M8_44340_147260 0.001755
R24868 n1_M8_44340_147260 n1_M8_45420_147260 0.001755
R24869 n1_M8_45420_147260 n1_M8_46500_147260 0.001755
R24870 n1_M8_46500_147260 n1_M8_47580_147260 0.001755
R24871 n1_M8_47580_147260 n1_M8_48660_147260 0.001755
R24872 n1_M8_48660_147260 n1_M8_49740_147260 0.001755
R24873 n1_M8_49740_147260 n1_M8_50820_147260 0.001755
R24874 n1_M8_50820_147260 n1_M8_51900_147260 0.001755
R24875 n1_M8_51900_147260 n1_M8_52980_147260 0.001755
R24876 n1_M8_52980_147260 n1_M8_54060_147260 0.001755
R24877 n1_M8_54060_147260 n1_M8_55140_147260 0.001755
R24878 n1_M8_55140_147260 n1_M8_56220_147260 0.001755
R24879 n1_M8_56220_147260 n1_M8_57300_147260 0.001755
R24880 n1_M8_57300_147260 n1_M8_58380_147260 0.001755
R24881 n1_M8_58380_147260 n1_M8_59460_147260 0.001755
R24882 n1_M8_59460_147260 n1_M8_60540_147260 0.001755
R24883 n1_M8_60540_147260 n1_M8_61620_147260 0.001755
R24884 n1_M8_61620_147260 n1_M8_62700_147260 0.001755
R24885 n1_M8_62700_147260 n1_M8_63780_147260 0.001755
R24886 n1_M8_63780_147260 n1_M8_64860_147260 0.001755
R24887 n1_M8_64860_147260 n1_M8_65940_147260 0.001755
R24888 n1_M8_65940_147260 n1_M8_67020_147260 0.001755
R24889 n1_M8_67020_147260 n1_M8_68100_147260 0.001755
R24890 n1_M8_68100_147260 n1_M8_69180_147260 0.001755
R24891 n1_M8_69180_147260 n1_M8_70260_147260 0.001755
R24892 n1_M8_70260_147260 n1_M8_71340_147260 0.001755
R24893 n1_M8_71340_147260 n1_M8_72420_147260 0.001755
R24894 n1_M8_72420_147260 n1_M8_73500_147260 0.001755
R24895 n1_M8_73500_147260 n1_M8_74580_147260 0.001755
R24896 n1_M8_74580_147260 n1_M8_75660_147260 0.001755
R24897 n1_M8_75660_147260 n1_M8_76740_147260 0.001755
R24898 n1_M8_76740_147260 n1_M8_77820_147260 0.001755
R24899 n1_M8_77820_147260 n1_M8_78900_147260 0.001755
R24900 n1_M8_78900_147260 n1_M8_79980_147260 0.001755
R24901 n1_M8_79980_147260 n1_M8_81060_147260 0.001755
R24902 n1_M8_81060_147260 n1_M8_82140_147260 0.001755
R24903 n1_M8_82140_147260 n1_M8_83220_147260 0.001755
R24904 n1_M8_83220_147260 n1_M8_84300_147260 0.001755
R24905 n1_M8_84300_147260 n1_M8_85380_147260 0.001755
R24906 n1_M8_85380_147260 n1_M8_86460_147260 0.001755
R24907 n1_M8_86460_147260 n1_M8_87540_147260 0.001755
R24908 n1_M8_87540_147260 n1_M8_88620_147260 0.001755
R24909 n1_M8_88620_147260 n1_M8_89700_147260 0.001755
R24910 n1_M8_89700_147260 n1_M8_90780_147260 0.001755
R24911 n1_M8_90780_147260 n1_M8_91860_147260 0.001755
R24912 n1_M8_91860_147260 n1_M8_92940_147260 0.001755
R24913 n1_M8_92940_147260 n1_M8_94020_147260 0.001755
R24914 n1_M8_94020_147260 n1_M8_95100_147260 0.001755
R24915 n1_M8_95100_147260 n1_M8_96180_147260 0.001755
R24916 n1_M8_96180_147260 n1_M8_97260_147260 0.001755
R24917 n1_M8_97260_147260 n1_M8_98340_147260 0.001755
R24918 n1_M8_98340_147260 n1_M8_99420_147260 0.001755
R24919 n1_M8_99420_147260 n1_M8_100500_147260 0.001755
R24920 n1_M8_100500_147260 n1_M8_101580_147260 0.001755
R24921 n1_M8_101580_147260 n1_M8_102660_147260 0.001755
R24922 n1_M8_102660_147260 n1_M8_103740_147260 0.001755
R24923 n1_M8_103740_147260 n1_M8_104820_147260 0.001755
R24924 n1_M8_104820_147260 n1_M8_105900_147260 0.001755
R24925 n1_M8_105900_147260 n1_M8_106980_147260 0.001755
R24926 n1_M8_106980_147260 n1_M8_108060_147260 0.001755
R24927 n1_M8_108060_147260 n1_M8_109140_147260 0.001755
R24928 n1_M8_109140_147260 n1_M8_110220_147260 0.001755
R24929 n1_M8_110220_147260 n1_M8_111300_147260 0.001755
R24930 n1_M8_111300_147260 n1_M8_112380_147260 0.001755
R24931 n1_M8_112380_147260 n1_M8_113460_147260 0.001755
R24932 n1_M8_113460_147260 n1_M8_114540_147260 0.001755
R24933 n1_M8_114540_147260 n1_M8_115620_147260 0.001755
R24934 n1_M8_115620_147260 n1_M8_116700_147260 0.001755
R24935 n1_M8_116700_147260 n1_M8_117780_147260 0.001755
R24936 n1_M8_117780_147260 n1_M8_118860_147260 0.001755
R24937 n1_M8_118860_147260 n1_M8_119940_147260 0.001755
R24938 n1_M8_119940_147260 n1_M8_121020_147260 0.001755
R24939 n1_M8_121020_147260 n1_M8_122100_147260 0.001755
R24940 n1_M8_122100_147260 n1_M8_123180_147260 0.001755
R24941 n1_M8_123180_147260 n1_M8_124260_147260 0.001755
R24942 n1_M8_124260_147260 n1_M8_125340_147260 0.001755
R24943 n1_M8_125340_147260 n1_M8_126420_147260 0.001755
R24944 n1_M8_126420_147260 n1_M8_127500_147260 0.001755
R24945 n1_M8_127500_147260 n1_M8_128580_147260 0.001755
R24946 n1_M8_128580_147260 n1_M8_129660_147260 0.001755
R24947 n1_M8_129660_147260 n1_M8_130740_147260 0.001755
R24948 n1_M8_130740_147260 n1_M8_131820_147260 0.001755
R24949 n1_M8_131820_147260 n1_M8_132900_147260 0.001755
R24950 n1_M8_132900_147260 n1_M8_133980_147260 0.001755
R24951 n1_M8_133980_147260 n1_M8_135060_147260 0.001755
R24952 n1_M8_135060_147260 n1_M8_136140_147260 0.001755
R24953 n1_M8_136140_147260 n1_M8_137220_147260 0.001755
R24954 n1_M8_137220_147260 n1_M8_138300_147260 0.001755
R24955 n1_M8_138300_147260 n1_M8_139380_147260 0.001755
R24956 n1_M8_139380_147260 n1_M8_140460_147260 0.001755
R24957 n1_M8_140460_147260 n1_M8_141540_147260 0.001755
R24958 n1_M8_141540_147260 n1_M8_142620_147260 0.001755
R24959 n1_M8_142620_147260 n1_M8_143700_147260 0.001755
R24960 n1_M8_143700_147260 n1_M8_144780_147260 0.001755
R24961 n1_M8_144780_147260 n1_M8_145860_147260 0.001755
R24962 n1_M8_145860_147260 n1_M8_146940_147260 0.001755
R24963 n1_M2_60_60 n1_M5_60_60 10.000000
R24964 n1_M2_60_1140 n1_M5_60_1140 10.000000
R24965 n1_M2_60_2220 n1_M5_60_2220 10.000000
R24966 n1_M2_60_3300 n1_M5_60_3300 10.000000
R24967 n1_M2_60_4380 n1_M5_60_4380 10.000000
R24968 n1_M2_60_5460 n1_M5_60_5460 10.000000
R24969 n1_M2_60_6540 n1_M5_60_6540 10.000000
R24970 n1_M2_60_7620 n1_M5_60_7620 10.000000
R24971 n1_M2_60_8700 n1_M5_60_8700 10.000000
R24972 n1_M2_60_9780 n1_M5_60_9780 10.000000
R24973 n1_M2_60_10860 n1_M5_60_10860 10.000000
R24974 n1_M2_60_11940 n1_M5_60_11940 10.000000
R24975 n1_M2_60_13020 n1_M5_60_13020 10.000000
R24976 n1_M2_60_14100 n1_M5_60_14100 10.000000
R24977 n1_M2_60_15180 n1_M5_60_15180 10.000000
R24978 n1_M2_60_16260 n1_M5_60_16260 10.000000
R24979 n1_M2_60_17340 n1_M5_60_17340 10.000000
R24980 n1_M2_60_18420 n1_M5_60_18420 10.000000
R24981 n1_M2_60_19500 n1_M5_60_19500 10.000000
R24982 n1_M2_60_20580 n1_M5_60_20580 10.000000
R24983 n1_M2_60_21660 n1_M5_60_21660 10.000000
R24984 n1_M2_60_22740 n1_M5_60_22740 10.000000
R24985 n1_M2_60_23820 n1_M5_60_23820 10.000000
R24986 n1_M2_60_24900 n1_M5_60_24900 10.000000
R24987 n1_M2_60_25980 n1_M5_60_25980 10.000000
R24988 n1_M2_60_27060 n1_M5_60_27060 10.000000
R24989 n1_M2_60_28140 n1_M5_60_28140 10.000000
R24990 n1_M2_60_29220 n1_M5_60_29220 10.000000
R24991 n1_M2_60_30300 n1_M5_60_30300 10.000000
R24992 n1_M2_60_31380 n1_M5_60_31380 10.000000
R24993 n1_M2_60_32460 n1_M5_60_32460 10.000000
R24994 n1_M2_60_33540 n1_M5_60_33540 10.000000
R24995 n1_M2_60_34620 n1_M5_60_34620 10.000000
R24996 n1_M2_60_35700 n1_M5_60_35700 10.000000
R24997 n1_M2_60_36780 n1_M5_60_36780 10.000000
R24998 n1_M2_60_37860 n1_M5_60_37860 10.000000
R24999 n1_M2_60_38940 n1_M5_60_38940 10.000000
R25000 n1_M2_60_40020 n1_M5_60_40020 10.000000
R25001 n1_M2_60_41100 n1_M5_60_41100 10.000000
R25002 n1_M2_60_42180 n1_M5_60_42180 10.000000
R25003 n1_M2_60_43260 n1_M5_60_43260 10.000000
R25004 n1_M2_60_44340 n1_M5_60_44340 10.000000
R25005 n1_M2_60_45420 n1_M5_60_45420 10.000000
R25006 n1_M2_60_46500 n1_M5_60_46500 10.000000
R25007 n1_M2_60_47580 n1_M5_60_47580 10.000000
R25008 n1_M2_60_48660 n1_M5_60_48660 10.000000
R25009 n1_M2_60_49740 n1_M5_60_49740 10.000000
R25010 n1_M2_60_50820 n1_M5_60_50820 10.000000
R25011 n1_M2_60_51900 n1_M5_60_51900 10.000000
R25012 n1_M2_60_52980 n1_M5_60_52980 10.000000
R25013 n1_M2_60_54060 n1_M5_60_54060 10.000000
R25014 n1_M2_60_55140 n1_M5_60_55140 10.000000
R25015 n1_M2_60_56220 n1_M5_60_56220 10.000000
R25016 n1_M2_60_57300 n1_M5_60_57300 10.000000
R25017 n1_M2_60_58380 n1_M5_60_58380 10.000000
R25018 n1_M2_60_59460 n1_M5_60_59460 10.000000
R25019 n1_M2_60_60540 n1_M5_60_60540 10.000000
R25020 n1_M2_60_61620 n1_M5_60_61620 10.000000
R25021 n1_M2_60_62700 n1_M5_60_62700 10.000000
R25022 n1_M2_60_63780 n1_M5_60_63780 10.000000
R25023 n1_M2_60_64860 n1_M5_60_64860 10.000000
R25024 n1_M2_60_65940 n1_M5_60_65940 10.000000
R25025 n1_M2_60_67020 n1_M5_60_67020 10.000000
R25026 n1_M2_60_68100 n1_M5_60_68100 10.000000
R25027 n1_M2_60_69180 n1_M5_60_69180 10.000000
R25028 n1_M2_60_70260 n1_M5_60_70260 10.000000
R25029 n1_M2_60_71340 n1_M5_60_71340 10.000000
R25030 n1_M2_60_72420 n1_M5_60_72420 10.000000
R25031 n1_M2_60_73500 n1_M5_60_73500 10.000000
R25032 n1_M2_60_74580 n1_M5_60_74580 10.000000
R25033 n1_M2_60_75660 n1_M5_60_75660 10.000000
R25034 n1_M2_60_76740 n1_M5_60_76740 10.000000
R25035 n1_M2_60_77820 n1_M5_60_77820 10.000000
R25036 n1_M2_60_78900 n1_M5_60_78900 10.000000
R25037 n1_M2_60_79980 n1_M5_60_79980 10.000000
R25038 n1_M2_60_81060 n1_M5_60_81060 10.000000
R25039 n1_M2_60_82140 n1_M5_60_82140 10.000000
R25040 n1_M2_60_83220 n1_M5_60_83220 10.000000
R25041 n1_M2_60_84300 n1_M5_60_84300 10.000000
R25042 n1_M2_60_85380 n1_M5_60_85380 10.000000
R25043 n1_M2_60_86460 n1_M5_60_86460 10.000000
R25044 n1_M2_60_87540 n1_M5_60_87540 10.000000
R25045 n1_M2_60_88620 n1_M5_60_88620 10.000000
R25046 n1_M2_60_89700 n1_M5_60_89700 10.000000
R25047 n1_M2_60_90780 n1_M5_60_90780 10.000000
R25048 n1_M2_60_91860 n1_M5_60_91860 10.000000
R25049 n1_M2_60_92940 n1_M5_60_92940 10.000000
R25050 n1_M2_60_94020 n1_M5_60_94020 10.000000
R25051 n1_M2_60_95100 n1_M5_60_95100 10.000000
R25052 n1_M2_60_96180 n1_M5_60_96180 10.000000
R25053 n1_M2_60_97260 n1_M5_60_97260 10.000000
R25054 n1_M2_60_98340 n1_M5_60_98340 10.000000
R25055 n1_M2_60_99420 n1_M5_60_99420 10.000000
R25056 n1_M2_60_100500 n1_M5_60_100500 10.000000
R25057 n1_M2_60_101580 n1_M5_60_101580 10.000000
R25058 n1_M2_60_102660 n1_M5_60_102660 10.000000
R25059 n1_M2_60_103740 n1_M5_60_103740 10.000000
R25060 n1_M2_60_104820 n1_M5_60_104820 10.000000
R25061 n1_M2_60_105900 n1_M5_60_105900 10.000000
R25062 n1_M2_60_106980 n1_M5_60_106980 10.000000
R25063 n1_M2_60_108060 n1_M5_60_108060 10.000000
R25064 n1_M2_60_109140 n1_M5_60_109140 10.000000
R25065 n1_M2_60_110220 n1_M5_60_110220 10.000000
R25066 n1_M2_60_111300 n1_M5_60_111300 10.000000
R25067 n1_M2_60_112380 n1_M5_60_112380 10.000000
R25068 n1_M2_60_113460 n1_M5_60_113460 10.000000
R25069 n1_M2_60_114540 n1_M5_60_114540 10.000000
R25070 n1_M2_60_115620 n1_M5_60_115620 10.000000
R25071 n1_M2_60_116700 n1_M5_60_116700 10.000000
R25072 n1_M2_60_117780 n1_M5_60_117780 10.000000
R25073 n1_M2_60_118860 n1_M5_60_118860 10.000000
R25074 n1_M2_60_119940 n1_M5_60_119940 10.000000
R25075 n1_M2_60_121020 n1_M5_60_121020 10.000000
R25076 n1_M2_60_122100 n1_M5_60_122100 10.000000
R25077 n1_M2_60_123180 n1_M5_60_123180 10.000000
R25078 n1_M2_60_124260 n1_M5_60_124260 10.000000
R25079 n1_M2_60_125340 n1_M5_60_125340 10.000000
R25080 n1_M2_60_126420 n1_M5_60_126420 10.000000
R25081 n1_M2_60_127500 n1_M5_60_127500 10.000000
R25082 n1_M2_60_128580 n1_M5_60_128580 10.000000
R25083 n1_M2_60_129660 n1_M5_60_129660 10.000000
R25084 n1_M2_60_130740 n1_M5_60_130740 10.000000
R25085 n1_M2_60_131820 n1_M5_60_131820 10.000000
R25086 n1_M2_60_132900 n1_M5_60_132900 10.000000
R25087 n1_M2_60_133980 n1_M5_60_133980 10.000000
R25088 n1_M2_60_135060 n1_M5_60_135060 10.000000
R25089 n1_M2_60_136140 n1_M5_60_136140 10.000000
R25090 n1_M2_60_137220 n1_M5_60_137220 10.000000
R25091 n1_M2_60_138300 n1_M5_60_138300 10.000000
R25092 n1_M2_60_139380 n1_M5_60_139380 10.000000
R25093 n1_M2_60_140460 n1_M5_60_140460 10.000000
R25094 n1_M2_60_141540 n1_M5_60_141540 10.000000
R25095 n1_M2_60_142620 n1_M5_60_142620 10.000000
R25096 n1_M2_60_143700 n1_M5_60_143700 10.000000
R25097 n1_M2_60_144780 n1_M5_60_144780 10.000000
R25098 n1_M2_60_145860 n1_M5_60_145860 10.000000
R25099 n1_M2_60_146940 n1_M5_60_146940 10.000000
R25100 n1_M2_6540_60 n1_M5_6060_60 10.000000
R25101 n1_M2_11940_60 n1_M5_12060_60 10.000000
R25102 n1_M2_18420_60 n1_M5_18060_60 10.000000
R25103 n1_M2_23820_60 n1_M5_24060_60 10.000000
R25104 n1_M2_23820_1140 n1_M5_24060_1140 10.000000
R25105 n1_M2_23820_2220 n1_M5_24060_2220 10.000000
R25106 n1_M2_23820_3300 n1_M5_24060_3300 10.000000
R25107 n1_M2_23820_4380 n1_M5_24060_4380 10.000000
R25108 n1_M2_23820_5460 n1_M5_24060_5460 10.000000
R25109 n1_M2_23820_6540 n1_M5_24060_6540 10.000000
R25110 n1_M2_23820_7620 n1_M5_24060_7620 10.000000
R25111 n1_M2_23820_8700 n1_M5_24060_8700 10.000000
R25112 n1_M2_23820_9780 n1_M5_24060_9780 10.000000
R25113 n1_M2_23820_10860 n1_M5_24060_10860 10.000000
R25114 n1_M2_23820_11940 n1_M5_24060_11940 10.000000
R25115 n1_M2_23820_13020 n1_M5_24060_13020 10.000000
R25116 n1_M2_23820_14100 n1_M5_24060_14100 10.000000
R25117 n1_M2_23820_15180 n1_M5_24060_15180 10.000000
R25118 n1_M2_23820_16260 n1_M5_24060_16260 10.000000
R25119 n1_M2_23820_17340 n1_M5_24060_17340 10.000000
R25120 n1_M2_23820_18420 n1_M5_24060_18420 10.000000
R25121 n1_M2_23820_19500 n1_M5_24060_19500 10.000000
R25122 n1_M2_23820_20580 n1_M5_24060_20580 10.000000
R25123 n1_M2_23820_21660 n1_M5_24060_21660 10.000000
R25124 n1_M2_23820_22740 n1_M5_24060_22740 10.000000
R25125 n1_M2_23820_23820 n1_M5_24060_23820 10.000000
R25126 n1_M2_23820_24900 n1_M5_24060_24900 10.000000
R25127 n1_M2_23820_25980 n1_M5_24060_25980 10.000000
R25128 n1_M2_23820_27060 n1_M5_24060_27060 10.000000
R25129 n1_M2_23820_28140 n1_M5_24060_28140 10.000000
R25130 n1_M2_23820_29220 n1_M5_24060_29220 10.000000
R25131 n1_M2_23820_30300 n1_M5_24060_30300 10.000000
R25132 n1_M2_23820_31380 n1_M5_24060_31380 10.000000
R25133 n1_M2_23820_32460 n1_M5_24060_32460 10.000000
R25134 n1_M2_23820_33540 n1_M5_24060_33540 10.000000
R25135 n1_M2_23820_34620 n1_M5_24060_34620 10.000000
R25136 n1_M2_23820_35700 n1_M5_24060_35700 10.000000
R25137 n1_M2_23820_36780 n1_M5_24060_36780 10.000000
R25138 n1_M2_23820_37860 n1_M5_24060_37860 10.000000
R25139 n1_M2_23820_38940 n1_M5_24060_38940 10.000000
R25140 n1_M2_23820_40020 n1_M5_24060_40020 10.000000
R25141 n1_M2_23820_41100 n1_M5_24060_41100 10.000000
R25142 n1_M2_23820_42180 n1_M5_24060_42180 10.000000
R25143 n1_M2_23820_43260 n1_M5_24060_43260 10.000000
R25144 n1_M2_23820_44340 n1_M5_24060_44340 10.000000
R25145 n1_M2_23820_45420 n1_M5_24060_45420 10.000000
R25146 n1_M2_23820_46500 n1_M5_24060_46500 10.000000
R25147 n1_M2_23820_47580 n1_M5_24060_47580 10.000000
R25148 n1_M2_23820_48660 n1_M5_24060_48660 10.000000
R25149 n1_M2_23820_49740 n1_M5_24060_49740 10.000000
R25150 n1_M2_23820_50820 n1_M5_24060_50820 10.000000
R25151 n1_M2_23820_51900 n1_M5_24060_51900 10.000000
R25152 n1_M2_23820_52980 n1_M5_24060_52980 10.000000
R25153 n1_M2_23820_54060 n1_M5_24060_54060 10.000000
R25154 n1_M2_23820_55140 n1_M5_24060_55140 10.000000
R25155 n1_M2_23820_56220 n1_M5_24060_56220 10.000000
R25156 n1_M2_23820_57300 n1_M5_24060_57300 10.000000
R25157 n1_M2_23820_58380 n1_M5_24060_58380 10.000000
R25158 n1_M2_23820_59460 n1_M5_24060_59460 10.000000
R25159 n1_M2_23820_60540 n1_M5_24060_60540 10.000000
R25160 n1_M2_23820_61620 n1_M5_24060_61620 10.000000
R25161 n1_M2_23820_62700 n1_M5_24060_62700 10.000000
R25162 n1_M2_23820_63780 n1_M5_24060_63780 10.000000
R25163 n1_M2_23820_64860 n1_M5_24060_64860 10.000000
R25164 n1_M2_23820_65940 n1_M5_24060_65940 10.000000
R25165 n1_M2_23820_67020 n1_M5_24060_67020 10.000000
R25166 n1_M2_23820_68100 n1_M5_24060_68100 10.000000
R25167 n1_M2_23820_69180 n1_M5_24060_69180 10.000000
R25168 n1_M2_23820_70260 n1_M5_24060_70260 10.000000
R25169 n1_M2_23820_71340 n1_M5_24060_71340 10.000000
R25170 n1_M2_23820_72420 n1_M5_24060_72420 10.000000
R25171 n1_M2_23820_73500 n1_M5_24060_73500 10.000000
R25172 n1_M2_23820_74580 n1_M5_24060_74580 10.000000
R25173 n1_M2_23820_75660 n1_M5_24060_75660 10.000000
R25174 n1_M2_23820_76740 n1_M5_24060_76740 10.000000
R25175 n1_M2_23820_77820 n1_M5_24060_77820 10.000000
R25176 n1_M2_23820_78900 n1_M5_24060_78900 10.000000
R25177 n1_M2_23820_79980 n1_M5_24060_79980 10.000000
R25178 n1_M2_23820_81060 n1_M5_24060_81060 10.000000
R25179 n1_M2_23820_82140 n1_M5_24060_82140 10.000000
R25180 n1_M2_23820_83220 n1_M5_24060_83220 10.000000
R25181 n1_M2_23820_84300 n1_M5_24060_84300 10.000000
R25182 n1_M2_23820_85380 n1_M5_24060_85380 10.000000
R25183 n1_M2_23820_86460 n1_M5_24060_86460 10.000000
R25184 n1_M2_23820_87540 n1_M5_24060_87540 10.000000
R25185 n1_M2_23820_88620 n1_M5_24060_88620 10.000000
R25186 n1_M2_23820_89700 n1_M5_24060_89700 10.000000
R25187 n1_M2_23820_90780 n1_M5_24060_90780 10.000000
R25188 n1_M2_23820_91860 n1_M5_24060_91860 10.000000
R25189 n1_M2_23820_92940 n1_M5_24060_92940 10.000000
R25190 n1_M2_23820_94020 n1_M5_24060_94020 10.000000
R25191 n1_M2_23820_95100 n1_M5_24060_95100 10.000000
R25192 n1_M2_23820_96180 n1_M5_24060_96180 10.000000
R25193 n1_M2_23820_97260 n1_M5_24060_97260 10.000000
R25194 n1_M2_23820_98340 n1_M5_24060_98340 10.000000
R25195 n1_M2_23820_99420 n1_M5_24060_99420 10.000000
R25196 n1_M2_23820_100500 n1_M5_24060_100500 10.000000
R25197 n1_M2_23820_101580 n1_M5_24060_101580 10.000000
R25198 n1_M2_23820_102660 n1_M5_24060_102660 10.000000
R25199 n1_M2_23820_103740 n1_M5_24060_103740 10.000000
R25200 n1_M2_23820_104820 n1_M5_24060_104820 10.000000
R25201 n1_M2_23820_105900 n1_M5_24060_105900 10.000000
R25202 n1_M2_23820_106980 n1_M5_24060_106980 10.000000
R25203 n1_M2_23820_108060 n1_M5_24060_108060 10.000000
R25204 n1_M2_23820_109140 n1_M5_24060_109140 10.000000
R25205 n1_M2_23820_110220 n1_M5_24060_110220 10.000000
R25206 n1_M2_23820_111300 n1_M5_24060_111300 10.000000
R25207 n1_M2_23820_112380 n1_M5_24060_112380 10.000000
R25208 n1_M2_23820_113460 n1_M5_24060_113460 10.000000
R25209 n1_M2_23820_114540 n1_M5_24060_114540 10.000000
R25210 n1_M2_23820_115620 n1_M5_24060_115620 10.000000
R25211 n1_M2_23820_116700 n1_M5_24060_116700 10.000000
R25212 n1_M2_23820_117780 n1_M5_24060_117780 10.000000
R25213 n1_M2_23820_118860 n1_M5_24060_118860 10.000000
R25214 n1_M2_23820_119940 n1_M5_24060_119940 10.000000
R25215 n1_M2_23820_121020 n1_M5_24060_121020 10.000000
R25216 n1_M2_23820_122100 n1_M5_24060_122100 10.000000
R25217 n1_M2_23820_123180 n1_M5_24060_123180 10.000000
R25218 n1_M2_23820_124260 n1_M5_24060_124260 10.000000
R25219 n1_M2_23820_125340 n1_M5_24060_125340 10.000000
R25220 n1_M2_23820_126420 n1_M5_24060_126420 10.000000
R25221 n1_M2_23820_127500 n1_M5_24060_127500 10.000000
R25222 n1_M2_23820_128580 n1_M5_24060_128580 10.000000
R25223 n1_M2_23820_129660 n1_M5_24060_129660 10.000000
R25224 n1_M2_23820_130740 n1_M5_24060_130740 10.000000
R25225 n1_M2_23820_131820 n1_M5_24060_131820 10.000000
R25226 n1_M2_23820_132900 n1_M5_24060_132900 10.000000
R25227 n1_M2_23820_133980 n1_M5_24060_133980 10.000000
R25228 n1_M2_23820_135060 n1_M5_24060_135060 10.000000
R25229 n1_M2_23820_136140 n1_M5_24060_136140 10.000000
R25230 n1_M2_23820_137220 n1_M5_24060_137220 10.000000
R25231 n1_M2_23820_138300 n1_M5_24060_138300 10.000000
R25232 n1_M2_23820_139380 n1_M5_24060_139380 10.000000
R25233 n1_M2_23820_140460 n1_M5_24060_140460 10.000000
R25234 n1_M2_23820_141540 n1_M5_24060_141540 10.000000
R25235 n1_M2_23820_142620 n1_M5_24060_142620 10.000000
R25236 n1_M2_23820_143700 n1_M5_24060_143700 10.000000
R25237 n1_M2_23820_144780 n1_M5_24060_144780 10.000000
R25238 n1_M2_23820_145860 n1_M5_24060_145860 10.000000
R25239 n1_M2_23820_146940 n1_M5_24060_146940 10.000000
R25240 n1_M2_30300_60 n1_M5_30060_60 10.000000
R25241 n1_M2_35700_60 n1_M5_36060_60 10.000000
R25242 n1_M2_42180_60 n1_M5_42060_60 10.000000
R25243 n1_M2_47580_60 n1_M5_48060_60 10.000000
R25244 n1_M2_47580_1140 n1_M5_48060_1140 10.000000
R25245 n1_M2_47580_2220 n1_M5_48060_2220 10.000000
R25246 n1_M2_47580_3300 n1_M5_48060_3300 10.000000
R25247 n1_M2_47580_4380 n1_M5_48060_4380 10.000000
R25248 n1_M2_47580_5460 n1_M5_48060_5460 10.000000
R25249 n1_M2_47580_6540 n1_M5_48060_6540 10.000000
R25250 n1_M2_47580_7620 n1_M5_48060_7620 10.000000
R25251 n1_M2_47580_8700 n1_M5_48060_8700 10.000000
R25252 n1_M2_47580_9780 n1_M5_48060_9780 10.000000
R25253 n1_M2_47580_10860 n1_M5_48060_10860 10.000000
R25254 n1_M2_47580_11940 n1_M5_48060_11940 10.000000
R25255 n1_M2_47580_13020 n1_M5_48060_13020 10.000000
R25256 n1_M2_47580_14100 n1_M5_48060_14100 10.000000
R25257 n1_M2_47580_15180 n1_M5_48060_15180 10.000000
R25258 n1_M2_47580_16260 n1_M5_48060_16260 10.000000
R25259 n1_M2_47580_17340 n1_M5_48060_17340 10.000000
R25260 n1_M2_47580_18420 n1_M5_48060_18420 10.000000
R25261 n1_M2_47580_19500 n1_M5_48060_19500 10.000000
R25262 n1_M2_47580_20580 n1_M5_48060_20580 10.000000
R25263 n1_M2_47580_21660 n1_M5_48060_21660 10.000000
R25264 n1_M2_47580_22740 n1_M5_48060_22740 10.000000
R25265 n1_M2_47580_23820 n1_M5_48060_23820 10.000000
R25266 n1_M2_47580_24900 n1_M5_48060_24900 10.000000
R25267 n1_M2_47580_25980 n1_M5_48060_25980 10.000000
R25268 n1_M2_47580_27060 n1_M5_48060_27060 10.000000
R25269 n1_M2_47580_28140 n1_M5_48060_28140 10.000000
R25270 n1_M2_47580_29220 n1_M5_48060_29220 10.000000
R25271 n1_M2_47580_30300 n1_M5_48060_30300 10.000000
R25272 n1_M2_47580_31380 n1_M5_48060_31380 10.000000
R25273 n1_M2_47580_32460 n1_M5_48060_32460 10.000000
R25274 n1_M2_47580_33540 n1_M5_48060_33540 10.000000
R25275 n1_M2_47580_34620 n1_M5_48060_34620 10.000000
R25276 n1_M2_47580_35700 n1_M5_48060_35700 10.000000
R25277 n1_M2_47580_36780 n1_M5_48060_36780 10.000000
R25278 n1_M2_47580_37860 n1_M5_48060_37860 10.000000
R25279 n1_M2_47580_38940 n1_M5_48060_38940 10.000000
R25280 n1_M2_47580_40020 n1_M5_48060_40020 10.000000
R25281 n1_M2_47580_41100 n1_M5_48060_41100 10.000000
R25282 n1_M2_47580_42180 n1_M5_48060_42180 10.000000
R25283 n1_M2_47580_43260 n1_M5_48060_43260 10.000000
R25284 n1_M2_47580_44340 n1_M5_48060_44340 10.000000
R25285 n1_M2_47580_45420 n1_M5_48060_45420 10.000000
R25286 n1_M2_47580_46500 n1_M5_48060_46500 10.000000
R25287 n1_M2_47580_47580 n1_M5_48060_47580 10.000000
R25288 n1_M2_47580_48660 n1_M5_48060_48660 10.000000
R25289 n1_M2_47580_49740 n1_M5_48060_49740 10.000000
R25290 n1_M2_47580_50820 n1_M5_48060_50820 10.000000
R25291 n1_M2_47580_51900 n1_M5_48060_51900 10.000000
R25292 n1_M2_47580_52980 n1_M5_48060_52980 10.000000
R25293 n1_M2_47580_54060 n1_M5_48060_54060 10.000000
R25294 n1_M2_47580_55140 n1_M5_48060_55140 10.000000
R25295 n1_M2_47580_56220 n1_M5_48060_56220 10.000000
R25296 n1_M2_47580_57300 n1_M5_48060_57300 10.000000
R25297 n1_M2_47580_58380 n1_M5_48060_58380 10.000000
R25298 n1_M2_47580_59460 n1_M5_48060_59460 10.000000
R25299 n1_M2_47580_60540 n1_M5_48060_60540 10.000000
R25300 n1_M2_47580_61620 n1_M5_48060_61620 10.000000
R25301 n1_M2_47580_62700 n1_M5_48060_62700 10.000000
R25302 n1_M2_47580_63780 n1_M5_48060_63780 10.000000
R25303 n1_M2_47580_64860 n1_M5_48060_64860 10.000000
R25304 n1_M2_47580_65940 n1_M5_48060_65940 10.000000
R25305 n1_M2_47580_67020 n1_M5_48060_67020 10.000000
R25306 n1_M2_47580_68100 n1_M5_48060_68100 10.000000
R25307 n1_M2_47580_69180 n1_M5_48060_69180 10.000000
R25308 n1_M2_47580_70260 n1_M5_48060_70260 10.000000
R25309 n1_M2_47580_71340 n1_M5_48060_71340 10.000000
R25310 n1_M2_47580_72420 n1_M5_48060_72420 10.000000
R25311 n1_M2_47580_73500 n1_M5_48060_73500 10.000000
R25312 n1_M2_47580_74580 n1_M5_48060_74580 10.000000
R25313 n1_M2_47580_75660 n1_M5_48060_75660 10.000000
R25314 n1_M2_47580_76740 n1_M5_48060_76740 10.000000
R25315 n1_M2_47580_77820 n1_M5_48060_77820 10.000000
R25316 n1_M2_47580_78900 n1_M5_48060_78900 10.000000
R25317 n1_M2_47580_79980 n1_M5_48060_79980 10.000000
R25318 n1_M2_47580_81060 n1_M5_48060_81060 10.000000
R25319 n1_M2_47580_82140 n1_M5_48060_82140 10.000000
R25320 n1_M2_47580_83220 n1_M5_48060_83220 10.000000
R25321 n1_M2_47580_84300 n1_M5_48060_84300 10.000000
R25322 n1_M2_47580_85380 n1_M5_48060_85380 10.000000
R25323 n1_M2_47580_86460 n1_M5_48060_86460 10.000000
R25324 n1_M2_47580_87540 n1_M5_48060_87540 10.000000
R25325 n1_M2_47580_88620 n1_M5_48060_88620 10.000000
R25326 n1_M2_47580_89700 n1_M5_48060_89700 10.000000
R25327 n1_M2_47580_90780 n1_M5_48060_90780 10.000000
R25328 n1_M2_47580_91860 n1_M5_48060_91860 10.000000
R25329 n1_M2_47580_92940 n1_M5_48060_92940 10.000000
R25330 n1_M2_47580_94020 n1_M5_48060_94020 10.000000
R25331 n1_M2_47580_95100 n1_M5_48060_95100 10.000000
R25332 n1_M2_47580_96180 n1_M5_48060_96180 10.000000
R25333 n1_M2_47580_97260 n1_M5_48060_97260 10.000000
R25334 n1_M2_47580_98340 n1_M5_48060_98340 10.000000
R25335 n1_M2_47580_99420 n1_M5_48060_99420 10.000000
R25336 n1_M2_47580_100500 n1_M5_48060_100500 10.000000
R25337 n1_M2_47580_101580 n1_M5_48060_101580 10.000000
R25338 n1_M2_47580_102660 n1_M5_48060_102660 10.000000
R25339 n1_M2_47580_103740 n1_M5_48060_103740 10.000000
R25340 n1_M2_47580_104820 n1_M5_48060_104820 10.000000
R25341 n1_M2_47580_105900 n1_M5_48060_105900 10.000000
R25342 n1_M2_47580_106980 n1_M5_48060_106980 10.000000
R25343 n1_M2_47580_108060 n1_M5_48060_108060 10.000000
R25344 n1_M2_47580_109140 n1_M5_48060_109140 10.000000
R25345 n1_M2_47580_110220 n1_M5_48060_110220 10.000000
R25346 n1_M2_47580_111300 n1_M5_48060_111300 10.000000
R25347 n1_M2_47580_112380 n1_M5_48060_112380 10.000000
R25348 n1_M2_47580_113460 n1_M5_48060_113460 10.000000
R25349 n1_M2_47580_114540 n1_M5_48060_114540 10.000000
R25350 n1_M2_47580_115620 n1_M5_48060_115620 10.000000
R25351 n1_M2_47580_116700 n1_M5_48060_116700 10.000000
R25352 n1_M2_47580_117780 n1_M5_48060_117780 10.000000
R25353 n1_M2_47580_118860 n1_M5_48060_118860 10.000000
R25354 n1_M2_47580_119940 n1_M5_48060_119940 10.000000
R25355 n1_M2_47580_121020 n1_M5_48060_121020 10.000000
R25356 n1_M2_47580_122100 n1_M5_48060_122100 10.000000
R25357 n1_M2_47580_123180 n1_M5_48060_123180 10.000000
R25358 n1_M2_47580_124260 n1_M5_48060_124260 10.000000
R25359 n1_M2_47580_125340 n1_M5_48060_125340 10.000000
R25360 n1_M2_47580_126420 n1_M5_48060_126420 10.000000
R25361 n1_M2_47580_127500 n1_M5_48060_127500 10.000000
R25362 n1_M2_47580_128580 n1_M5_48060_128580 10.000000
R25363 n1_M2_47580_129660 n1_M5_48060_129660 10.000000
R25364 n1_M2_47580_130740 n1_M5_48060_130740 10.000000
R25365 n1_M2_47580_131820 n1_M5_48060_131820 10.000000
R25366 n1_M2_47580_132900 n1_M5_48060_132900 10.000000
R25367 n1_M2_47580_133980 n1_M5_48060_133980 10.000000
R25368 n1_M2_47580_135060 n1_M5_48060_135060 10.000000
R25369 n1_M2_47580_136140 n1_M5_48060_136140 10.000000
R25370 n1_M2_47580_137220 n1_M5_48060_137220 10.000000
R25371 n1_M2_47580_138300 n1_M5_48060_138300 10.000000
R25372 n1_M2_47580_139380 n1_M5_48060_139380 10.000000
R25373 n1_M2_47580_140460 n1_M5_48060_140460 10.000000
R25374 n1_M2_47580_141540 n1_M5_48060_141540 10.000000
R25375 n1_M2_47580_142620 n1_M5_48060_142620 10.000000
R25376 n1_M2_47580_143700 n1_M5_48060_143700 10.000000
R25377 n1_M2_47580_144780 n1_M5_48060_144780 10.000000
R25378 n1_M2_47580_145860 n1_M5_48060_145860 10.000000
R25379 n1_M2_47580_146940 n1_M5_48060_146940 10.000000
R25380 n1_M2_54060_60 n1_M5_54060_60 10.000000
R25381 n1_M2_60540_60 n1_M5_60060_60 10.000000
R25382 n1_M2_65940_60 n1_M5_66060_60 10.000000
R25383 n1_M2_72420_60 n1_M5_72060_60 10.000000
R25384 n1_M2_72420_1140 n1_M5_72060_1140 10.000000
R25385 n1_M2_72420_2220 n1_M5_72060_2220 10.000000
R25386 n1_M2_72420_3300 n1_M5_72060_3300 10.000000
R25387 n1_M2_72420_4380 n1_M5_72060_4380 10.000000
R25388 n1_M2_72420_5460 n1_M5_72060_5460 10.000000
R25389 n1_M2_72420_6540 n1_M5_72060_6540 10.000000
R25390 n1_M2_72420_7620 n1_M5_72060_7620 10.000000
R25391 n1_M2_72420_8700 n1_M5_72060_8700 10.000000
R25392 n1_M2_72420_9780 n1_M5_72060_9780 10.000000
R25393 n1_M2_72420_10860 n1_M5_72060_10860 10.000000
R25394 n1_M2_72420_11940 n1_M5_72060_11940 10.000000
R25395 n1_M2_72420_13020 n1_M5_72060_13020 10.000000
R25396 n1_M2_72420_14100 n1_M5_72060_14100 10.000000
R25397 n1_M2_72420_15180 n1_M5_72060_15180 10.000000
R25398 n1_M2_72420_16260 n1_M5_72060_16260 10.000000
R25399 n1_M2_72420_17340 n1_M5_72060_17340 10.000000
R25400 n1_M2_72420_18420 n1_M5_72060_18420 10.000000
R25401 n1_M2_72420_19500 n1_M5_72060_19500 10.000000
R25402 n1_M2_72420_20580 n1_M5_72060_20580 10.000000
R25403 n1_M2_72420_21660 n1_M5_72060_21660 10.000000
R25404 n1_M2_72420_22740 n1_M5_72060_22740 10.000000
R25405 n1_M2_72420_23820 n1_M5_72060_23820 10.000000
R25406 n1_M2_72420_24900 n1_M5_72060_24900 10.000000
R25407 n1_M2_72420_25980 n1_M5_72060_25980 10.000000
R25408 n1_M2_72420_27060 n1_M5_72060_27060 10.000000
R25409 n1_M2_72420_28140 n1_M5_72060_28140 10.000000
R25410 n1_M2_72420_29220 n1_M5_72060_29220 10.000000
R25411 n1_M2_72420_30300 n1_M5_72060_30300 10.000000
R25412 n1_M2_72420_31380 n1_M5_72060_31380 10.000000
R25413 n1_M2_72420_32460 n1_M5_72060_32460 10.000000
R25414 n1_M2_72420_33540 n1_M5_72060_33540 10.000000
R25415 n1_M2_72420_34620 n1_M5_72060_34620 10.000000
R25416 n1_M2_72420_35700 n1_M5_72060_35700 10.000000
R25417 n1_M2_72420_36780 n1_M5_72060_36780 10.000000
R25418 n1_M2_72420_37860 n1_M5_72060_37860 10.000000
R25419 n1_M2_72420_38940 n1_M5_72060_38940 10.000000
R25420 n1_M2_72420_40020 n1_M5_72060_40020 10.000000
R25421 n1_M2_72420_41100 n1_M5_72060_41100 10.000000
R25422 n1_M2_72420_42180 n1_M5_72060_42180 10.000000
R25423 n1_M2_72420_43260 n1_M5_72060_43260 10.000000
R25424 n1_M2_72420_44340 n1_M5_72060_44340 10.000000
R25425 n1_M2_72420_45420 n1_M5_72060_45420 10.000000
R25426 n1_M2_72420_46500 n1_M5_72060_46500 10.000000
R25427 n1_M2_72420_47580 n1_M5_72060_47580 10.000000
R25428 n1_M2_72420_48660 n1_M5_72060_48660 10.000000
R25429 n1_M2_72420_49740 n1_M5_72060_49740 10.000000
R25430 n1_M2_72420_50820 n1_M5_72060_50820 10.000000
R25431 n1_M2_72420_51900 n1_M5_72060_51900 10.000000
R25432 n1_M2_72420_52980 n1_M5_72060_52980 10.000000
R25433 n1_M2_72420_54060 n1_M5_72060_54060 10.000000
R25434 n1_M2_72420_55140 n1_M5_72060_55140 10.000000
R25435 n1_M2_72420_56220 n1_M5_72060_56220 10.000000
R25436 n1_M2_72420_57300 n1_M5_72060_57300 10.000000
R25437 n1_M2_72420_58380 n1_M5_72060_58380 10.000000
R25438 n1_M2_72420_59460 n1_M5_72060_59460 10.000000
R25439 n1_M2_72420_60540 n1_M5_72060_60540 10.000000
R25440 n1_M2_72420_61620 n1_M5_72060_61620 10.000000
R25441 n1_M2_72420_62700 n1_M5_72060_62700 10.000000
R25442 n1_M2_72420_63780 n1_M5_72060_63780 10.000000
R25443 n1_M2_72420_64860 n1_M5_72060_64860 10.000000
R25444 n1_M2_72420_65940 n1_M5_72060_65940 10.000000
R25445 n1_M2_72420_67020 n1_M5_72060_67020 10.000000
R25446 n1_M2_72420_68100 n1_M5_72060_68100 10.000000
R25447 n1_M2_72420_69180 n1_M5_72060_69180 10.000000
R25448 n1_M2_72420_70260 n1_M5_72060_70260 10.000000
R25449 n1_M2_72420_71340 n1_M5_72060_71340 10.000000
R25450 n1_M2_72420_72420 n1_M5_72060_72420 10.000000
R25451 n1_M2_72420_73500 n1_M5_72060_73500 10.000000
R25452 n1_M2_72420_74580 n1_M5_72060_74580 10.000000
R25453 n1_M2_72420_75660 n1_M5_72060_75660 10.000000
R25454 n1_M2_72420_76740 n1_M5_72060_76740 10.000000
R25455 n1_M2_72420_77820 n1_M5_72060_77820 10.000000
R25456 n1_M2_72420_78900 n1_M5_72060_78900 10.000000
R25457 n1_M2_72420_79980 n1_M5_72060_79980 10.000000
R25458 n1_M2_72420_81060 n1_M5_72060_81060 10.000000
R25459 n1_M2_72420_82140 n1_M5_72060_82140 10.000000
R25460 n1_M2_72420_83220 n1_M5_72060_83220 10.000000
R25461 n1_M2_72420_84300 n1_M5_72060_84300 10.000000
R25462 n1_M2_72420_85380 n1_M5_72060_85380 10.000000
R25463 n1_M2_72420_86460 n1_M5_72060_86460 10.000000
R25464 n1_M2_72420_87540 n1_M5_72060_87540 10.000000
R25465 n1_M2_72420_88620 n1_M5_72060_88620 10.000000
R25466 n1_M2_72420_89700 n1_M5_72060_89700 10.000000
R25467 n1_M2_72420_90780 n1_M5_72060_90780 10.000000
R25468 n1_M2_72420_91860 n1_M5_72060_91860 10.000000
R25469 n1_M2_72420_92940 n1_M5_72060_92940 10.000000
R25470 n1_M2_72420_94020 n1_M5_72060_94020 10.000000
R25471 n1_M2_72420_95100 n1_M5_72060_95100 10.000000
R25472 n1_M2_72420_96180 n1_M5_72060_96180 10.000000
R25473 n1_M2_72420_97260 n1_M5_72060_97260 10.000000
R25474 n1_M2_72420_98340 n1_M5_72060_98340 10.000000
R25475 n1_M2_72420_99420 n1_M5_72060_99420 10.000000
R25476 n1_M2_72420_100500 n1_M5_72060_100500 10.000000
R25477 n1_M2_72420_101580 n1_M5_72060_101580 10.000000
R25478 n1_M2_72420_102660 n1_M5_72060_102660 10.000000
R25479 n1_M2_72420_103740 n1_M5_72060_103740 10.000000
R25480 n1_M2_72420_104820 n1_M5_72060_104820 10.000000
R25481 n1_M2_72420_105900 n1_M5_72060_105900 10.000000
R25482 n1_M2_72420_106980 n1_M5_72060_106980 10.000000
R25483 n1_M2_72420_108060 n1_M5_72060_108060 10.000000
R25484 n1_M2_72420_109140 n1_M5_72060_109140 10.000000
R25485 n1_M2_72420_110220 n1_M5_72060_110220 10.000000
R25486 n1_M2_72420_111300 n1_M5_72060_111300 10.000000
R25487 n1_M2_72420_112380 n1_M5_72060_112380 10.000000
R25488 n1_M2_72420_113460 n1_M5_72060_113460 10.000000
R25489 n1_M2_72420_114540 n1_M5_72060_114540 10.000000
R25490 n1_M2_72420_115620 n1_M5_72060_115620 10.000000
R25491 n1_M2_72420_116700 n1_M5_72060_116700 10.000000
R25492 n1_M2_72420_117780 n1_M5_72060_117780 10.000000
R25493 n1_M2_72420_118860 n1_M5_72060_118860 10.000000
R25494 n1_M2_72420_119940 n1_M5_72060_119940 10.000000
R25495 n1_M2_72420_121020 n1_M5_72060_121020 10.000000
R25496 n1_M2_72420_122100 n1_M5_72060_122100 10.000000
R25497 n1_M2_72420_123180 n1_M5_72060_123180 10.000000
R25498 n1_M2_72420_124260 n1_M5_72060_124260 10.000000
R25499 n1_M2_72420_125340 n1_M5_72060_125340 10.000000
R25500 n1_M2_72420_126420 n1_M5_72060_126420 10.000000
R25501 n1_M2_72420_127500 n1_M5_72060_127500 10.000000
R25502 n1_M2_72420_128580 n1_M5_72060_128580 10.000000
R25503 n1_M2_72420_129660 n1_M5_72060_129660 10.000000
R25504 n1_M2_72420_130740 n1_M5_72060_130740 10.000000
R25505 n1_M2_72420_131820 n1_M5_72060_131820 10.000000
R25506 n1_M2_72420_132900 n1_M5_72060_132900 10.000000
R25507 n1_M2_72420_133980 n1_M5_72060_133980 10.000000
R25508 n1_M2_72420_135060 n1_M5_72060_135060 10.000000
R25509 n1_M2_72420_136140 n1_M5_72060_136140 10.000000
R25510 n1_M2_72420_137220 n1_M5_72060_137220 10.000000
R25511 n1_M2_72420_138300 n1_M5_72060_138300 10.000000
R25512 n1_M2_72420_139380 n1_M5_72060_139380 10.000000
R25513 n1_M2_72420_140460 n1_M5_72060_140460 10.000000
R25514 n1_M2_72420_141540 n1_M5_72060_141540 10.000000
R25515 n1_M2_72420_142620 n1_M5_72060_142620 10.000000
R25516 n1_M2_72420_143700 n1_M5_72060_143700 10.000000
R25517 n1_M2_72420_144780 n1_M5_72060_144780 10.000000
R25518 n1_M2_72420_145860 n1_M5_72060_145860 10.000000
R25519 n1_M2_72420_146940 n1_M5_72060_146940 10.000000
R25520 n1_M2_77820_60 n1_M5_78060_60 10.000000
R25521 n1_M2_84300_60 n1_M5_84060_60 10.000000
R25522 n1_M2_89700_60 n1_M5_90060_60 10.000000
R25523 n1_M2_96180_60 n1_M5_96060_60 10.000000
R25524 n1_M2_96180_1140 n1_M5_96060_1140 10.000000
R25525 n1_M2_96180_2220 n1_M5_96060_2220 10.000000
R25526 n1_M2_96180_3300 n1_M5_96060_3300 10.000000
R25527 n1_M2_96180_4380 n1_M5_96060_4380 10.000000
R25528 n1_M2_96180_5460 n1_M5_96060_5460 10.000000
R25529 n1_M2_96180_6540 n1_M5_96060_6540 10.000000
R25530 n1_M2_96180_7620 n1_M5_96060_7620 10.000000
R25531 n1_M2_96180_8700 n1_M5_96060_8700 10.000000
R25532 n1_M2_96180_9780 n1_M5_96060_9780 10.000000
R25533 n1_M2_96180_10860 n1_M5_96060_10860 10.000000
R25534 n1_M2_96180_11940 n1_M5_96060_11940 10.000000
R25535 n1_M2_96180_13020 n1_M5_96060_13020 10.000000
R25536 n1_M2_96180_14100 n1_M5_96060_14100 10.000000
R25537 n1_M2_96180_15180 n1_M5_96060_15180 10.000000
R25538 n1_M2_96180_16260 n1_M5_96060_16260 10.000000
R25539 n1_M2_96180_17340 n1_M5_96060_17340 10.000000
R25540 n1_M2_96180_18420 n1_M5_96060_18420 10.000000
R25541 n1_M2_96180_19500 n1_M5_96060_19500 10.000000
R25542 n1_M2_96180_20580 n1_M5_96060_20580 10.000000
R25543 n1_M2_96180_21660 n1_M5_96060_21660 10.000000
R25544 n1_M2_96180_22740 n1_M5_96060_22740 10.000000
R25545 n1_M2_96180_23820 n1_M5_96060_23820 10.000000
R25546 n1_M2_96180_24900 n1_M5_96060_24900 10.000000
R25547 n1_M2_96180_25980 n1_M5_96060_25980 10.000000
R25548 n1_M2_96180_27060 n1_M5_96060_27060 10.000000
R25549 n1_M2_96180_28140 n1_M5_96060_28140 10.000000
R25550 n1_M2_96180_29220 n1_M5_96060_29220 10.000000
R25551 n1_M2_96180_30300 n1_M5_96060_30300 10.000000
R25552 n1_M2_96180_31380 n1_M5_96060_31380 10.000000
R25553 n1_M2_96180_32460 n1_M5_96060_32460 10.000000
R25554 n1_M2_96180_33540 n1_M5_96060_33540 10.000000
R25555 n1_M2_96180_34620 n1_M5_96060_34620 10.000000
R25556 n1_M2_96180_35700 n1_M5_96060_35700 10.000000
R25557 n1_M2_96180_36780 n1_M5_96060_36780 10.000000
R25558 n1_M2_96180_37860 n1_M5_96060_37860 10.000000
R25559 n1_M2_96180_38940 n1_M5_96060_38940 10.000000
R25560 n1_M2_96180_40020 n1_M5_96060_40020 10.000000
R25561 n1_M2_96180_41100 n1_M5_96060_41100 10.000000
R25562 n1_M2_96180_42180 n1_M5_96060_42180 10.000000
R25563 n1_M2_96180_43260 n1_M5_96060_43260 10.000000
R25564 n1_M2_96180_44340 n1_M5_96060_44340 10.000000
R25565 n1_M2_96180_45420 n1_M5_96060_45420 10.000000
R25566 n1_M2_96180_46500 n1_M5_96060_46500 10.000000
R25567 n1_M2_96180_47580 n1_M5_96060_47580 10.000000
R25568 n1_M2_96180_48660 n1_M5_96060_48660 10.000000
R25569 n1_M2_96180_49740 n1_M5_96060_49740 10.000000
R25570 n1_M2_96180_50820 n1_M5_96060_50820 10.000000
R25571 n1_M2_96180_51900 n1_M5_96060_51900 10.000000
R25572 n1_M2_96180_52980 n1_M5_96060_52980 10.000000
R25573 n1_M2_96180_54060 n1_M5_96060_54060 10.000000
R25574 n1_M2_96180_55140 n1_M5_96060_55140 10.000000
R25575 n1_M2_96180_56220 n1_M5_96060_56220 10.000000
R25576 n1_M2_96180_57300 n1_M5_96060_57300 10.000000
R25577 n1_M2_96180_58380 n1_M5_96060_58380 10.000000
R25578 n1_M2_96180_59460 n1_M5_96060_59460 10.000000
R25579 n1_M2_96180_60540 n1_M5_96060_60540 10.000000
R25580 n1_M2_96180_61620 n1_M5_96060_61620 10.000000
R25581 n1_M2_96180_62700 n1_M5_96060_62700 10.000000
R25582 n1_M2_96180_63780 n1_M5_96060_63780 10.000000
R25583 n1_M2_96180_64860 n1_M5_96060_64860 10.000000
R25584 n1_M2_96180_65940 n1_M5_96060_65940 10.000000
R25585 n1_M2_96180_67020 n1_M5_96060_67020 10.000000
R25586 n1_M2_96180_68100 n1_M5_96060_68100 10.000000
R25587 n1_M2_96180_69180 n1_M5_96060_69180 10.000000
R25588 n1_M2_96180_70260 n1_M5_96060_70260 10.000000
R25589 n1_M2_96180_71340 n1_M5_96060_71340 10.000000
R25590 n1_M2_96180_72420 n1_M5_96060_72420 10.000000
R25591 n1_M2_96180_73500 n1_M5_96060_73500 10.000000
R25592 n1_M2_96180_74580 n1_M5_96060_74580 10.000000
R25593 n1_M2_96180_75660 n1_M5_96060_75660 10.000000
R25594 n1_M2_96180_76740 n1_M5_96060_76740 10.000000
R25595 n1_M2_96180_77820 n1_M5_96060_77820 10.000000
R25596 n1_M2_96180_78900 n1_M5_96060_78900 10.000000
R25597 n1_M2_96180_79980 n1_M5_96060_79980 10.000000
R25598 n1_M2_96180_81060 n1_M5_96060_81060 10.000000
R25599 n1_M2_96180_82140 n1_M5_96060_82140 10.000000
R25600 n1_M2_96180_83220 n1_M5_96060_83220 10.000000
R25601 n1_M2_96180_84300 n1_M5_96060_84300 10.000000
R25602 n1_M2_96180_85380 n1_M5_96060_85380 10.000000
R25603 n1_M2_96180_86460 n1_M5_96060_86460 10.000000
R25604 n1_M2_96180_87540 n1_M5_96060_87540 10.000000
R25605 n1_M2_96180_88620 n1_M5_96060_88620 10.000000
R25606 n1_M2_96180_89700 n1_M5_96060_89700 10.000000
R25607 n1_M2_96180_90780 n1_M5_96060_90780 10.000000
R25608 n1_M2_96180_91860 n1_M5_96060_91860 10.000000
R25609 n1_M2_96180_92940 n1_M5_96060_92940 10.000000
R25610 n1_M2_96180_94020 n1_M5_96060_94020 10.000000
R25611 n1_M2_96180_95100 n1_M5_96060_95100 10.000000
R25612 n1_M2_96180_96180 n1_M5_96060_96180 10.000000
R25613 n1_M2_96180_97260 n1_M5_96060_97260 10.000000
R25614 n1_M2_96180_98340 n1_M5_96060_98340 10.000000
R25615 n1_M2_96180_99420 n1_M5_96060_99420 10.000000
R25616 n1_M2_96180_100500 n1_M5_96060_100500 10.000000
R25617 n1_M2_96180_101580 n1_M5_96060_101580 10.000000
R25618 n1_M2_96180_102660 n1_M5_96060_102660 10.000000
R25619 n1_M2_96180_103740 n1_M5_96060_103740 10.000000
R25620 n1_M2_96180_104820 n1_M5_96060_104820 10.000000
R25621 n1_M2_96180_105900 n1_M5_96060_105900 10.000000
R25622 n1_M2_96180_106980 n1_M5_96060_106980 10.000000
R25623 n1_M2_96180_108060 n1_M5_96060_108060 10.000000
R25624 n1_M2_96180_109140 n1_M5_96060_109140 10.000000
R25625 n1_M2_96180_110220 n1_M5_96060_110220 10.000000
R25626 n1_M2_96180_111300 n1_M5_96060_111300 10.000000
R25627 n1_M2_96180_112380 n1_M5_96060_112380 10.000000
R25628 n1_M2_96180_113460 n1_M5_96060_113460 10.000000
R25629 n1_M2_96180_114540 n1_M5_96060_114540 10.000000
R25630 n1_M2_96180_115620 n1_M5_96060_115620 10.000000
R25631 n1_M2_96180_116700 n1_M5_96060_116700 10.000000
R25632 n1_M2_96180_117780 n1_M5_96060_117780 10.000000
R25633 n1_M2_96180_118860 n1_M5_96060_118860 10.000000
R25634 n1_M2_96180_119940 n1_M5_96060_119940 10.000000
R25635 n1_M2_96180_121020 n1_M5_96060_121020 10.000000
R25636 n1_M2_96180_122100 n1_M5_96060_122100 10.000000
R25637 n1_M2_96180_123180 n1_M5_96060_123180 10.000000
R25638 n1_M2_96180_124260 n1_M5_96060_124260 10.000000
R25639 n1_M2_96180_125340 n1_M5_96060_125340 10.000000
R25640 n1_M2_96180_126420 n1_M5_96060_126420 10.000000
R25641 n1_M2_96180_127500 n1_M5_96060_127500 10.000000
R25642 n1_M2_96180_128580 n1_M5_96060_128580 10.000000
R25643 n1_M2_96180_129660 n1_M5_96060_129660 10.000000
R25644 n1_M2_96180_130740 n1_M5_96060_130740 10.000000
R25645 n1_M2_96180_131820 n1_M5_96060_131820 10.000000
R25646 n1_M2_96180_132900 n1_M5_96060_132900 10.000000
R25647 n1_M2_96180_133980 n1_M5_96060_133980 10.000000
R25648 n1_M2_96180_135060 n1_M5_96060_135060 10.000000
R25649 n1_M2_96180_136140 n1_M5_96060_136140 10.000000
R25650 n1_M2_96180_137220 n1_M5_96060_137220 10.000000
R25651 n1_M2_96180_138300 n1_M5_96060_138300 10.000000
R25652 n1_M2_96180_139380 n1_M5_96060_139380 10.000000
R25653 n1_M2_96180_140460 n1_M5_96060_140460 10.000000
R25654 n1_M2_96180_141540 n1_M5_96060_141540 10.000000
R25655 n1_M2_96180_142620 n1_M5_96060_142620 10.000000
R25656 n1_M2_96180_143700 n1_M5_96060_143700 10.000000
R25657 n1_M2_96180_144780 n1_M5_96060_144780 10.000000
R25658 n1_M2_96180_145860 n1_M5_96060_145860 10.000000
R25659 n1_M2_96180_146940 n1_M5_96060_146940 10.000000
R25660 n1_M2_101580_60 n1_M5_102060_60 10.000000
R25661 n1_M2_108060_60 n1_M5_108060_60 10.000000
R25662 n1_M2_114540_60 n1_M5_114060_60 10.000000
R25663 n1_M2_119940_60 n1_M5_120060_60 10.000000
R25664 n1_M2_119940_1140 n1_M5_120060_1140 10.000000
R25665 n1_M2_119940_2220 n1_M5_120060_2220 10.000000
R25666 n1_M2_119940_3300 n1_M5_120060_3300 10.000000
R25667 n1_M2_119940_4380 n1_M5_120060_4380 10.000000
R25668 n1_M2_119940_5460 n1_M5_120060_5460 10.000000
R25669 n1_M2_119940_6540 n1_M5_120060_6540 10.000000
R25670 n1_M2_119940_7620 n1_M5_120060_7620 10.000000
R25671 n1_M2_119940_8700 n1_M5_120060_8700 10.000000
R25672 n1_M2_119940_9780 n1_M5_120060_9780 10.000000
R25673 n1_M2_119940_10860 n1_M5_120060_10860 10.000000
R25674 n1_M2_119940_11940 n1_M5_120060_11940 10.000000
R25675 n1_M2_119940_13020 n1_M5_120060_13020 10.000000
R25676 n1_M2_119940_14100 n1_M5_120060_14100 10.000000
R25677 n1_M2_119940_15180 n1_M5_120060_15180 10.000000
R25678 n1_M2_119940_16260 n1_M5_120060_16260 10.000000
R25679 n1_M2_119940_17340 n1_M5_120060_17340 10.000000
R25680 n1_M2_119940_18420 n1_M5_120060_18420 10.000000
R25681 n1_M2_119940_19500 n1_M5_120060_19500 10.000000
R25682 n1_M2_119940_20580 n1_M5_120060_20580 10.000000
R25683 n1_M2_119940_21660 n1_M5_120060_21660 10.000000
R25684 n1_M2_119940_22740 n1_M5_120060_22740 10.000000
R25685 n1_M2_119940_23820 n1_M5_120060_23820 10.000000
R25686 n1_M2_119940_24900 n1_M5_120060_24900 10.000000
R25687 n1_M2_119940_25980 n1_M5_120060_25980 10.000000
R25688 n1_M2_119940_27060 n1_M5_120060_27060 10.000000
R25689 n1_M2_119940_28140 n1_M5_120060_28140 10.000000
R25690 n1_M2_119940_29220 n1_M5_120060_29220 10.000000
R25691 n1_M2_119940_30300 n1_M5_120060_30300 10.000000
R25692 n1_M2_119940_31380 n1_M5_120060_31380 10.000000
R25693 n1_M2_119940_32460 n1_M5_120060_32460 10.000000
R25694 n1_M2_119940_33540 n1_M5_120060_33540 10.000000
R25695 n1_M2_119940_34620 n1_M5_120060_34620 10.000000
R25696 n1_M2_119940_35700 n1_M5_120060_35700 10.000000
R25697 n1_M2_119940_36780 n1_M5_120060_36780 10.000000
R25698 n1_M2_119940_37860 n1_M5_120060_37860 10.000000
R25699 n1_M2_119940_38940 n1_M5_120060_38940 10.000000
R25700 n1_M2_119940_40020 n1_M5_120060_40020 10.000000
R25701 n1_M2_119940_41100 n1_M5_120060_41100 10.000000
R25702 n1_M2_119940_42180 n1_M5_120060_42180 10.000000
R25703 n1_M2_119940_43260 n1_M5_120060_43260 10.000000
R25704 n1_M2_119940_44340 n1_M5_120060_44340 10.000000
R25705 n1_M2_119940_45420 n1_M5_120060_45420 10.000000
R25706 n1_M2_119940_46500 n1_M5_120060_46500 10.000000
R25707 n1_M2_119940_47580 n1_M5_120060_47580 10.000000
R25708 n1_M2_119940_48660 n1_M5_120060_48660 10.000000
R25709 n1_M2_119940_49740 n1_M5_120060_49740 10.000000
R25710 n1_M2_119940_50820 n1_M5_120060_50820 10.000000
R25711 n1_M2_119940_51900 n1_M5_120060_51900 10.000000
R25712 n1_M2_119940_52980 n1_M5_120060_52980 10.000000
R25713 n1_M2_119940_54060 n1_M5_120060_54060 10.000000
R25714 n1_M2_119940_55140 n1_M5_120060_55140 10.000000
R25715 n1_M2_119940_56220 n1_M5_120060_56220 10.000000
R25716 n1_M2_119940_57300 n1_M5_120060_57300 10.000000
R25717 n1_M2_119940_58380 n1_M5_120060_58380 10.000000
R25718 n1_M2_119940_59460 n1_M5_120060_59460 10.000000
R25719 n1_M2_119940_60540 n1_M5_120060_60540 10.000000
R25720 n1_M2_119940_61620 n1_M5_120060_61620 10.000000
R25721 n1_M2_119940_62700 n1_M5_120060_62700 10.000000
R25722 n1_M2_119940_63780 n1_M5_120060_63780 10.000000
R25723 n1_M2_119940_64860 n1_M5_120060_64860 10.000000
R25724 n1_M2_119940_65940 n1_M5_120060_65940 10.000000
R25725 n1_M2_119940_67020 n1_M5_120060_67020 10.000000
R25726 n1_M2_119940_68100 n1_M5_120060_68100 10.000000
R25727 n1_M2_119940_69180 n1_M5_120060_69180 10.000000
R25728 n1_M2_119940_70260 n1_M5_120060_70260 10.000000
R25729 n1_M2_119940_71340 n1_M5_120060_71340 10.000000
R25730 n1_M2_119940_72420 n1_M5_120060_72420 10.000000
R25731 n1_M2_119940_73500 n1_M5_120060_73500 10.000000
R25732 n1_M2_119940_74580 n1_M5_120060_74580 10.000000
R25733 n1_M2_119940_75660 n1_M5_120060_75660 10.000000
R25734 n1_M2_119940_76740 n1_M5_120060_76740 10.000000
R25735 n1_M2_119940_77820 n1_M5_120060_77820 10.000000
R25736 n1_M2_119940_78900 n1_M5_120060_78900 10.000000
R25737 n1_M2_119940_79980 n1_M5_120060_79980 10.000000
R25738 n1_M2_119940_81060 n1_M5_120060_81060 10.000000
R25739 n1_M2_119940_82140 n1_M5_120060_82140 10.000000
R25740 n1_M2_119940_83220 n1_M5_120060_83220 10.000000
R25741 n1_M2_119940_84300 n1_M5_120060_84300 10.000000
R25742 n1_M2_119940_85380 n1_M5_120060_85380 10.000000
R25743 n1_M2_119940_86460 n1_M5_120060_86460 10.000000
R25744 n1_M2_119940_87540 n1_M5_120060_87540 10.000000
R25745 n1_M2_119940_88620 n1_M5_120060_88620 10.000000
R25746 n1_M2_119940_89700 n1_M5_120060_89700 10.000000
R25747 n1_M2_119940_90780 n1_M5_120060_90780 10.000000
R25748 n1_M2_119940_91860 n1_M5_120060_91860 10.000000
R25749 n1_M2_119940_92940 n1_M5_120060_92940 10.000000
R25750 n1_M2_119940_94020 n1_M5_120060_94020 10.000000
R25751 n1_M2_119940_95100 n1_M5_120060_95100 10.000000
R25752 n1_M2_119940_96180 n1_M5_120060_96180 10.000000
R25753 n1_M2_119940_97260 n1_M5_120060_97260 10.000000
R25754 n1_M2_119940_98340 n1_M5_120060_98340 10.000000
R25755 n1_M2_119940_99420 n1_M5_120060_99420 10.000000
R25756 n1_M2_119940_100500 n1_M5_120060_100500 10.000000
R25757 n1_M2_119940_101580 n1_M5_120060_101580 10.000000
R25758 n1_M2_119940_102660 n1_M5_120060_102660 10.000000
R25759 n1_M2_119940_103740 n1_M5_120060_103740 10.000000
R25760 n1_M2_119940_104820 n1_M5_120060_104820 10.000000
R25761 n1_M2_119940_105900 n1_M5_120060_105900 10.000000
R25762 n1_M2_119940_106980 n1_M5_120060_106980 10.000000
R25763 n1_M2_119940_108060 n1_M5_120060_108060 10.000000
R25764 n1_M2_119940_109140 n1_M5_120060_109140 10.000000
R25765 n1_M2_119940_110220 n1_M5_120060_110220 10.000000
R25766 n1_M2_119940_111300 n1_M5_120060_111300 10.000000
R25767 n1_M2_119940_112380 n1_M5_120060_112380 10.000000
R25768 n1_M2_119940_113460 n1_M5_120060_113460 10.000000
R25769 n1_M2_119940_114540 n1_M5_120060_114540 10.000000
R25770 n1_M2_119940_115620 n1_M5_120060_115620 10.000000
R25771 n1_M2_119940_116700 n1_M5_120060_116700 10.000000
R25772 n1_M2_119940_117780 n1_M5_120060_117780 10.000000
R25773 n1_M2_119940_118860 n1_M5_120060_118860 10.000000
R25774 n1_M2_119940_119940 n1_M5_120060_119940 10.000000
R25775 n1_M2_119940_121020 n1_M5_120060_121020 10.000000
R25776 n1_M2_119940_122100 n1_M5_120060_122100 10.000000
R25777 n1_M2_119940_123180 n1_M5_120060_123180 10.000000
R25778 n1_M2_119940_124260 n1_M5_120060_124260 10.000000
R25779 n1_M2_119940_125340 n1_M5_120060_125340 10.000000
R25780 n1_M2_119940_126420 n1_M5_120060_126420 10.000000
R25781 n1_M2_119940_127500 n1_M5_120060_127500 10.000000
R25782 n1_M2_119940_128580 n1_M5_120060_128580 10.000000
R25783 n1_M2_119940_129660 n1_M5_120060_129660 10.000000
R25784 n1_M2_119940_130740 n1_M5_120060_130740 10.000000
R25785 n1_M2_119940_131820 n1_M5_120060_131820 10.000000
R25786 n1_M2_119940_132900 n1_M5_120060_132900 10.000000
R25787 n1_M2_119940_133980 n1_M5_120060_133980 10.000000
R25788 n1_M2_119940_135060 n1_M5_120060_135060 10.000000
R25789 n1_M2_119940_136140 n1_M5_120060_136140 10.000000
R25790 n1_M2_119940_137220 n1_M5_120060_137220 10.000000
R25791 n1_M2_119940_138300 n1_M5_120060_138300 10.000000
R25792 n1_M2_119940_139380 n1_M5_120060_139380 10.000000
R25793 n1_M2_119940_140460 n1_M5_120060_140460 10.000000
R25794 n1_M2_119940_141540 n1_M5_120060_141540 10.000000
R25795 n1_M2_119940_142620 n1_M5_120060_142620 10.000000
R25796 n1_M2_119940_143700 n1_M5_120060_143700 10.000000
R25797 n1_M2_119940_144780 n1_M5_120060_144780 10.000000
R25798 n1_M2_119940_145860 n1_M5_120060_145860 10.000000
R25799 n1_M2_119940_146940 n1_M5_120060_146940 10.000000
R25800 n1_M2_126420_60 n1_M5_126060_60 10.000000
R25801 n1_M2_131820_60 n1_M5_132060_60 10.000000
R25802 n1_M2_138300_60 n1_M5_138060_60 10.000000
R25803 n1_M2_143700_60 n1_M5_144060_60 10.000000
R25804 n1_M2_143700_1140 n1_M5_144060_1140 10.000000
R25805 n1_M2_143700_2220 n1_M5_144060_2220 10.000000
R25806 n1_M2_143700_3300 n1_M5_144060_3300 10.000000
R25807 n1_M2_143700_4380 n1_M5_144060_4380 10.000000
R25808 n1_M2_143700_5460 n1_M5_144060_5460 10.000000
R25809 n1_M2_143700_6540 n1_M5_144060_6540 10.000000
R25810 n1_M2_143700_7620 n1_M5_144060_7620 10.000000
R25811 n1_M2_143700_8700 n1_M5_144060_8700 10.000000
R25812 n1_M2_143700_9780 n1_M5_144060_9780 10.000000
R25813 n1_M2_143700_10860 n1_M5_144060_10860 10.000000
R25814 n1_M2_143700_11940 n1_M5_144060_11940 10.000000
R25815 n1_M2_143700_13020 n1_M5_144060_13020 10.000000
R25816 n1_M2_143700_14100 n1_M5_144060_14100 10.000000
R25817 n1_M2_143700_15180 n1_M5_144060_15180 10.000000
R25818 n1_M2_143700_16260 n1_M5_144060_16260 10.000000
R25819 n1_M2_143700_17340 n1_M5_144060_17340 10.000000
R25820 n1_M2_143700_18420 n1_M5_144060_18420 10.000000
R25821 n1_M2_143700_19500 n1_M5_144060_19500 10.000000
R25822 n1_M2_143700_20580 n1_M5_144060_20580 10.000000
R25823 n1_M2_143700_21660 n1_M5_144060_21660 10.000000
R25824 n1_M2_143700_22740 n1_M5_144060_22740 10.000000
R25825 n1_M2_143700_23820 n1_M5_144060_23820 10.000000
R25826 n1_M2_143700_24900 n1_M5_144060_24900 10.000000
R25827 n1_M2_143700_25980 n1_M5_144060_25980 10.000000
R25828 n1_M2_143700_27060 n1_M5_144060_27060 10.000000
R25829 n1_M2_143700_28140 n1_M5_144060_28140 10.000000
R25830 n1_M2_143700_29220 n1_M5_144060_29220 10.000000
R25831 n1_M2_143700_30300 n1_M5_144060_30300 10.000000
R25832 n1_M2_143700_31380 n1_M5_144060_31380 10.000000
R25833 n1_M2_143700_32460 n1_M5_144060_32460 10.000000
R25834 n1_M2_143700_33540 n1_M5_144060_33540 10.000000
R25835 n1_M2_143700_34620 n1_M5_144060_34620 10.000000
R25836 n1_M2_143700_35700 n1_M5_144060_35700 10.000000
R25837 n1_M2_143700_36780 n1_M5_144060_36780 10.000000
R25838 n1_M2_143700_37860 n1_M5_144060_37860 10.000000
R25839 n1_M2_143700_38940 n1_M5_144060_38940 10.000000
R25840 n1_M2_143700_40020 n1_M5_144060_40020 10.000000
R25841 n1_M2_143700_41100 n1_M5_144060_41100 10.000000
R25842 n1_M2_143700_42180 n1_M5_144060_42180 10.000000
R25843 n1_M2_143700_43260 n1_M5_144060_43260 10.000000
R25844 n1_M2_143700_44340 n1_M5_144060_44340 10.000000
R25845 n1_M2_143700_45420 n1_M5_144060_45420 10.000000
R25846 n1_M2_143700_46500 n1_M5_144060_46500 10.000000
R25847 n1_M2_143700_47580 n1_M5_144060_47580 10.000000
R25848 n1_M2_143700_48660 n1_M5_144060_48660 10.000000
R25849 n1_M2_143700_49740 n1_M5_144060_49740 10.000000
R25850 n1_M2_143700_50820 n1_M5_144060_50820 10.000000
R25851 n1_M2_143700_51900 n1_M5_144060_51900 10.000000
R25852 n1_M2_143700_52980 n1_M5_144060_52980 10.000000
R25853 n1_M2_143700_54060 n1_M5_144060_54060 10.000000
R25854 n1_M2_143700_55140 n1_M5_144060_55140 10.000000
R25855 n1_M2_143700_56220 n1_M5_144060_56220 10.000000
R25856 n1_M2_143700_57300 n1_M5_144060_57300 10.000000
R25857 n1_M2_143700_58380 n1_M5_144060_58380 10.000000
R25858 n1_M2_143700_59460 n1_M5_144060_59460 10.000000
R25859 n1_M2_143700_60540 n1_M5_144060_60540 10.000000
R25860 n1_M2_143700_61620 n1_M5_144060_61620 10.000000
R25861 n1_M2_143700_62700 n1_M5_144060_62700 10.000000
R25862 n1_M2_143700_63780 n1_M5_144060_63780 10.000000
R25863 n1_M2_143700_64860 n1_M5_144060_64860 10.000000
R25864 n1_M2_143700_65940 n1_M5_144060_65940 10.000000
R25865 n1_M2_143700_67020 n1_M5_144060_67020 10.000000
R25866 n1_M2_143700_68100 n1_M5_144060_68100 10.000000
R25867 n1_M2_143700_69180 n1_M5_144060_69180 10.000000
R25868 n1_M2_143700_70260 n1_M5_144060_70260 10.000000
R25869 n1_M2_143700_71340 n1_M5_144060_71340 10.000000
R25870 n1_M2_143700_72420 n1_M5_144060_72420 10.000000
R25871 n1_M2_143700_73500 n1_M5_144060_73500 10.000000
R25872 n1_M2_143700_74580 n1_M5_144060_74580 10.000000
R25873 n1_M2_143700_75660 n1_M5_144060_75660 10.000000
R25874 n1_M2_143700_76740 n1_M5_144060_76740 10.000000
R25875 n1_M2_143700_77820 n1_M5_144060_77820 10.000000
R25876 n1_M2_143700_78900 n1_M5_144060_78900 10.000000
R25877 n1_M2_143700_79980 n1_M5_144060_79980 10.000000
R25878 n1_M2_143700_81060 n1_M5_144060_81060 10.000000
R25879 n1_M2_143700_82140 n1_M5_144060_82140 10.000000
R25880 n1_M2_143700_83220 n1_M5_144060_83220 10.000000
R25881 n1_M2_143700_84300 n1_M5_144060_84300 10.000000
R25882 n1_M2_143700_85380 n1_M5_144060_85380 10.000000
R25883 n1_M2_143700_86460 n1_M5_144060_86460 10.000000
R25884 n1_M2_143700_87540 n1_M5_144060_87540 10.000000
R25885 n1_M2_143700_88620 n1_M5_144060_88620 10.000000
R25886 n1_M2_143700_89700 n1_M5_144060_89700 10.000000
R25887 n1_M2_143700_90780 n1_M5_144060_90780 10.000000
R25888 n1_M2_143700_91860 n1_M5_144060_91860 10.000000
R25889 n1_M2_143700_92940 n1_M5_144060_92940 10.000000
R25890 n1_M2_143700_94020 n1_M5_144060_94020 10.000000
R25891 n1_M2_143700_95100 n1_M5_144060_95100 10.000000
R25892 n1_M2_143700_96180 n1_M5_144060_96180 10.000000
R25893 n1_M2_143700_97260 n1_M5_144060_97260 10.000000
R25894 n1_M2_143700_98340 n1_M5_144060_98340 10.000000
R25895 n1_M2_143700_99420 n1_M5_144060_99420 10.000000
R25896 n1_M2_143700_100500 n1_M5_144060_100500 10.000000
R25897 n1_M2_143700_101580 n1_M5_144060_101580 10.000000
R25898 n1_M2_143700_102660 n1_M5_144060_102660 10.000000
R25899 n1_M2_143700_103740 n1_M5_144060_103740 10.000000
R25900 n1_M2_143700_104820 n1_M5_144060_104820 10.000000
R25901 n1_M2_143700_105900 n1_M5_144060_105900 10.000000
R25902 n1_M2_143700_106980 n1_M5_144060_106980 10.000000
R25903 n1_M2_143700_108060 n1_M5_144060_108060 10.000000
R25904 n1_M2_143700_109140 n1_M5_144060_109140 10.000000
R25905 n1_M2_143700_110220 n1_M5_144060_110220 10.000000
R25906 n1_M2_143700_111300 n1_M5_144060_111300 10.000000
R25907 n1_M2_143700_112380 n1_M5_144060_112380 10.000000
R25908 n1_M2_143700_113460 n1_M5_144060_113460 10.000000
R25909 n1_M2_143700_114540 n1_M5_144060_114540 10.000000
R25910 n1_M2_143700_115620 n1_M5_144060_115620 10.000000
R25911 n1_M2_143700_116700 n1_M5_144060_116700 10.000000
R25912 n1_M2_143700_117780 n1_M5_144060_117780 10.000000
R25913 n1_M2_143700_118860 n1_M5_144060_118860 10.000000
R25914 n1_M2_143700_119940 n1_M5_144060_119940 10.000000
R25915 n1_M2_143700_121020 n1_M5_144060_121020 10.000000
R25916 n1_M2_143700_122100 n1_M5_144060_122100 10.000000
R25917 n1_M2_143700_123180 n1_M5_144060_123180 10.000000
R25918 n1_M2_143700_124260 n1_M5_144060_124260 10.000000
R25919 n1_M2_143700_125340 n1_M5_144060_125340 10.000000
R25920 n1_M2_143700_126420 n1_M5_144060_126420 10.000000
R25921 n1_M2_143700_127500 n1_M5_144060_127500 10.000000
R25922 n1_M2_143700_128580 n1_M5_144060_128580 10.000000
R25923 n1_M2_143700_129660 n1_M5_144060_129660 10.000000
R25924 n1_M2_143700_130740 n1_M5_144060_130740 10.000000
R25925 n1_M2_143700_131820 n1_M5_144060_131820 10.000000
R25926 n1_M2_143700_132900 n1_M5_144060_132900 10.000000
R25927 n1_M2_143700_133980 n1_M5_144060_133980 10.000000
R25928 n1_M2_143700_135060 n1_M5_144060_135060 10.000000
R25929 n1_M2_143700_136140 n1_M5_144060_136140 10.000000
R25930 n1_M2_143700_137220 n1_M5_144060_137220 10.000000
R25931 n1_M2_143700_138300 n1_M5_144060_138300 10.000000
R25932 n1_M2_143700_139380 n1_M5_144060_139380 10.000000
R25933 n1_M2_143700_140460 n1_M5_144060_140460 10.000000
R25934 n1_M2_143700_141540 n1_M5_144060_141540 10.000000
R25935 n1_M2_143700_142620 n1_M5_144060_142620 10.000000
R25936 n1_M2_143700_143700 n1_M5_144060_143700 10.000000
R25937 n1_M2_143700_144780 n1_M5_144060_144780 10.000000
R25938 n1_M2_143700_145860 n1_M5_144060_145860 10.000000
R25939 n1_M2_143700_146940 n1_M5_144060_146940 10.000000
R25940 n1_M5_60_60 n1_M6_60_60 10.000000
R25941 n1_M5_60_12060 n1_M6_60_12060 10.000000
R25942 n1_M5_60_24060 n1_M6_60_24060 10.000000
R25943 n1_M5_60_36060 n1_M6_60_36060 10.000000
R25944 n1_M5_60_48060 n1_M6_60_48060 10.000000
R25945 n1_M5_60_60060 n1_M6_60_60060 10.000000
R25946 n1_M5_60_72060 n1_M6_60_72060 10.000000
R25947 n1_M5_60_84060 n1_M6_60_84060 10.000000
R25948 n1_M5_60_96060 n1_M6_60_96060 10.000000
R25949 n1_M5_60_108060 n1_M6_60_108060 10.000000
R25950 n1_M5_60_120060 n1_M6_60_120060 10.000000
R25951 n1_M5_60_132060 n1_M6_60_132060 10.000000
R25952 n1_M5_60_144060 n1_M6_60_144060 10.000000
R25953 n1_M5_6060_60 n1_M6_6060_60 10.000000
R25954 n1_M5_12060_60 n1_M6_12060_60 10.000000
R25955 n1_M5_18060_60 n1_M6_18060_60 10.000000
R25956 n1_M5_24060_60 n1_M6_24060_60 10.000000
R25957 n1_M5_24060_12060 n1_M6_24060_12060 10.000000
R25958 n1_M5_24060_24060 n1_M6_24060_24060 10.000000
R25959 n1_M5_24060_36060 n1_M6_24060_36060 10.000000
R25960 n1_M5_24060_48060 n1_M6_24060_48060 10.000000
R25961 n1_M5_24060_60060 n1_M6_24060_60060 10.000000
R25962 n1_M5_24060_72060 n1_M6_24060_72060 10.000000
R25963 n1_M5_24060_84060 n1_M6_24060_84060 10.000000
R25964 n1_M5_24060_96060 n1_M6_24060_96060 10.000000
R25965 n1_M5_24060_108060 n1_M6_24060_108060 10.000000
R25966 n1_M5_24060_120060 n1_M6_24060_120060 10.000000
R25967 n1_M5_24060_132060 n1_M6_24060_132060 10.000000
R25968 n1_M5_24060_144060 n1_M6_24060_144060 10.000000
R25969 n1_M5_30060_60 n1_M6_30060_60 10.000000
R25970 n1_M5_36060_60 n1_M6_36060_60 10.000000
R25971 n1_M5_42060_60 n1_M6_42060_60 10.000000
R25972 n1_M5_48060_60 n1_M6_48060_60 10.000000
R25973 n1_M5_48060_12060 n1_M6_48060_12060 10.000000
R25974 n1_M5_48060_24060 n1_M6_48060_24060 10.000000
R25975 n1_M5_48060_36060 n1_M6_48060_36060 10.000000
R25976 n1_M5_48060_48060 n1_M6_48060_48060 10.000000
R25977 n1_M5_48060_60060 n1_M6_48060_60060 10.000000
R25978 n1_M5_48060_72060 n1_M6_48060_72060 10.000000
R25979 n1_M5_48060_84060 n1_M6_48060_84060 10.000000
R25980 n1_M5_48060_96060 n1_M6_48060_96060 10.000000
R25981 n1_M5_48060_108060 n1_M6_48060_108060 10.000000
R25982 n1_M5_48060_120060 n1_M6_48060_120060 10.000000
R25983 n1_M5_48060_132060 n1_M6_48060_132060 10.000000
R25984 n1_M5_48060_144060 n1_M6_48060_144060 10.000000
R25985 n1_M5_54060_60 n1_M6_54060_60 10.000000
R25986 n1_M5_60060_60 n1_M6_60060_60 10.000000
R25987 n1_M5_66060_60 n1_M6_66060_60 10.000000
R25988 n1_M5_72060_60 n1_M6_72060_60 10.000000
R25989 n1_M5_72060_12060 n1_M6_72060_12060 10.000000
R25990 n1_M5_72060_24060 n1_M6_72060_24060 10.000000
R25991 n1_M5_72060_36060 n1_M6_72060_36060 10.000000
R25992 n1_M5_72060_48060 n1_M6_72060_48060 10.000000
R25993 n1_M5_72060_60060 n1_M6_72060_60060 10.000000
R25994 n1_M5_72060_72060 n1_M6_72060_72060 10.000000
R25995 n1_M5_72060_84060 n1_M6_72060_84060 10.000000
R25996 n1_M5_72060_96060 n1_M6_72060_96060 10.000000
R25997 n1_M5_72060_108060 n1_M6_72060_108060 10.000000
R25998 n1_M5_72060_120060 n1_M6_72060_120060 10.000000
R25999 n1_M5_72060_132060 n1_M6_72060_132060 10.000000
R26000 n1_M5_72060_144060 n1_M6_72060_144060 10.000000
R26001 n1_M5_78060_60 n1_M6_78060_60 10.000000
R26002 n1_M5_84060_60 n1_M6_84060_60 10.000000
R26003 n1_M5_90060_60 n1_M6_90060_60 10.000000
R26004 n1_M5_96060_60 n1_M6_96060_60 10.000000
R26005 n1_M5_96060_12060 n1_M6_96060_12060 10.000000
R26006 n1_M5_96060_24060 n1_M6_96060_24060 10.000000
R26007 n1_M5_96060_36060 n1_M6_96060_36060 10.000000
R26008 n1_M5_96060_48060 n1_M6_96060_48060 10.000000
R26009 n1_M5_96060_60060 n1_M6_96060_60060 10.000000
R26010 n1_M5_96060_72060 n1_M6_96060_72060 10.000000
R26011 n1_M5_96060_84060 n1_M6_96060_84060 10.000000
R26012 n1_M5_96060_96060 n1_M6_96060_96060 10.000000
R26013 n1_M5_96060_108060 n1_M6_96060_108060 10.000000
R26014 n1_M5_96060_120060 n1_M6_96060_120060 10.000000
R26015 n1_M5_96060_132060 n1_M6_96060_132060 10.000000
R26016 n1_M5_96060_144060 n1_M6_96060_144060 10.000000
R26017 n1_M5_102060_60 n1_M6_102060_60 10.000000
R26018 n1_M5_108060_60 n1_M6_108060_60 10.000000
R26019 n1_M5_114060_60 n1_M6_114060_60 10.000000
R26020 n1_M5_120060_60 n1_M6_120060_60 10.000000
R26021 n1_M5_120060_12060 n1_M6_120060_12060 10.000000
R26022 n1_M5_120060_24060 n1_M6_120060_24060 10.000000
R26023 n1_M5_120060_36060 n1_M6_120060_36060 10.000000
R26024 n1_M5_120060_48060 n1_M6_120060_48060 10.000000
R26025 n1_M5_120060_60060 n1_M6_120060_60060 10.000000
R26026 n1_M5_120060_72060 n1_M6_120060_72060 10.000000
R26027 n1_M5_120060_84060 n1_M6_120060_84060 10.000000
R26028 n1_M5_120060_96060 n1_M6_120060_96060 10.000000
R26029 n1_M5_120060_108060 n1_M6_120060_108060 10.000000
R26030 n1_M5_120060_120060 n1_M6_120060_120060 10.000000
R26031 n1_M5_120060_132060 n1_M6_120060_132060 10.000000
R26032 n1_M5_120060_144060 n1_M6_120060_144060 10.000000
R26033 n1_M5_126060_60 n1_M6_126060_60 10.000000
R26034 n1_M5_132060_60 n1_M6_132060_60 10.000000
R26035 n1_M5_138060_60 n1_M6_138060_60 10.000000
R26036 n1_M5_144060_60 n1_M6_144060_60 10.000000
R26037 n1_M5_144060_12060 n1_M6_144060_12060 10.000000
R26038 n1_M5_144060_24060 n1_M6_144060_24060 10.000000
R26039 n1_M5_144060_36060 n1_M6_144060_36060 10.000000
R26040 n1_M5_144060_48060 n1_M6_144060_48060 10.000000
R26041 n1_M5_144060_60060 n1_M6_144060_60060 10.000000
R26042 n1_M5_144060_72060 n1_M6_144060_72060 10.000000
R26043 n1_M5_144060_84060 n1_M6_144060_84060 10.000000
R26044 n1_M5_144060_96060 n1_M6_144060_96060 10.000000
R26045 n1_M5_144060_108060 n1_M6_144060_108060 10.000000
R26046 n1_M5_144060_120060 n1_M6_144060_120060 10.000000
R26047 n1_M5_144060_132060 n1_M6_144060_132060 10.000000
R26048 n1_M5_144060_144060 n1_M6_144060_144060 10.000000
R26049 n1_M6_60_60 n1_M7_60_60 10.000000
R26050 n1_M6_60_12060 n1_M7_60_12060 10.000000
R26051 n1_M6_60_24060 n1_M7_60_24060 10.000000
R26052 n1_M6_60_36060 n1_M7_60_36060 10.000000
R26053 n1_M6_60_48060 n1_M7_60_48060 10.000000
R26054 n1_M6_60_60060 n1_M7_60_60060 10.000000
R26055 n1_M6_60_72060 n1_M7_60_72060 10.000000
R26056 n1_M6_60_84060 n1_M7_60_84060 10.000000
R26057 n1_M6_60_96060 n1_M7_60_96060 10.000000
R26058 n1_M6_60_108060 n1_M7_60_108060 10.000000
R26059 n1_M6_60_120060 n1_M7_60_120060 10.000000
R26060 n1_M6_60_132060 n1_M7_60_132060 10.000000
R26061 n1_M6_60_144060 n1_M7_60_144060 10.000000
R26062 n1_M6_4156_60 n1_M7_4156_60 10.000000
R26063 n1_M6_4156_12060 n1_M7_4156_12060 10.000000
R26064 n1_M6_4156_24060 n1_M7_4156_24060 10.000000
R26065 n1_M6_4156_36060 n1_M7_4156_36060 10.000000
R26066 n1_M6_4156_48060 n1_M7_4156_48060 10.000000
R26067 n1_M6_4156_60060 n1_M7_4156_60060 10.000000
R26068 n1_M6_4156_72060 n1_M7_4156_72060 10.000000
R26069 n1_M6_4156_84060 n1_M7_4156_84060 10.000000
R26070 n1_M6_4156_96060 n1_M7_4156_96060 10.000000
R26071 n1_M6_4156_108060 n1_M7_4156_108060 10.000000
R26072 n1_M6_4156_120060 n1_M7_4156_120060 10.000000
R26073 n1_M6_4156_132060 n1_M7_4156_132060 10.000000
R26074 n1_M6_4156_144060 n1_M7_4156_144060 10.000000
R26075 n1_M6_8252_60 n1_M7_8252_60 10.000000
R26076 n1_M6_8252_12060 n1_M7_8252_12060 10.000000
R26077 n1_M6_8252_24060 n1_M7_8252_24060 10.000000
R26078 n1_M6_8252_36060 n1_M7_8252_36060 10.000000
R26079 n1_M6_8252_48060 n1_M7_8252_48060 10.000000
R26080 n1_M6_8252_60060 n1_M7_8252_60060 10.000000
R26081 n1_M6_8252_72060 n1_M7_8252_72060 10.000000
R26082 n1_M6_8252_84060 n1_M7_8252_84060 10.000000
R26083 n1_M6_8252_96060 n1_M7_8252_96060 10.000000
R26084 n1_M6_8252_108060 n1_M7_8252_108060 10.000000
R26085 n1_M6_8252_120060 n1_M7_8252_120060 10.000000
R26086 n1_M6_8252_132060 n1_M7_8252_132060 10.000000
R26087 n1_M6_8252_144060 n1_M7_8252_144060 10.000000
R26088 n1_M6_12348_60 n1_M7_12348_60 10.000000
R26089 n1_M6_12348_12060 n1_M7_12348_12060 10.000000
R26090 n1_M6_12348_24060 n1_M7_12348_24060 10.000000
R26091 n1_M6_12348_36060 n1_M7_12348_36060 10.000000
R26092 n1_M6_12348_48060 n1_M7_12348_48060 10.000000
R26093 n1_M6_12348_60060 n1_M7_12348_60060 10.000000
R26094 n1_M6_12348_72060 n1_M7_12348_72060 10.000000
R26095 n1_M6_12348_84060 n1_M7_12348_84060 10.000000
R26096 n1_M6_12348_96060 n1_M7_12348_96060 10.000000
R26097 n1_M6_12348_108060 n1_M7_12348_108060 10.000000
R26098 n1_M6_12348_120060 n1_M7_12348_120060 10.000000
R26099 n1_M6_12348_132060 n1_M7_12348_132060 10.000000
R26100 n1_M6_12348_144060 n1_M7_12348_144060 10.000000
R26101 n1_M6_16444_60 n1_M7_16444_60 10.000000
R26102 n1_M6_16444_12060 n1_M7_16444_12060 10.000000
R26103 n1_M6_16444_24060 n1_M7_16444_24060 10.000000
R26104 n1_M6_16444_36060 n1_M7_16444_36060 10.000000
R26105 n1_M6_16444_48060 n1_M7_16444_48060 10.000000
R26106 n1_M6_16444_60060 n1_M7_16444_60060 10.000000
R26107 n1_M6_16444_72060 n1_M7_16444_72060 10.000000
R26108 n1_M6_16444_84060 n1_M7_16444_84060 10.000000
R26109 n1_M6_16444_96060 n1_M7_16444_96060 10.000000
R26110 n1_M6_16444_108060 n1_M7_16444_108060 10.000000
R26111 n1_M6_16444_120060 n1_M7_16444_120060 10.000000
R26112 n1_M6_16444_132060 n1_M7_16444_132060 10.000000
R26113 n1_M6_16444_144060 n1_M7_16444_144060 10.000000
R26114 n1_M6_20540_60 n1_M7_20540_60 10.000000
R26115 n1_M6_20540_12060 n1_M7_20540_12060 10.000000
R26116 n1_M6_20540_24060 n1_M7_20540_24060 10.000000
R26117 n1_M6_20540_36060 n1_M7_20540_36060 10.000000
R26118 n1_M6_20540_48060 n1_M7_20540_48060 10.000000
R26119 n1_M6_20540_60060 n1_M7_20540_60060 10.000000
R26120 n1_M6_20540_72060 n1_M7_20540_72060 10.000000
R26121 n1_M6_20540_84060 n1_M7_20540_84060 10.000000
R26122 n1_M6_20540_96060 n1_M7_20540_96060 10.000000
R26123 n1_M6_20540_108060 n1_M7_20540_108060 10.000000
R26124 n1_M6_20540_120060 n1_M7_20540_120060 10.000000
R26125 n1_M6_20540_132060 n1_M7_20540_132060 10.000000
R26126 n1_M6_20540_144060 n1_M7_20540_144060 10.000000
R26127 n1_M6_24636_60 n1_M7_24636_60 10.000000
R26128 n1_M6_24636_12060 n1_M7_24636_12060 10.000000
R26129 n1_M6_24636_24060 n1_M7_24636_24060 10.000000
R26130 n1_M6_24636_36060 n1_M7_24636_36060 10.000000
R26131 n1_M6_24636_48060 n1_M7_24636_48060 10.000000
R26132 n1_M6_24636_60060 n1_M7_24636_60060 10.000000
R26133 n1_M6_24636_72060 n1_M7_24636_72060 10.000000
R26134 n1_M6_24636_84060 n1_M7_24636_84060 10.000000
R26135 n1_M6_24636_96060 n1_M7_24636_96060 10.000000
R26136 n1_M6_24636_108060 n1_M7_24636_108060 10.000000
R26137 n1_M6_24636_120060 n1_M7_24636_120060 10.000000
R26138 n1_M6_24636_132060 n1_M7_24636_132060 10.000000
R26139 n1_M6_24636_144060 n1_M7_24636_144060 10.000000
R26140 n1_M6_28732_60 n1_M7_28732_60 10.000000
R26141 n1_M6_28732_12060 n1_M7_28732_12060 10.000000
R26142 n1_M6_28732_24060 n1_M7_28732_24060 10.000000
R26143 n1_M6_28732_36060 n1_M7_28732_36060 10.000000
R26144 n1_M6_28732_48060 n1_M7_28732_48060 10.000000
R26145 n1_M6_28732_60060 n1_M7_28732_60060 10.000000
R26146 n1_M6_28732_72060 n1_M7_28732_72060 10.000000
R26147 n1_M6_28732_84060 n1_M7_28732_84060 10.000000
R26148 n1_M6_28732_96060 n1_M7_28732_96060 10.000000
R26149 n1_M6_28732_108060 n1_M7_28732_108060 10.000000
R26150 n1_M6_28732_120060 n1_M7_28732_120060 10.000000
R26151 n1_M6_28732_132060 n1_M7_28732_132060 10.000000
R26152 n1_M6_28732_144060 n1_M7_28732_144060 10.000000
R26153 n1_M6_32828_60 n1_M7_32828_60 10.000000
R26154 n1_M6_32828_12060 n1_M7_32828_12060 10.000000
R26155 n1_M6_32828_24060 n1_M7_32828_24060 10.000000
R26156 n1_M6_32828_36060 n1_M7_32828_36060 10.000000
R26157 n1_M6_32828_48060 n1_M7_32828_48060 10.000000
R26158 n1_M6_32828_60060 n1_M7_32828_60060 10.000000
R26159 n1_M6_32828_72060 n1_M7_32828_72060 10.000000
R26160 n1_M6_32828_84060 n1_M7_32828_84060 10.000000
R26161 n1_M6_32828_96060 n1_M7_32828_96060 10.000000
R26162 n1_M6_32828_108060 n1_M7_32828_108060 10.000000
R26163 n1_M6_32828_120060 n1_M7_32828_120060 10.000000
R26164 n1_M6_32828_132060 n1_M7_32828_132060 10.000000
R26165 n1_M6_32828_144060 n1_M7_32828_144060 10.000000
R26166 n1_M6_36924_60 n1_M7_36924_60 10.000000
R26167 n1_M6_36924_12060 n1_M7_36924_12060 10.000000
R26168 n1_M6_36924_24060 n1_M7_36924_24060 10.000000
R26169 n1_M6_36924_36060 n1_M7_36924_36060 10.000000
R26170 n1_M6_36924_48060 n1_M7_36924_48060 10.000000
R26171 n1_M6_36924_60060 n1_M7_36924_60060 10.000000
R26172 n1_M6_36924_72060 n1_M7_36924_72060 10.000000
R26173 n1_M6_36924_84060 n1_M7_36924_84060 10.000000
R26174 n1_M6_36924_96060 n1_M7_36924_96060 10.000000
R26175 n1_M6_36924_108060 n1_M7_36924_108060 10.000000
R26176 n1_M6_36924_120060 n1_M7_36924_120060 10.000000
R26177 n1_M6_36924_132060 n1_M7_36924_132060 10.000000
R26178 n1_M6_36924_144060 n1_M7_36924_144060 10.000000
R26179 n1_M6_41020_60 n1_M7_41020_60 10.000000
R26180 n1_M6_41020_12060 n1_M7_41020_12060 10.000000
R26181 n1_M6_41020_24060 n1_M7_41020_24060 10.000000
R26182 n1_M6_41020_36060 n1_M7_41020_36060 10.000000
R26183 n1_M6_41020_48060 n1_M7_41020_48060 10.000000
R26184 n1_M6_41020_60060 n1_M7_41020_60060 10.000000
R26185 n1_M6_41020_72060 n1_M7_41020_72060 10.000000
R26186 n1_M6_41020_84060 n1_M7_41020_84060 10.000000
R26187 n1_M6_41020_96060 n1_M7_41020_96060 10.000000
R26188 n1_M6_41020_108060 n1_M7_41020_108060 10.000000
R26189 n1_M6_41020_120060 n1_M7_41020_120060 10.000000
R26190 n1_M6_41020_132060 n1_M7_41020_132060 10.000000
R26191 n1_M6_41020_144060 n1_M7_41020_144060 10.000000
R26192 n1_M6_45116_60 n1_M7_45116_60 10.000000
R26193 n1_M6_45116_12060 n1_M7_45116_12060 10.000000
R26194 n1_M6_45116_24060 n1_M7_45116_24060 10.000000
R26195 n1_M6_45116_36060 n1_M7_45116_36060 10.000000
R26196 n1_M6_45116_48060 n1_M7_45116_48060 10.000000
R26197 n1_M6_45116_60060 n1_M7_45116_60060 10.000000
R26198 n1_M6_45116_72060 n1_M7_45116_72060 10.000000
R26199 n1_M6_45116_84060 n1_M7_45116_84060 10.000000
R26200 n1_M6_45116_96060 n1_M7_45116_96060 10.000000
R26201 n1_M6_45116_108060 n1_M7_45116_108060 10.000000
R26202 n1_M6_45116_120060 n1_M7_45116_120060 10.000000
R26203 n1_M6_45116_132060 n1_M7_45116_132060 10.000000
R26204 n1_M6_45116_144060 n1_M7_45116_144060 10.000000
R26205 n1_M6_49212_60 n1_M7_49212_60 10.000000
R26206 n1_M6_49212_12060 n1_M7_49212_12060 10.000000
R26207 n1_M6_49212_24060 n1_M7_49212_24060 10.000000
R26208 n1_M6_49212_36060 n1_M7_49212_36060 10.000000
R26209 n1_M6_49212_48060 n1_M7_49212_48060 10.000000
R26210 n1_M6_49212_60060 n1_M7_49212_60060 10.000000
R26211 n1_M6_49212_72060 n1_M7_49212_72060 10.000000
R26212 n1_M6_49212_84060 n1_M7_49212_84060 10.000000
R26213 n1_M6_49212_96060 n1_M7_49212_96060 10.000000
R26214 n1_M6_49212_108060 n1_M7_49212_108060 10.000000
R26215 n1_M6_49212_120060 n1_M7_49212_120060 10.000000
R26216 n1_M6_49212_132060 n1_M7_49212_132060 10.000000
R26217 n1_M6_49212_144060 n1_M7_49212_144060 10.000000
R26218 n1_M6_53308_60 n1_M7_53308_60 10.000000
R26219 n1_M6_53308_12060 n1_M7_53308_12060 10.000000
R26220 n1_M6_53308_24060 n1_M7_53308_24060 10.000000
R26221 n1_M6_53308_36060 n1_M7_53308_36060 10.000000
R26222 n1_M6_53308_48060 n1_M7_53308_48060 10.000000
R26223 n1_M6_53308_60060 n1_M7_53308_60060 10.000000
R26224 n1_M6_53308_72060 n1_M7_53308_72060 10.000000
R26225 n1_M6_53308_84060 n1_M7_53308_84060 10.000000
R26226 n1_M6_53308_96060 n1_M7_53308_96060 10.000000
R26227 n1_M6_53308_108060 n1_M7_53308_108060 10.000000
R26228 n1_M6_53308_120060 n1_M7_53308_120060 10.000000
R26229 n1_M6_53308_132060 n1_M7_53308_132060 10.000000
R26230 n1_M6_53308_144060 n1_M7_53308_144060 10.000000
R26231 n1_M6_57404_60 n1_M7_57404_60 10.000000
R26232 n1_M6_57404_12060 n1_M7_57404_12060 10.000000
R26233 n1_M6_57404_24060 n1_M7_57404_24060 10.000000
R26234 n1_M6_57404_36060 n1_M7_57404_36060 10.000000
R26235 n1_M6_57404_48060 n1_M7_57404_48060 10.000000
R26236 n1_M6_57404_60060 n1_M7_57404_60060 10.000000
R26237 n1_M6_57404_72060 n1_M7_57404_72060 10.000000
R26238 n1_M6_57404_84060 n1_M7_57404_84060 10.000000
R26239 n1_M6_57404_96060 n1_M7_57404_96060 10.000000
R26240 n1_M6_57404_108060 n1_M7_57404_108060 10.000000
R26241 n1_M6_57404_120060 n1_M7_57404_120060 10.000000
R26242 n1_M6_57404_132060 n1_M7_57404_132060 10.000000
R26243 n1_M6_57404_144060 n1_M7_57404_144060 10.000000
R26244 n1_M6_61500_60 n1_M7_61500_60 10.000000
R26245 n1_M6_61500_12060 n1_M7_61500_12060 10.000000
R26246 n1_M6_61500_24060 n1_M7_61500_24060 10.000000
R26247 n1_M6_61500_36060 n1_M7_61500_36060 10.000000
R26248 n1_M6_61500_48060 n1_M7_61500_48060 10.000000
R26249 n1_M6_61500_60060 n1_M7_61500_60060 10.000000
R26250 n1_M6_61500_72060 n1_M7_61500_72060 10.000000
R26251 n1_M6_61500_84060 n1_M7_61500_84060 10.000000
R26252 n1_M6_61500_96060 n1_M7_61500_96060 10.000000
R26253 n1_M6_61500_108060 n1_M7_61500_108060 10.000000
R26254 n1_M6_61500_120060 n1_M7_61500_120060 10.000000
R26255 n1_M6_61500_132060 n1_M7_61500_132060 10.000000
R26256 n1_M6_61500_144060 n1_M7_61500_144060 10.000000
R26257 n1_M6_65596_60 n1_M7_65596_60 10.000000
R26258 n1_M6_65596_12060 n1_M7_65596_12060 10.000000
R26259 n1_M6_65596_24060 n1_M7_65596_24060 10.000000
R26260 n1_M6_65596_36060 n1_M7_65596_36060 10.000000
R26261 n1_M6_65596_48060 n1_M7_65596_48060 10.000000
R26262 n1_M6_65596_60060 n1_M7_65596_60060 10.000000
R26263 n1_M6_65596_72060 n1_M7_65596_72060 10.000000
R26264 n1_M6_65596_84060 n1_M7_65596_84060 10.000000
R26265 n1_M6_65596_96060 n1_M7_65596_96060 10.000000
R26266 n1_M6_65596_108060 n1_M7_65596_108060 10.000000
R26267 n1_M6_65596_120060 n1_M7_65596_120060 10.000000
R26268 n1_M6_65596_132060 n1_M7_65596_132060 10.000000
R26269 n1_M6_65596_144060 n1_M7_65596_144060 10.000000
R26270 n1_M6_69692_60 n1_M7_69692_60 10.000000
R26271 n1_M6_69692_12060 n1_M7_69692_12060 10.000000
R26272 n1_M6_69692_24060 n1_M7_69692_24060 10.000000
R26273 n1_M6_69692_36060 n1_M7_69692_36060 10.000000
R26274 n1_M6_69692_48060 n1_M7_69692_48060 10.000000
R26275 n1_M6_69692_60060 n1_M7_69692_60060 10.000000
R26276 n1_M6_69692_72060 n1_M7_69692_72060 10.000000
R26277 n1_M6_69692_84060 n1_M7_69692_84060 10.000000
R26278 n1_M6_69692_96060 n1_M7_69692_96060 10.000000
R26279 n1_M6_69692_108060 n1_M7_69692_108060 10.000000
R26280 n1_M6_69692_120060 n1_M7_69692_120060 10.000000
R26281 n1_M6_69692_132060 n1_M7_69692_132060 10.000000
R26282 n1_M6_69692_144060 n1_M7_69692_144060 10.000000
R26283 n1_M6_73788_60 n1_M7_73788_60 10.000000
R26284 n1_M6_73788_12060 n1_M7_73788_12060 10.000000
R26285 n1_M6_73788_24060 n1_M7_73788_24060 10.000000
R26286 n1_M6_73788_36060 n1_M7_73788_36060 10.000000
R26287 n1_M6_73788_48060 n1_M7_73788_48060 10.000000
R26288 n1_M6_73788_60060 n1_M7_73788_60060 10.000000
R26289 n1_M6_73788_72060 n1_M7_73788_72060 10.000000
R26290 n1_M6_73788_84060 n1_M7_73788_84060 10.000000
R26291 n1_M6_73788_96060 n1_M7_73788_96060 10.000000
R26292 n1_M6_73788_108060 n1_M7_73788_108060 10.000000
R26293 n1_M6_73788_120060 n1_M7_73788_120060 10.000000
R26294 n1_M6_73788_132060 n1_M7_73788_132060 10.000000
R26295 n1_M6_73788_144060 n1_M7_73788_144060 10.000000
R26296 n1_M6_77884_60 n1_M7_77884_60 10.000000
R26297 n1_M6_77884_12060 n1_M7_77884_12060 10.000000
R26298 n1_M6_77884_24060 n1_M7_77884_24060 10.000000
R26299 n1_M6_77884_36060 n1_M7_77884_36060 10.000000
R26300 n1_M6_77884_48060 n1_M7_77884_48060 10.000000
R26301 n1_M6_77884_60060 n1_M7_77884_60060 10.000000
R26302 n1_M6_77884_72060 n1_M7_77884_72060 10.000000
R26303 n1_M6_77884_84060 n1_M7_77884_84060 10.000000
R26304 n1_M6_77884_96060 n1_M7_77884_96060 10.000000
R26305 n1_M6_77884_108060 n1_M7_77884_108060 10.000000
R26306 n1_M6_77884_120060 n1_M7_77884_120060 10.000000
R26307 n1_M6_77884_132060 n1_M7_77884_132060 10.000000
R26308 n1_M6_77884_144060 n1_M7_77884_144060 10.000000
R26309 n1_M6_81980_60 n1_M7_81980_60 10.000000
R26310 n1_M6_81980_12060 n1_M7_81980_12060 10.000000
R26311 n1_M6_81980_24060 n1_M7_81980_24060 10.000000
R26312 n1_M6_81980_36060 n1_M7_81980_36060 10.000000
R26313 n1_M6_81980_48060 n1_M7_81980_48060 10.000000
R26314 n1_M6_81980_60060 n1_M7_81980_60060 10.000000
R26315 n1_M6_81980_72060 n1_M7_81980_72060 10.000000
R26316 n1_M6_81980_84060 n1_M7_81980_84060 10.000000
R26317 n1_M6_81980_96060 n1_M7_81980_96060 10.000000
R26318 n1_M6_81980_108060 n1_M7_81980_108060 10.000000
R26319 n1_M6_81980_120060 n1_M7_81980_120060 10.000000
R26320 n1_M6_81980_132060 n1_M7_81980_132060 10.000000
R26321 n1_M6_81980_144060 n1_M7_81980_144060 10.000000
R26322 n1_M6_86076_60 n1_M7_86076_60 10.000000
R26323 n1_M6_86076_12060 n1_M7_86076_12060 10.000000
R26324 n1_M6_86076_24060 n1_M7_86076_24060 10.000000
R26325 n1_M6_86076_36060 n1_M7_86076_36060 10.000000
R26326 n1_M6_86076_48060 n1_M7_86076_48060 10.000000
R26327 n1_M6_86076_60060 n1_M7_86076_60060 10.000000
R26328 n1_M6_86076_72060 n1_M7_86076_72060 10.000000
R26329 n1_M6_86076_84060 n1_M7_86076_84060 10.000000
R26330 n1_M6_86076_96060 n1_M7_86076_96060 10.000000
R26331 n1_M6_86076_108060 n1_M7_86076_108060 10.000000
R26332 n1_M6_86076_120060 n1_M7_86076_120060 10.000000
R26333 n1_M6_86076_132060 n1_M7_86076_132060 10.000000
R26334 n1_M6_86076_144060 n1_M7_86076_144060 10.000000
R26335 n1_M6_90172_60 n1_M7_90172_60 10.000000
R26336 n1_M6_90172_12060 n1_M7_90172_12060 10.000000
R26337 n1_M6_90172_24060 n1_M7_90172_24060 10.000000
R26338 n1_M6_90172_36060 n1_M7_90172_36060 10.000000
R26339 n1_M6_90172_48060 n1_M7_90172_48060 10.000000
R26340 n1_M6_90172_60060 n1_M7_90172_60060 10.000000
R26341 n1_M6_90172_72060 n1_M7_90172_72060 10.000000
R26342 n1_M6_90172_84060 n1_M7_90172_84060 10.000000
R26343 n1_M6_90172_96060 n1_M7_90172_96060 10.000000
R26344 n1_M6_90172_108060 n1_M7_90172_108060 10.000000
R26345 n1_M6_90172_120060 n1_M7_90172_120060 10.000000
R26346 n1_M6_90172_132060 n1_M7_90172_132060 10.000000
R26347 n1_M6_90172_144060 n1_M7_90172_144060 10.000000
R26348 n1_M6_94268_60 n1_M7_94268_60 10.000000
R26349 n1_M6_94268_12060 n1_M7_94268_12060 10.000000
R26350 n1_M6_94268_24060 n1_M7_94268_24060 10.000000
R26351 n1_M6_94268_36060 n1_M7_94268_36060 10.000000
R26352 n1_M6_94268_48060 n1_M7_94268_48060 10.000000
R26353 n1_M6_94268_60060 n1_M7_94268_60060 10.000000
R26354 n1_M6_94268_72060 n1_M7_94268_72060 10.000000
R26355 n1_M6_94268_84060 n1_M7_94268_84060 10.000000
R26356 n1_M6_94268_96060 n1_M7_94268_96060 10.000000
R26357 n1_M6_94268_108060 n1_M7_94268_108060 10.000000
R26358 n1_M6_94268_120060 n1_M7_94268_120060 10.000000
R26359 n1_M6_94268_132060 n1_M7_94268_132060 10.000000
R26360 n1_M6_94268_144060 n1_M7_94268_144060 10.000000
R26361 n1_M6_98364_60 n1_M7_98364_60 10.000000
R26362 n1_M6_98364_12060 n1_M7_98364_12060 10.000000
R26363 n1_M6_98364_24060 n1_M7_98364_24060 10.000000
R26364 n1_M6_98364_36060 n1_M7_98364_36060 10.000000
R26365 n1_M6_98364_48060 n1_M7_98364_48060 10.000000
R26366 n1_M6_98364_60060 n1_M7_98364_60060 10.000000
R26367 n1_M6_98364_72060 n1_M7_98364_72060 10.000000
R26368 n1_M6_98364_84060 n1_M7_98364_84060 10.000000
R26369 n1_M6_98364_96060 n1_M7_98364_96060 10.000000
R26370 n1_M6_98364_108060 n1_M7_98364_108060 10.000000
R26371 n1_M6_98364_120060 n1_M7_98364_120060 10.000000
R26372 n1_M6_98364_132060 n1_M7_98364_132060 10.000000
R26373 n1_M6_98364_144060 n1_M7_98364_144060 10.000000
R26374 n1_M6_102460_60 n1_M7_102460_60 10.000000
R26375 n1_M6_102460_12060 n1_M7_102460_12060 10.000000
R26376 n1_M6_102460_24060 n1_M7_102460_24060 10.000000
R26377 n1_M6_102460_36060 n1_M7_102460_36060 10.000000
R26378 n1_M6_102460_48060 n1_M7_102460_48060 10.000000
R26379 n1_M6_102460_60060 n1_M7_102460_60060 10.000000
R26380 n1_M6_102460_72060 n1_M7_102460_72060 10.000000
R26381 n1_M6_102460_84060 n1_M7_102460_84060 10.000000
R26382 n1_M6_102460_96060 n1_M7_102460_96060 10.000000
R26383 n1_M6_102460_108060 n1_M7_102460_108060 10.000000
R26384 n1_M6_102460_120060 n1_M7_102460_120060 10.000000
R26385 n1_M6_102460_132060 n1_M7_102460_132060 10.000000
R26386 n1_M6_102460_144060 n1_M7_102460_144060 10.000000
R26387 n1_M6_106556_60 n1_M7_106556_60 10.000000
R26388 n1_M6_106556_12060 n1_M7_106556_12060 10.000000
R26389 n1_M6_106556_24060 n1_M7_106556_24060 10.000000
R26390 n1_M6_106556_36060 n1_M7_106556_36060 10.000000
R26391 n1_M6_106556_48060 n1_M7_106556_48060 10.000000
R26392 n1_M6_106556_60060 n1_M7_106556_60060 10.000000
R26393 n1_M6_106556_72060 n1_M7_106556_72060 10.000000
R26394 n1_M6_106556_84060 n1_M7_106556_84060 10.000000
R26395 n1_M6_106556_96060 n1_M7_106556_96060 10.000000
R26396 n1_M6_106556_108060 n1_M7_106556_108060 10.000000
R26397 n1_M6_106556_120060 n1_M7_106556_120060 10.000000
R26398 n1_M6_106556_132060 n1_M7_106556_132060 10.000000
R26399 n1_M6_106556_144060 n1_M7_106556_144060 10.000000
R26400 n1_M6_110652_60 n1_M7_110652_60 10.000000
R26401 n1_M6_110652_12060 n1_M7_110652_12060 10.000000
R26402 n1_M6_110652_24060 n1_M7_110652_24060 10.000000
R26403 n1_M6_110652_36060 n1_M7_110652_36060 10.000000
R26404 n1_M6_110652_48060 n1_M7_110652_48060 10.000000
R26405 n1_M6_110652_60060 n1_M7_110652_60060 10.000000
R26406 n1_M6_110652_72060 n1_M7_110652_72060 10.000000
R26407 n1_M6_110652_84060 n1_M7_110652_84060 10.000000
R26408 n1_M6_110652_96060 n1_M7_110652_96060 10.000000
R26409 n1_M6_110652_108060 n1_M7_110652_108060 10.000000
R26410 n1_M6_110652_120060 n1_M7_110652_120060 10.000000
R26411 n1_M6_110652_132060 n1_M7_110652_132060 10.000000
R26412 n1_M6_110652_144060 n1_M7_110652_144060 10.000000
R26413 n1_M6_114748_60 n1_M7_114748_60 10.000000
R26414 n1_M6_114748_12060 n1_M7_114748_12060 10.000000
R26415 n1_M6_114748_24060 n1_M7_114748_24060 10.000000
R26416 n1_M6_114748_36060 n1_M7_114748_36060 10.000000
R26417 n1_M6_114748_48060 n1_M7_114748_48060 10.000000
R26418 n1_M6_114748_60060 n1_M7_114748_60060 10.000000
R26419 n1_M6_114748_72060 n1_M7_114748_72060 10.000000
R26420 n1_M6_114748_84060 n1_M7_114748_84060 10.000000
R26421 n1_M6_114748_96060 n1_M7_114748_96060 10.000000
R26422 n1_M6_114748_108060 n1_M7_114748_108060 10.000000
R26423 n1_M6_114748_120060 n1_M7_114748_120060 10.000000
R26424 n1_M6_114748_132060 n1_M7_114748_132060 10.000000
R26425 n1_M6_114748_144060 n1_M7_114748_144060 10.000000
R26426 n1_M6_118844_60 n1_M7_118844_60 10.000000
R26427 n1_M6_118844_12060 n1_M7_118844_12060 10.000000
R26428 n1_M6_118844_24060 n1_M7_118844_24060 10.000000
R26429 n1_M6_118844_36060 n1_M7_118844_36060 10.000000
R26430 n1_M6_118844_48060 n1_M7_118844_48060 10.000000
R26431 n1_M6_118844_60060 n1_M7_118844_60060 10.000000
R26432 n1_M6_118844_72060 n1_M7_118844_72060 10.000000
R26433 n1_M6_118844_84060 n1_M7_118844_84060 10.000000
R26434 n1_M6_118844_96060 n1_M7_118844_96060 10.000000
R26435 n1_M6_118844_108060 n1_M7_118844_108060 10.000000
R26436 n1_M6_118844_120060 n1_M7_118844_120060 10.000000
R26437 n1_M6_118844_132060 n1_M7_118844_132060 10.000000
R26438 n1_M6_118844_144060 n1_M7_118844_144060 10.000000
R26439 n1_M6_122940_60 n1_M7_122940_60 10.000000
R26440 n1_M6_122940_12060 n1_M7_122940_12060 10.000000
R26441 n1_M6_122940_24060 n1_M7_122940_24060 10.000000
R26442 n1_M6_122940_36060 n1_M7_122940_36060 10.000000
R26443 n1_M6_122940_48060 n1_M7_122940_48060 10.000000
R26444 n1_M6_122940_60060 n1_M7_122940_60060 10.000000
R26445 n1_M6_122940_72060 n1_M7_122940_72060 10.000000
R26446 n1_M6_122940_84060 n1_M7_122940_84060 10.000000
R26447 n1_M6_122940_96060 n1_M7_122940_96060 10.000000
R26448 n1_M6_122940_108060 n1_M7_122940_108060 10.000000
R26449 n1_M6_122940_120060 n1_M7_122940_120060 10.000000
R26450 n1_M6_122940_132060 n1_M7_122940_132060 10.000000
R26451 n1_M6_122940_144060 n1_M7_122940_144060 10.000000
R26452 n1_M6_127036_60 n1_M7_127036_60 10.000000
R26453 n1_M6_127036_12060 n1_M7_127036_12060 10.000000
R26454 n1_M6_127036_24060 n1_M7_127036_24060 10.000000
R26455 n1_M6_127036_36060 n1_M7_127036_36060 10.000000
R26456 n1_M6_127036_48060 n1_M7_127036_48060 10.000000
R26457 n1_M6_127036_60060 n1_M7_127036_60060 10.000000
R26458 n1_M6_127036_72060 n1_M7_127036_72060 10.000000
R26459 n1_M6_127036_84060 n1_M7_127036_84060 10.000000
R26460 n1_M6_127036_96060 n1_M7_127036_96060 10.000000
R26461 n1_M6_127036_108060 n1_M7_127036_108060 10.000000
R26462 n1_M6_127036_120060 n1_M7_127036_120060 10.000000
R26463 n1_M6_127036_132060 n1_M7_127036_132060 10.000000
R26464 n1_M6_127036_144060 n1_M7_127036_144060 10.000000
R26465 n1_M6_131132_60 n1_M7_131132_60 10.000000
R26466 n1_M6_131132_12060 n1_M7_131132_12060 10.000000
R26467 n1_M6_131132_24060 n1_M7_131132_24060 10.000000
R26468 n1_M6_131132_36060 n1_M7_131132_36060 10.000000
R26469 n1_M6_131132_48060 n1_M7_131132_48060 10.000000
R26470 n1_M6_131132_60060 n1_M7_131132_60060 10.000000
R26471 n1_M6_131132_72060 n1_M7_131132_72060 10.000000
R26472 n1_M6_131132_84060 n1_M7_131132_84060 10.000000
R26473 n1_M6_131132_96060 n1_M7_131132_96060 10.000000
R26474 n1_M6_131132_108060 n1_M7_131132_108060 10.000000
R26475 n1_M6_131132_120060 n1_M7_131132_120060 10.000000
R26476 n1_M6_131132_132060 n1_M7_131132_132060 10.000000
R26477 n1_M6_131132_144060 n1_M7_131132_144060 10.000000
R26478 n1_M6_135228_60 n1_M7_135228_60 10.000000
R26479 n1_M6_135228_12060 n1_M7_135228_12060 10.000000
R26480 n1_M6_135228_24060 n1_M7_135228_24060 10.000000
R26481 n1_M6_135228_36060 n1_M7_135228_36060 10.000000
R26482 n1_M6_135228_48060 n1_M7_135228_48060 10.000000
R26483 n1_M6_135228_60060 n1_M7_135228_60060 10.000000
R26484 n1_M6_135228_72060 n1_M7_135228_72060 10.000000
R26485 n1_M6_135228_84060 n1_M7_135228_84060 10.000000
R26486 n1_M6_135228_96060 n1_M7_135228_96060 10.000000
R26487 n1_M6_135228_108060 n1_M7_135228_108060 10.000000
R26488 n1_M6_135228_120060 n1_M7_135228_120060 10.000000
R26489 n1_M6_135228_132060 n1_M7_135228_132060 10.000000
R26490 n1_M6_135228_144060 n1_M7_135228_144060 10.000000
R26491 n1_M6_139324_60 n1_M7_139324_60 10.000000
R26492 n1_M6_139324_12060 n1_M7_139324_12060 10.000000
R26493 n1_M6_139324_24060 n1_M7_139324_24060 10.000000
R26494 n1_M6_139324_36060 n1_M7_139324_36060 10.000000
R26495 n1_M6_139324_48060 n1_M7_139324_48060 10.000000
R26496 n1_M6_139324_60060 n1_M7_139324_60060 10.000000
R26497 n1_M6_139324_72060 n1_M7_139324_72060 10.000000
R26498 n1_M6_139324_84060 n1_M7_139324_84060 10.000000
R26499 n1_M6_139324_96060 n1_M7_139324_96060 10.000000
R26500 n1_M6_139324_108060 n1_M7_139324_108060 10.000000
R26501 n1_M6_139324_120060 n1_M7_139324_120060 10.000000
R26502 n1_M6_139324_132060 n1_M7_139324_132060 10.000000
R26503 n1_M6_139324_144060 n1_M7_139324_144060 10.000000
R26504 n1_M6_143420_60 n1_M7_143420_60 10.000000
R26505 n1_M6_143420_12060 n1_M7_143420_12060 10.000000
R26506 n1_M6_143420_24060 n1_M7_143420_24060 10.000000
R26507 n1_M6_143420_36060 n1_M7_143420_36060 10.000000
R26508 n1_M6_143420_48060 n1_M7_143420_48060 10.000000
R26509 n1_M6_143420_60060 n1_M7_143420_60060 10.000000
R26510 n1_M6_143420_72060 n1_M7_143420_72060 10.000000
R26511 n1_M6_143420_84060 n1_M7_143420_84060 10.000000
R26512 n1_M6_143420_96060 n1_M7_143420_96060 10.000000
R26513 n1_M6_143420_108060 n1_M7_143420_108060 10.000000
R26514 n1_M6_143420_120060 n1_M7_143420_120060 10.000000
R26515 n1_M6_143420_132060 n1_M7_143420_132060 10.000000
R26516 n1_M6_143420_144060 n1_M7_143420_144060 10.000000
R26517 n1_M6_147516_60 n1_M7_147516_60 10.000000
R26518 n1_M6_147516_12060 n1_M7_147516_12060 10.000000
R26519 n1_M6_147516_24060 n1_M7_147516_24060 10.000000
R26520 n1_M6_147516_36060 n1_M7_147516_36060 10.000000
R26521 n1_M6_147516_48060 n1_M7_147516_48060 10.000000
R26522 n1_M6_147516_60060 n1_M7_147516_60060 10.000000
R26523 n1_M6_147516_72060 n1_M7_147516_72060 10.000000
R26524 n1_M6_147516_84060 n1_M7_147516_84060 10.000000
R26525 n1_M6_147516_96060 n1_M7_147516_96060 10.000000
R26526 n1_M6_147516_108060 n1_M7_147516_108060 10.000000
R26527 n1_M6_147516_120060 n1_M7_147516_120060 10.000000
R26528 n1_M6_147516_132060 n1_M7_147516_132060 10.000000
R26529 n1_M6_147516_144060 n1_M7_147516_144060 10.000000
R26530 n1_M7_60_60 n1_M8_60_60 10.000000
R26531 n1_M7_60_6460 n1_M8_60_6460 10.000000
R26532 n1_M7_60_12860 n1_M8_60_12860 10.000000
R26533 n1_M7_60_19260 n1_M8_60_19260 10.000000
R26534 n1_M7_60_25660 n1_M8_60_25660 10.000000
R26535 n1_M7_60_32060 n1_M8_60_32060 10.000000
R26536 n1_M7_60_38460 n1_M8_60_38460 10.000000
R26537 n1_M7_60_44860 n1_M8_60_44860 10.000000
R26538 n1_M7_60_51260 n1_M8_60_51260 10.000000
R26539 n1_M7_60_57660 n1_M8_60_57660 10.000000
R26540 n1_M7_60_64060 n1_M8_60_64060 10.000000
R26541 n1_M7_60_70460 n1_M8_60_70460 10.000000
R26542 n1_M7_60_76860 n1_M8_60_76860 10.000000
R26543 n1_M7_60_83260 n1_M8_60_83260 10.000000
R26544 n1_M7_60_89660 n1_M8_60_89660 10.000000
R26545 n1_M7_60_96060 n1_M8_60_96060 10.000000
R26546 n1_M7_60_102460 n1_M8_60_102460 10.000000
R26547 n1_M7_60_108860 n1_M8_60_108860 10.000000
R26548 n1_M7_60_115260 n1_M8_60_115260 10.000000
R26549 n1_M7_60_121660 n1_M8_60_121660 10.000000
R26550 n1_M7_60_128060 n1_M8_60_128060 10.000000
R26551 n1_M7_60_134460 n1_M8_60_134460 10.000000
R26552 n1_M7_60_140860 n1_M8_60_140860 10.000000
R26553 n1_M7_60_147260 n1_M8_60_147260 10.000000
R26554 n1_M7_4156_60 n1_M8_4380_60 10.000000
R26555 n1_M7_4156_6460 n1_M8_4380_6460 10.000000
R26556 n1_M7_4156_12860 n1_M8_4380_12860 10.000000
R26557 n1_M7_4156_19260 n1_M8_4380_19260 10.000000
R26558 n1_M7_4156_25660 n1_M8_4380_25660 10.000000
R26559 n1_M7_4156_32060 n1_M8_4380_32060 10.000000
R26560 n1_M7_4156_38460 n1_M8_4380_38460 10.000000
R26561 n1_M7_4156_44860 n1_M8_4380_44860 10.000000
R26562 n1_M7_4156_51260 n1_M8_4380_51260 10.000000
R26563 n1_M7_4156_57660 n1_M8_4380_57660 10.000000
R26564 n1_M7_4156_64060 n1_M8_4380_64060 10.000000
R26565 n1_M7_4156_70460 n1_M8_4380_70460 10.000000
R26566 n1_M7_4156_76860 n1_M8_4380_76860 10.000000
R26567 n1_M7_4156_83260 n1_M8_4380_83260 10.000000
R26568 n1_M7_4156_89660 n1_M8_4380_89660 10.000000
R26569 n1_M7_4156_96060 n1_M8_4380_96060 10.000000
R26570 n1_M7_4156_102460 n1_M8_4380_102460 10.000000
R26571 n1_M7_4156_108860 n1_M8_4380_108860 10.000000
R26572 n1_M7_4156_115260 n1_M8_4380_115260 10.000000
R26573 n1_M7_4156_121660 n1_M8_4380_121660 10.000000
R26574 n1_M7_4156_128060 n1_M8_4380_128060 10.000000
R26575 n1_M7_4156_134460 n1_M8_4380_134460 10.000000
R26576 n1_M7_4156_140860 n1_M8_4380_140860 10.000000
R26577 n1_M7_4156_147260 n1_M8_4380_147260 10.000000
R26578 n1_M7_8252_60 n1_M8_8700_60 10.000000
R26579 n1_M7_8252_6460 n1_M8_8700_6460 10.000000
R26580 n1_M7_8252_12860 n1_M8_8700_12860 10.000000
R26581 n1_M7_8252_19260 n1_M8_8700_19260 10.000000
R26582 n1_M7_8252_25660 n1_M8_8700_25660 10.000000
R26583 n1_M7_8252_32060 n1_M8_8700_32060 10.000000
R26584 n1_M7_8252_38460 n1_M8_8700_38460 10.000000
R26585 n1_M7_8252_44860 n1_M8_8700_44860 10.000000
R26586 n1_M7_8252_51260 n1_M8_8700_51260 10.000000
R26587 n1_M7_8252_57660 n1_M8_8700_57660 10.000000
R26588 n1_M7_8252_64060 n1_M8_8700_64060 10.000000
R26589 n1_M7_8252_70460 n1_M8_8700_70460 10.000000
R26590 n1_M7_8252_76860 n1_M8_8700_76860 10.000000
R26591 n1_M7_8252_83260 n1_M8_8700_83260 10.000000
R26592 n1_M7_8252_89660 n1_M8_8700_89660 10.000000
R26593 n1_M7_8252_96060 n1_M8_8700_96060 10.000000
R26594 n1_M7_8252_102460 n1_M8_8700_102460 10.000000
R26595 n1_M7_8252_108860 n1_M8_8700_108860 10.000000
R26596 n1_M7_8252_115260 n1_M8_8700_115260 10.000000
R26597 n1_M7_8252_121660 n1_M8_8700_121660 10.000000
R26598 n1_M7_8252_128060 n1_M8_8700_128060 10.000000
R26599 n1_M7_8252_134460 n1_M8_8700_134460 10.000000
R26600 n1_M7_8252_140860 n1_M8_8700_140860 10.000000
R26601 n1_M7_8252_147260 n1_M8_8700_147260 10.000000
R26602 n1_M7_12348_60 n1_M8_11940_60 10.000000
R26603 n1_M7_12348_6460 n1_M8_11940_6460 10.000000
R26604 n1_M7_12348_12860 n1_M8_11940_12860 10.000000
R26605 n1_M7_12348_19260 n1_M8_11940_19260 10.000000
R26606 n1_M7_12348_25660 n1_M8_11940_25660 10.000000
R26607 n1_M7_12348_32060 n1_M8_11940_32060 10.000000
R26608 n1_M7_12348_38460 n1_M8_11940_38460 10.000000
R26609 n1_M7_12348_44860 n1_M8_11940_44860 10.000000
R26610 n1_M7_12348_51260 n1_M8_11940_51260 10.000000
R26611 n1_M7_12348_57660 n1_M8_11940_57660 10.000000
R26612 n1_M7_12348_64060 n1_M8_11940_64060 10.000000
R26613 n1_M7_12348_70460 n1_M8_11940_70460 10.000000
R26614 n1_M7_12348_76860 n1_M8_11940_76860 10.000000
R26615 n1_M7_12348_83260 n1_M8_11940_83260 10.000000
R26616 n1_M7_12348_89660 n1_M8_11940_89660 10.000000
R26617 n1_M7_12348_96060 n1_M8_11940_96060 10.000000
R26618 n1_M7_12348_102460 n1_M8_11940_102460 10.000000
R26619 n1_M7_12348_108860 n1_M8_11940_108860 10.000000
R26620 n1_M7_12348_115260 n1_M8_11940_115260 10.000000
R26621 n1_M7_12348_121660 n1_M8_11940_121660 10.000000
R26622 n1_M7_12348_128060 n1_M8_11940_128060 10.000000
R26623 n1_M7_12348_134460 n1_M8_11940_134460 10.000000
R26624 n1_M7_12348_140860 n1_M8_11940_140860 10.000000
R26625 n1_M7_12348_147260 n1_M8_11940_147260 10.000000
R26626 n1_M7_16444_60 n1_M8_16260_60 10.000000
R26627 n1_M7_16444_6460 n1_M8_16260_6460 10.000000
R26628 n1_M7_16444_12860 n1_M8_16260_12860 10.000000
R26629 n1_M7_16444_19260 n1_M8_16260_19260 10.000000
R26630 n1_M7_16444_25660 n1_M8_16260_25660 10.000000
R26631 n1_M7_16444_32060 n1_M8_16260_32060 10.000000
R26632 n1_M7_16444_38460 n1_M8_16260_38460 10.000000
R26633 n1_M7_16444_44860 n1_M8_16260_44860 10.000000
R26634 n1_M7_16444_51260 n1_M8_16260_51260 10.000000
R26635 n1_M7_16444_57660 n1_M8_16260_57660 10.000000
R26636 n1_M7_16444_64060 n1_M8_16260_64060 10.000000
R26637 n1_M7_16444_70460 n1_M8_16260_70460 10.000000
R26638 n1_M7_16444_76860 n1_M8_16260_76860 10.000000
R26639 n1_M7_16444_83260 n1_M8_16260_83260 10.000000
R26640 n1_M7_16444_89660 n1_M8_16260_89660 10.000000
R26641 n1_M7_16444_96060 n1_M8_16260_96060 10.000000
R26642 n1_M7_16444_102460 n1_M8_16260_102460 10.000000
R26643 n1_M7_16444_108860 n1_M8_16260_108860 10.000000
R26644 n1_M7_16444_115260 n1_M8_16260_115260 10.000000
R26645 n1_M7_16444_121660 n1_M8_16260_121660 10.000000
R26646 n1_M7_16444_128060 n1_M8_16260_128060 10.000000
R26647 n1_M7_16444_134460 n1_M8_16260_134460 10.000000
R26648 n1_M7_16444_140860 n1_M8_16260_140860 10.000000
R26649 n1_M7_16444_147260 n1_M8_16260_147260 10.000000
R26650 n1_M7_20540_60 n1_M8_20580_60 10.000000
R26651 n1_M7_20540_6460 n1_M8_20580_6460 10.000000
R26652 n1_M7_20540_12860 n1_M8_20580_12860 10.000000
R26653 n1_M7_20540_19260 n1_M8_20580_19260 10.000000
R26654 n1_M7_20540_25660 n1_M8_20580_25660 10.000000
R26655 n1_M7_20540_32060 n1_M8_20580_32060 10.000000
R26656 n1_M7_20540_38460 n1_M8_20580_38460 10.000000
R26657 n1_M7_20540_44860 n1_M8_20580_44860 10.000000
R26658 n1_M7_20540_51260 n1_M8_20580_51260 10.000000
R26659 n1_M7_20540_57660 n1_M8_20580_57660 10.000000
R26660 n1_M7_20540_64060 n1_M8_20580_64060 10.000000
R26661 n1_M7_20540_70460 n1_M8_20580_70460 10.000000
R26662 n1_M7_20540_76860 n1_M8_20580_76860 10.000000
R26663 n1_M7_20540_83260 n1_M8_20580_83260 10.000000
R26664 n1_M7_20540_89660 n1_M8_20580_89660 10.000000
R26665 n1_M7_20540_96060 n1_M8_20580_96060 10.000000
R26666 n1_M7_20540_102460 n1_M8_20580_102460 10.000000
R26667 n1_M7_20540_108860 n1_M8_20580_108860 10.000000
R26668 n1_M7_20540_115260 n1_M8_20580_115260 10.000000
R26669 n1_M7_20540_121660 n1_M8_20580_121660 10.000000
R26670 n1_M7_20540_128060 n1_M8_20580_128060 10.000000
R26671 n1_M7_20540_134460 n1_M8_20580_134460 10.000000
R26672 n1_M7_20540_140860 n1_M8_20580_140860 10.000000
R26673 n1_M7_20540_147260 n1_M8_20580_147260 10.000000
R26674 n1_M7_24636_60 n1_M8_24900_60 10.000000
R26675 n1_M7_24636_6460 n1_M8_24900_6460 10.000000
R26676 n1_M7_24636_12860 n1_M8_24900_12860 10.000000
R26677 n1_M7_24636_19260 n1_M8_24900_19260 10.000000
R26678 n1_M7_24636_25660 n1_M8_24900_25660 10.000000
R26679 n1_M7_24636_32060 n1_M8_24900_32060 10.000000
R26680 n1_M7_24636_38460 n1_M8_24900_38460 10.000000
R26681 n1_M7_24636_44860 n1_M8_24900_44860 10.000000
R26682 n1_M7_24636_51260 n1_M8_24900_51260 10.000000
R26683 n1_M7_24636_57660 n1_M8_24900_57660 10.000000
R26684 n1_M7_24636_64060 n1_M8_24900_64060 10.000000
R26685 n1_M7_24636_70460 n1_M8_24900_70460 10.000000
R26686 n1_M7_24636_76860 n1_M8_24900_76860 10.000000
R26687 n1_M7_24636_83260 n1_M8_24900_83260 10.000000
R26688 n1_M7_24636_89660 n1_M8_24900_89660 10.000000
R26689 n1_M7_24636_96060 n1_M8_24900_96060 10.000000
R26690 n1_M7_24636_102460 n1_M8_24900_102460 10.000000
R26691 n1_M7_24636_108860 n1_M8_24900_108860 10.000000
R26692 n1_M7_24636_115260 n1_M8_24900_115260 10.000000
R26693 n1_M7_24636_121660 n1_M8_24900_121660 10.000000
R26694 n1_M7_24636_128060 n1_M8_24900_128060 10.000000
R26695 n1_M7_24636_134460 n1_M8_24900_134460 10.000000
R26696 n1_M7_24636_140860 n1_M8_24900_140860 10.000000
R26697 n1_M7_24636_147260 n1_M8_24900_147260 10.000000
R26698 n1_M7_28732_60 n1_M8_29220_60 10.000000
R26699 n1_M7_28732_6460 n1_M8_29220_6460 10.000000
R26700 n1_M7_28732_12860 n1_M8_29220_12860 10.000000
R26701 n1_M7_28732_19260 n1_M8_29220_19260 10.000000
R26702 n1_M7_28732_25660 n1_M8_29220_25660 10.000000
R26703 n1_M7_28732_32060 n1_M8_29220_32060 10.000000
R26704 n1_M7_28732_38460 n1_M8_29220_38460 10.000000
R26705 n1_M7_28732_44860 n1_M8_29220_44860 10.000000
R26706 n1_M7_28732_51260 n1_M8_29220_51260 10.000000
R26707 n1_M7_28732_57660 n1_M8_29220_57660 10.000000
R26708 n1_M7_28732_64060 n1_M8_29220_64060 10.000000
R26709 n1_M7_28732_70460 n1_M8_29220_70460 10.000000
R26710 n1_M7_28732_76860 n1_M8_29220_76860 10.000000
R26711 n1_M7_28732_83260 n1_M8_29220_83260 10.000000
R26712 n1_M7_28732_89660 n1_M8_29220_89660 10.000000
R26713 n1_M7_28732_96060 n1_M8_29220_96060 10.000000
R26714 n1_M7_28732_102460 n1_M8_29220_102460 10.000000
R26715 n1_M7_28732_108860 n1_M8_29220_108860 10.000000
R26716 n1_M7_28732_115260 n1_M8_29220_115260 10.000000
R26717 n1_M7_28732_121660 n1_M8_29220_121660 10.000000
R26718 n1_M7_28732_128060 n1_M8_29220_128060 10.000000
R26719 n1_M7_28732_134460 n1_M8_29220_134460 10.000000
R26720 n1_M7_28732_140860 n1_M8_29220_140860 10.000000
R26721 n1_M7_28732_147260 n1_M8_29220_147260 10.000000
R26722 n1_M7_32828_60 n1_M8_32460_60 10.000000
R26723 n1_M7_32828_6460 n1_M8_32460_6460 10.000000
R26724 n1_M7_32828_12860 n1_M8_32460_12860 10.000000
R26725 n1_M7_32828_19260 n1_M8_32460_19260 10.000000
R26726 n1_M7_32828_25660 n1_M8_32460_25660 10.000000
R26727 n1_M7_32828_32060 n1_M8_32460_32060 10.000000
R26728 n1_M7_32828_38460 n1_M8_32460_38460 10.000000
R26729 n1_M7_32828_44860 n1_M8_32460_44860 10.000000
R26730 n1_M7_32828_51260 n1_M8_32460_51260 10.000000
R26731 n1_M7_32828_57660 n1_M8_32460_57660 10.000000
R26732 n1_M7_32828_64060 n1_M8_32460_64060 10.000000
R26733 n1_M7_32828_70460 n1_M8_32460_70460 10.000000
R26734 n1_M7_32828_76860 n1_M8_32460_76860 10.000000
R26735 n1_M7_32828_83260 n1_M8_32460_83260 10.000000
R26736 n1_M7_32828_89660 n1_M8_32460_89660 10.000000
R26737 n1_M7_32828_96060 n1_M8_32460_96060 10.000000
R26738 n1_M7_32828_102460 n1_M8_32460_102460 10.000000
R26739 n1_M7_32828_108860 n1_M8_32460_108860 10.000000
R26740 n1_M7_32828_115260 n1_M8_32460_115260 10.000000
R26741 n1_M7_32828_121660 n1_M8_32460_121660 10.000000
R26742 n1_M7_32828_128060 n1_M8_32460_128060 10.000000
R26743 n1_M7_32828_134460 n1_M8_32460_134460 10.000000
R26744 n1_M7_32828_140860 n1_M8_32460_140860 10.000000
R26745 n1_M7_32828_147260 n1_M8_32460_147260 10.000000
R26746 n1_M7_36924_60 n1_M8_36780_60 10.000000
R26747 n1_M7_36924_6460 n1_M8_36780_6460 10.000000
R26748 n1_M7_36924_12860 n1_M8_36780_12860 10.000000
R26749 n1_M7_36924_19260 n1_M8_36780_19260 10.000000
R26750 n1_M7_36924_25660 n1_M8_36780_25660 10.000000
R26751 n1_M7_36924_32060 n1_M8_36780_32060 10.000000
R26752 n1_M7_36924_38460 n1_M8_36780_38460 10.000000
R26753 n1_M7_36924_44860 n1_M8_36780_44860 10.000000
R26754 n1_M7_36924_51260 n1_M8_36780_51260 10.000000
R26755 n1_M7_36924_57660 n1_M8_36780_57660 10.000000
R26756 n1_M7_36924_64060 n1_M8_36780_64060 10.000000
R26757 n1_M7_36924_70460 n1_M8_36780_70460 10.000000
R26758 n1_M7_36924_76860 n1_M8_36780_76860 10.000000
R26759 n1_M7_36924_83260 n1_M8_36780_83260 10.000000
R26760 n1_M7_36924_89660 n1_M8_36780_89660 10.000000
R26761 n1_M7_36924_96060 n1_M8_36780_96060 10.000000
R26762 n1_M7_36924_102460 n1_M8_36780_102460 10.000000
R26763 n1_M7_36924_108860 n1_M8_36780_108860 10.000000
R26764 n1_M7_36924_115260 n1_M8_36780_115260 10.000000
R26765 n1_M7_36924_121660 n1_M8_36780_121660 10.000000
R26766 n1_M7_36924_128060 n1_M8_36780_128060 10.000000
R26767 n1_M7_36924_134460 n1_M8_36780_134460 10.000000
R26768 n1_M7_36924_140860 n1_M8_36780_140860 10.000000
R26769 n1_M7_36924_147260 n1_M8_36780_147260 10.000000
R26770 n1_M7_41020_60 n1_M8_41100_60 10.000000
R26771 n1_M7_41020_6460 n1_M8_41100_6460 10.000000
R26772 n1_M7_41020_12860 n1_M8_41100_12860 10.000000
R26773 n1_M7_41020_19260 n1_M8_41100_19260 10.000000
R26774 n1_M7_41020_25660 n1_M8_41100_25660 10.000000
R26775 n1_M7_41020_32060 n1_M8_41100_32060 10.000000
R26776 n1_M7_41020_38460 n1_M8_41100_38460 10.000000
R26777 n1_M7_41020_44860 n1_M8_41100_44860 10.000000
R26778 n1_M7_41020_51260 n1_M8_41100_51260 10.000000
R26779 n1_M7_41020_57660 n1_M8_41100_57660 10.000000
R26780 n1_M7_41020_64060 n1_M8_41100_64060 10.000000
R26781 n1_M7_41020_70460 n1_M8_41100_70460 10.000000
R26782 n1_M7_41020_76860 n1_M8_41100_76860 10.000000
R26783 n1_M7_41020_83260 n1_M8_41100_83260 10.000000
R26784 n1_M7_41020_89660 n1_M8_41100_89660 10.000000
R26785 n1_M7_41020_96060 n1_M8_41100_96060 10.000000
R26786 n1_M7_41020_102460 n1_M8_41100_102460 10.000000
R26787 n1_M7_41020_108860 n1_M8_41100_108860 10.000000
R26788 n1_M7_41020_115260 n1_M8_41100_115260 10.000000
R26789 n1_M7_41020_121660 n1_M8_41100_121660 10.000000
R26790 n1_M7_41020_128060 n1_M8_41100_128060 10.000000
R26791 n1_M7_41020_134460 n1_M8_41100_134460 10.000000
R26792 n1_M7_41020_140860 n1_M8_41100_140860 10.000000
R26793 n1_M7_41020_147260 n1_M8_41100_147260 10.000000
R26794 n1_M7_45116_60 n1_M8_45420_60 10.000000
R26795 n1_M7_45116_6460 n1_M8_45420_6460 10.000000
R26796 n1_M7_45116_12860 n1_M8_45420_12860 10.000000
R26797 n1_M7_45116_19260 n1_M8_45420_19260 10.000000
R26798 n1_M7_45116_25660 n1_M8_45420_25660 10.000000
R26799 n1_M7_45116_32060 n1_M8_45420_32060 10.000000
R26800 n1_M7_45116_38460 n1_M8_45420_38460 10.000000
R26801 n1_M7_45116_44860 n1_M8_45420_44860 10.000000
R26802 n1_M7_45116_51260 n1_M8_45420_51260 10.000000
R26803 n1_M7_45116_57660 n1_M8_45420_57660 10.000000
R26804 n1_M7_45116_64060 n1_M8_45420_64060 10.000000
R26805 n1_M7_45116_70460 n1_M8_45420_70460 10.000000
R26806 n1_M7_45116_76860 n1_M8_45420_76860 10.000000
R26807 n1_M7_45116_83260 n1_M8_45420_83260 10.000000
R26808 n1_M7_45116_89660 n1_M8_45420_89660 10.000000
R26809 n1_M7_45116_96060 n1_M8_45420_96060 10.000000
R26810 n1_M7_45116_102460 n1_M8_45420_102460 10.000000
R26811 n1_M7_45116_108860 n1_M8_45420_108860 10.000000
R26812 n1_M7_45116_115260 n1_M8_45420_115260 10.000000
R26813 n1_M7_45116_121660 n1_M8_45420_121660 10.000000
R26814 n1_M7_45116_128060 n1_M8_45420_128060 10.000000
R26815 n1_M7_45116_134460 n1_M8_45420_134460 10.000000
R26816 n1_M7_45116_140860 n1_M8_45420_140860 10.000000
R26817 n1_M7_45116_147260 n1_M8_45420_147260 10.000000
R26818 n1_M7_49212_60 n1_M8_49740_60 10.000000
R26819 n1_M7_49212_6460 n1_M8_49740_6460 10.000000
R26820 n1_M7_49212_12860 n1_M8_49740_12860 10.000000
R26821 n1_M7_49212_19260 n1_M8_49740_19260 10.000000
R26822 n1_M7_49212_25660 n1_M8_49740_25660 10.000000
R26823 n1_M7_49212_32060 n1_M8_49740_32060 10.000000
R26824 n1_M7_49212_38460 n1_M8_49740_38460 10.000000
R26825 n1_M7_49212_44860 n1_M8_49740_44860 10.000000
R26826 n1_M7_49212_51260 n1_M8_49740_51260 10.000000
R26827 n1_M7_49212_57660 n1_M8_49740_57660 10.000000
R26828 n1_M7_49212_64060 n1_M8_49740_64060 10.000000
R26829 n1_M7_49212_70460 n1_M8_49740_70460 10.000000
R26830 n1_M7_49212_76860 n1_M8_49740_76860 10.000000
R26831 n1_M7_49212_83260 n1_M8_49740_83260 10.000000
R26832 n1_M7_49212_89660 n1_M8_49740_89660 10.000000
R26833 n1_M7_49212_96060 n1_M8_49740_96060 10.000000
R26834 n1_M7_49212_102460 n1_M8_49740_102460 10.000000
R26835 n1_M7_49212_108860 n1_M8_49740_108860 10.000000
R26836 n1_M7_49212_115260 n1_M8_49740_115260 10.000000
R26837 n1_M7_49212_121660 n1_M8_49740_121660 10.000000
R26838 n1_M7_49212_128060 n1_M8_49740_128060 10.000000
R26839 n1_M7_49212_134460 n1_M8_49740_134460 10.000000
R26840 n1_M7_49212_140860 n1_M8_49740_140860 10.000000
R26841 n1_M7_49212_147260 n1_M8_49740_147260 10.000000
R26842 n1_M7_53308_60 n1_M8_52980_60 10.000000
R26843 n1_M7_53308_6460 n1_M8_52980_6460 10.000000
R26844 n1_M7_53308_12860 n1_M8_52980_12860 10.000000
R26845 n1_M7_53308_19260 n1_M8_52980_19260 10.000000
R26846 n1_M7_53308_25660 n1_M8_52980_25660 10.000000
R26847 n1_M7_53308_32060 n1_M8_52980_32060 10.000000
R26848 n1_M7_53308_38460 n1_M8_52980_38460 10.000000
R26849 n1_M7_53308_44860 n1_M8_52980_44860 10.000000
R26850 n1_M7_53308_51260 n1_M8_52980_51260 10.000000
R26851 n1_M7_53308_57660 n1_M8_52980_57660 10.000000
R26852 n1_M7_53308_64060 n1_M8_52980_64060 10.000000
R26853 n1_M7_53308_70460 n1_M8_52980_70460 10.000000
R26854 n1_M7_53308_76860 n1_M8_52980_76860 10.000000
R26855 n1_M7_53308_83260 n1_M8_52980_83260 10.000000
R26856 n1_M7_53308_89660 n1_M8_52980_89660 10.000000
R26857 n1_M7_53308_96060 n1_M8_52980_96060 10.000000
R26858 n1_M7_53308_102460 n1_M8_52980_102460 10.000000
R26859 n1_M7_53308_108860 n1_M8_52980_108860 10.000000
R26860 n1_M7_53308_115260 n1_M8_52980_115260 10.000000
R26861 n1_M7_53308_121660 n1_M8_52980_121660 10.000000
R26862 n1_M7_53308_128060 n1_M8_52980_128060 10.000000
R26863 n1_M7_53308_134460 n1_M8_52980_134460 10.000000
R26864 n1_M7_53308_140860 n1_M8_52980_140860 10.000000
R26865 n1_M7_53308_147260 n1_M8_52980_147260 10.000000
R26866 n1_M7_57404_60 n1_M8_57300_60 10.000000
R26867 n1_M7_57404_6460 n1_M8_57300_6460 10.000000
R26868 n1_M7_57404_12860 n1_M8_57300_12860 10.000000
R26869 n1_M7_57404_19260 n1_M8_57300_19260 10.000000
R26870 n1_M7_57404_25660 n1_M8_57300_25660 10.000000
R26871 n1_M7_57404_32060 n1_M8_57300_32060 10.000000
R26872 n1_M7_57404_38460 n1_M8_57300_38460 10.000000
R26873 n1_M7_57404_44860 n1_M8_57300_44860 10.000000
R26874 n1_M7_57404_51260 n1_M8_57300_51260 10.000000
R26875 n1_M7_57404_57660 n1_M8_57300_57660 10.000000
R26876 n1_M7_57404_64060 n1_M8_57300_64060 10.000000
R26877 n1_M7_57404_70460 n1_M8_57300_70460 10.000000
R26878 n1_M7_57404_76860 n1_M8_57300_76860 10.000000
R26879 n1_M7_57404_83260 n1_M8_57300_83260 10.000000
R26880 n1_M7_57404_89660 n1_M8_57300_89660 10.000000
R26881 n1_M7_57404_96060 n1_M8_57300_96060 10.000000
R26882 n1_M7_57404_102460 n1_M8_57300_102460 10.000000
R26883 n1_M7_57404_108860 n1_M8_57300_108860 10.000000
R26884 n1_M7_57404_115260 n1_M8_57300_115260 10.000000
R26885 n1_M7_57404_121660 n1_M8_57300_121660 10.000000
R26886 n1_M7_57404_128060 n1_M8_57300_128060 10.000000
R26887 n1_M7_57404_134460 n1_M8_57300_134460 10.000000
R26888 n1_M7_57404_140860 n1_M8_57300_140860 10.000000
R26889 n1_M7_57404_147260 n1_M8_57300_147260 10.000000
R26890 n1_M7_61500_60 n1_M8_61620_60 10.000000
R26891 n1_M7_61500_6460 n1_M8_61620_6460 10.000000
R26892 n1_M7_61500_12860 n1_M8_61620_12860 10.000000
R26893 n1_M7_61500_19260 n1_M8_61620_19260 10.000000
R26894 n1_M7_61500_25660 n1_M8_61620_25660 10.000000
R26895 n1_M7_61500_32060 n1_M8_61620_32060 10.000000
R26896 n1_M7_61500_38460 n1_M8_61620_38460 10.000000
R26897 n1_M7_61500_44860 n1_M8_61620_44860 10.000000
R26898 n1_M7_61500_51260 n1_M8_61620_51260 10.000000
R26899 n1_M7_61500_57660 n1_M8_61620_57660 10.000000
R26900 n1_M7_61500_64060 n1_M8_61620_64060 10.000000
R26901 n1_M7_61500_70460 n1_M8_61620_70460 10.000000
R26902 n1_M7_61500_76860 n1_M8_61620_76860 10.000000
R26903 n1_M7_61500_83260 n1_M8_61620_83260 10.000000
R26904 n1_M7_61500_89660 n1_M8_61620_89660 10.000000
R26905 n1_M7_61500_96060 n1_M8_61620_96060 10.000000
R26906 n1_M7_61500_102460 n1_M8_61620_102460 10.000000
R26907 n1_M7_61500_108860 n1_M8_61620_108860 10.000000
R26908 n1_M7_61500_115260 n1_M8_61620_115260 10.000000
R26909 n1_M7_61500_121660 n1_M8_61620_121660 10.000000
R26910 n1_M7_61500_128060 n1_M8_61620_128060 10.000000
R26911 n1_M7_61500_134460 n1_M8_61620_134460 10.000000
R26912 n1_M7_61500_140860 n1_M8_61620_140860 10.000000
R26913 n1_M7_61500_147260 n1_M8_61620_147260 10.000000
R26914 n1_M7_65596_60 n1_M8_65940_60 10.000000
R26915 n1_M7_65596_6460 n1_M8_65940_6460 10.000000
R26916 n1_M7_65596_12860 n1_M8_65940_12860 10.000000
R26917 n1_M7_65596_19260 n1_M8_65940_19260 10.000000
R26918 n1_M7_65596_25660 n1_M8_65940_25660 10.000000
R26919 n1_M7_65596_32060 n1_M8_65940_32060 10.000000
R26920 n1_M7_65596_38460 n1_M8_65940_38460 10.000000
R26921 n1_M7_65596_44860 n1_M8_65940_44860 10.000000
R26922 n1_M7_65596_51260 n1_M8_65940_51260 10.000000
R26923 n1_M7_65596_57660 n1_M8_65940_57660 10.000000
R26924 n1_M7_65596_64060 n1_M8_65940_64060 10.000000
R26925 n1_M7_65596_70460 n1_M8_65940_70460 10.000000
R26926 n1_M7_65596_76860 n1_M8_65940_76860 10.000000
R26927 n1_M7_65596_83260 n1_M8_65940_83260 10.000000
R26928 n1_M7_65596_89660 n1_M8_65940_89660 10.000000
R26929 n1_M7_65596_96060 n1_M8_65940_96060 10.000000
R26930 n1_M7_65596_102460 n1_M8_65940_102460 10.000000
R26931 n1_M7_65596_108860 n1_M8_65940_108860 10.000000
R26932 n1_M7_65596_115260 n1_M8_65940_115260 10.000000
R26933 n1_M7_65596_121660 n1_M8_65940_121660 10.000000
R26934 n1_M7_65596_128060 n1_M8_65940_128060 10.000000
R26935 n1_M7_65596_134460 n1_M8_65940_134460 10.000000
R26936 n1_M7_65596_140860 n1_M8_65940_140860 10.000000
R26937 n1_M7_65596_147260 n1_M8_65940_147260 10.000000
R26938 n1_M7_69692_60 n1_M8_69180_60 10.000000
R26939 n1_M7_69692_6460 n1_M8_69180_6460 10.000000
R26940 n1_M7_69692_12860 n1_M8_69180_12860 10.000000
R26941 n1_M7_69692_19260 n1_M8_69180_19260 10.000000
R26942 n1_M7_69692_25660 n1_M8_69180_25660 10.000000
R26943 n1_M7_69692_32060 n1_M8_69180_32060 10.000000
R26944 n1_M7_69692_38460 n1_M8_69180_38460 10.000000
R26945 n1_M7_69692_44860 n1_M8_69180_44860 10.000000
R26946 n1_M7_69692_51260 n1_M8_69180_51260 10.000000
R26947 n1_M7_69692_57660 n1_M8_69180_57660 10.000000
R26948 n1_M7_69692_64060 n1_M8_69180_64060 10.000000
R26949 n1_M7_69692_70460 n1_M8_69180_70460 10.000000
R26950 n1_M7_69692_76860 n1_M8_69180_76860 10.000000
R26951 n1_M7_69692_83260 n1_M8_69180_83260 10.000000
R26952 n1_M7_69692_89660 n1_M8_69180_89660 10.000000
R26953 n1_M7_69692_96060 n1_M8_69180_96060 10.000000
R26954 n1_M7_69692_102460 n1_M8_69180_102460 10.000000
R26955 n1_M7_69692_108860 n1_M8_69180_108860 10.000000
R26956 n1_M7_69692_115260 n1_M8_69180_115260 10.000000
R26957 n1_M7_69692_121660 n1_M8_69180_121660 10.000000
R26958 n1_M7_69692_128060 n1_M8_69180_128060 10.000000
R26959 n1_M7_69692_134460 n1_M8_69180_134460 10.000000
R26960 n1_M7_69692_140860 n1_M8_69180_140860 10.000000
R26961 n1_M7_69692_147260 n1_M8_69180_147260 10.000000
R26962 n1_M7_73788_60 n1_M8_73500_60 10.000000
R26963 n1_M7_73788_6460 n1_M8_73500_6460 10.000000
R26964 n1_M7_73788_12860 n1_M8_73500_12860 10.000000
R26965 n1_M7_73788_19260 n1_M8_73500_19260 10.000000
R26966 n1_M7_73788_25660 n1_M8_73500_25660 10.000000
R26967 n1_M7_73788_32060 n1_M8_73500_32060 10.000000
R26968 n1_M7_73788_38460 n1_M8_73500_38460 10.000000
R26969 n1_M7_73788_44860 n1_M8_73500_44860 10.000000
R26970 n1_M7_73788_51260 n1_M8_73500_51260 10.000000
R26971 n1_M7_73788_57660 n1_M8_73500_57660 10.000000
R26972 n1_M7_73788_64060 n1_M8_73500_64060 10.000000
R26973 n1_M7_73788_70460 n1_M8_73500_70460 10.000000
R26974 n1_M7_73788_76860 n1_M8_73500_76860 10.000000
R26975 n1_M7_73788_83260 n1_M8_73500_83260 10.000000
R26976 n1_M7_73788_89660 n1_M8_73500_89660 10.000000
R26977 n1_M7_73788_96060 n1_M8_73500_96060 10.000000
R26978 n1_M7_73788_102460 n1_M8_73500_102460 10.000000
R26979 n1_M7_73788_108860 n1_M8_73500_108860 10.000000
R26980 n1_M7_73788_115260 n1_M8_73500_115260 10.000000
R26981 n1_M7_73788_121660 n1_M8_73500_121660 10.000000
R26982 n1_M7_73788_128060 n1_M8_73500_128060 10.000000
R26983 n1_M7_73788_134460 n1_M8_73500_134460 10.000000
R26984 n1_M7_73788_140860 n1_M8_73500_140860 10.000000
R26985 n1_M7_73788_147260 n1_M8_73500_147260 10.000000
R26986 n1_M7_77884_60 n1_M8_77820_60 10.000000
R26987 n1_M7_77884_6460 n1_M8_77820_6460 10.000000
R26988 n1_M7_77884_12860 n1_M8_77820_12860 10.000000
R26989 n1_M7_77884_19260 n1_M8_77820_19260 10.000000
R26990 n1_M7_77884_25660 n1_M8_77820_25660 10.000000
R26991 n1_M7_77884_32060 n1_M8_77820_32060 10.000000
R26992 n1_M7_77884_38460 n1_M8_77820_38460 10.000000
R26993 n1_M7_77884_44860 n1_M8_77820_44860 10.000000
R26994 n1_M7_77884_51260 n1_M8_77820_51260 10.000000
R26995 n1_M7_77884_57660 n1_M8_77820_57660 10.000000
R26996 n1_M7_77884_64060 n1_M8_77820_64060 10.000000
R26997 n1_M7_77884_70460 n1_M8_77820_70460 10.000000
R26998 n1_M7_77884_76860 n1_M8_77820_76860 10.000000
R26999 n1_M7_77884_83260 n1_M8_77820_83260 10.000000
R27000 n1_M7_77884_89660 n1_M8_77820_89660 10.000000
R27001 n1_M7_77884_96060 n1_M8_77820_96060 10.000000
R27002 n1_M7_77884_102460 n1_M8_77820_102460 10.000000
R27003 n1_M7_77884_108860 n1_M8_77820_108860 10.000000
R27004 n1_M7_77884_115260 n1_M8_77820_115260 10.000000
R27005 n1_M7_77884_121660 n1_M8_77820_121660 10.000000
R27006 n1_M7_77884_128060 n1_M8_77820_128060 10.000000
R27007 n1_M7_77884_134460 n1_M8_77820_134460 10.000000
R27008 n1_M7_77884_140860 n1_M8_77820_140860 10.000000
R27009 n1_M7_77884_147260 n1_M8_77820_147260 10.000000
R27010 n1_M7_81980_60 n1_M8_82140_60 10.000000
R27011 n1_M7_81980_6460 n1_M8_82140_6460 10.000000
R27012 n1_M7_81980_12860 n1_M8_82140_12860 10.000000
R27013 n1_M7_81980_19260 n1_M8_82140_19260 10.000000
R27014 n1_M7_81980_25660 n1_M8_82140_25660 10.000000
R27015 n1_M7_81980_32060 n1_M8_82140_32060 10.000000
R27016 n1_M7_81980_38460 n1_M8_82140_38460 10.000000
R27017 n1_M7_81980_44860 n1_M8_82140_44860 10.000000
R27018 n1_M7_81980_51260 n1_M8_82140_51260 10.000000
R27019 n1_M7_81980_57660 n1_M8_82140_57660 10.000000
R27020 n1_M7_81980_64060 n1_M8_82140_64060 10.000000
R27021 n1_M7_81980_70460 n1_M8_82140_70460 10.000000
R27022 n1_M7_81980_76860 n1_M8_82140_76860 10.000000
R27023 n1_M7_81980_83260 n1_M8_82140_83260 10.000000
R27024 n1_M7_81980_89660 n1_M8_82140_89660 10.000000
R27025 n1_M7_81980_96060 n1_M8_82140_96060 10.000000
R27026 n1_M7_81980_102460 n1_M8_82140_102460 10.000000
R27027 n1_M7_81980_108860 n1_M8_82140_108860 10.000000
R27028 n1_M7_81980_115260 n1_M8_82140_115260 10.000000
R27029 n1_M7_81980_121660 n1_M8_82140_121660 10.000000
R27030 n1_M7_81980_128060 n1_M8_82140_128060 10.000000
R27031 n1_M7_81980_134460 n1_M8_82140_134460 10.000000
R27032 n1_M7_81980_140860 n1_M8_82140_140860 10.000000
R27033 n1_M7_81980_147260 n1_M8_82140_147260 10.000000
R27034 n1_M7_86076_60 n1_M8_86460_60 10.000000
R27035 n1_M7_86076_6460 n1_M8_86460_6460 10.000000
R27036 n1_M7_86076_12860 n1_M8_86460_12860 10.000000
R27037 n1_M7_86076_19260 n1_M8_86460_19260 10.000000
R27038 n1_M7_86076_25660 n1_M8_86460_25660 10.000000
R27039 n1_M7_86076_32060 n1_M8_86460_32060 10.000000
R27040 n1_M7_86076_38460 n1_M8_86460_38460 10.000000
R27041 n1_M7_86076_44860 n1_M8_86460_44860 10.000000
R27042 n1_M7_86076_51260 n1_M8_86460_51260 10.000000
R27043 n1_M7_86076_57660 n1_M8_86460_57660 10.000000
R27044 n1_M7_86076_64060 n1_M8_86460_64060 10.000000
R27045 n1_M7_86076_70460 n1_M8_86460_70460 10.000000
R27046 n1_M7_86076_76860 n1_M8_86460_76860 10.000000
R27047 n1_M7_86076_83260 n1_M8_86460_83260 10.000000
R27048 n1_M7_86076_89660 n1_M8_86460_89660 10.000000
R27049 n1_M7_86076_96060 n1_M8_86460_96060 10.000000
R27050 n1_M7_86076_102460 n1_M8_86460_102460 10.000000
R27051 n1_M7_86076_108860 n1_M8_86460_108860 10.000000
R27052 n1_M7_86076_115260 n1_M8_86460_115260 10.000000
R27053 n1_M7_86076_121660 n1_M8_86460_121660 10.000000
R27054 n1_M7_86076_128060 n1_M8_86460_128060 10.000000
R27055 n1_M7_86076_134460 n1_M8_86460_134460 10.000000
R27056 n1_M7_86076_140860 n1_M8_86460_140860 10.000000
R27057 n1_M7_86076_147260 n1_M8_86460_147260 10.000000
R27058 n1_M7_90172_60 n1_M8_89700_60 10.000000
R27059 n1_M7_90172_6460 n1_M8_89700_6460 10.000000
R27060 n1_M7_90172_12860 n1_M8_89700_12860 10.000000
R27061 n1_M7_90172_19260 n1_M8_89700_19260 10.000000
R27062 n1_M7_90172_25660 n1_M8_89700_25660 10.000000
R27063 n1_M7_90172_32060 n1_M8_89700_32060 10.000000
R27064 n1_M7_90172_38460 n1_M8_89700_38460 10.000000
R27065 n1_M7_90172_44860 n1_M8_89700_44860 10.000000
R27066 n1_M7_90172_51260 n1_M8_89700_51260 10.000000
R27067 n1_M7_90172_57660 n1_M8_89700_57660 10.000000
R27068 n1_M7_90172_64060 n1_M8_89700_64060 10.000000
R27069 n1_M7_90172_70460 n1_M8_89700_70460 10.000000
R27070 n1_M7_90172_76860 n1_M8_89700_76860 10.000000
R27071 n1_M7_90172_83260 n1_M8_89700_83260 10.000000
R27072 n1_M7_90172_89660 n1_M8_89700_89660 10.000000
R27073 n1_M7_90172_96060 n1_M8_89700_96060 10.000000
R27074 n1_M7_90172_102460 n1_M8_89700_102460 10.000000
R27075 n1_M7_90172_108860 n1_M8_89700_108860 10.000000
R27076 n1_M7_90172_115260 n1_M8_89700_115260 10.000000
R27077 n1_M7_90172_121660 n1_M8_89700_121660 10.000000
R27078 n1_M7_90172_128060 n1_M8_89700_128060 10.000000
R27079 n1_M7_90172_134460 n1_M8_89700_134460 10.000000
R27080 n1_M7_90172_140860 n1_M8_89700_140860 10.000000
R27081 n1_M7_90172_147260 n1_M8_89700_147260 10.000000
R27082 n1_M7_94268_60 n1_M8_94020_60 10.000000
R27083 n1_M7_94268_6460 n1_M8_94020_6460 10.000000
R27084 n1_M7_94268_12860 n1_M8_94020_12860 10.000000
R27085 n1_M7_94268_19260 n1_M8_94020_19260 10.000000
R27086 n1_M7_94268_25660 n1_M8_94020_25660 10.000000
R27087 n1_M7_94268_32060 n1_M8_94020_32060 10.000000
R27088 n1_M7_94268_38460 n1_M8_94020_38460 10.000000
R27089 n1_M7_94268_44860 n1_M8_94020_44860 10.000000
R27090 n1_M7_94268_51260 n1_M8_94020_51260 10.000000
R27091 n1_M7_94268_57660 n1_M8_94020_57660 10.000000
R27092 n1_M7_94268_64060 n1_M8_94020_64060 10.000000
R27093 n1_M7_94268_70460 n1_M8_94020_70460 10.000000
R27094 n1_M7_94268_76860 n1_M8_94020_76860 10.000000
R27095 n1_M7_94268_83260 n1_M8_94020_83260 10.000000
R27096 n1_M7_94268_89660 n1_M8_94020_89660 10.000000
R27097 n1_M7_94268_96060 n1_M8_94020_96060 10.000000
R27098 n1_M7_94268_102460 n1_M8_94020_102460 10.000000
R27099 n1_M7_94268_108860 n1_M8_94020_108860 10.000000
R27100 n1_M7_94268_115260 n1_M8_94020_115260 10.000000
R27101 n1_M7_94268_121660 n1_M8_94020_121660 10.000000
R27102 n1_M7_94268_128060 n1_M8_94020_128060 10.000000
R27103 n1_M7_94268_134460 n1_M8_94020_134460 10.000000
R27104 n1_M7_94268_140860 n1_M8_94020_140860 10.000000
R27105 n1_M7_94268_147260 n1_M8_94020_147260 10.000000
R27106 n1_M7_98364_60 n1_M8_98340_60 10.000000
R27107 n1_M7_98364_6460 n1_M8_98340_6460 10.000000
R27108 n1_M7_98364_12860 n1_M8_98340_12860 10.000000
R27109 n1_M7_98364_19260 n1_M8_98340_19260 10.000000
R27110 n1_M7_98364_25660 n1_M8_98340_25660 10.000000
R27111 n1_M7_98364_32060 n1_M8_98340_32060 10.000000
R27112 n1_M7_98364_38460 n1_M8_98340_38460 10.000000
R27113 n1_M7_98364_44860 n1_M8_98340_44860 10.000000
R27114 n1_M7_98364_51260 n1_M8_98340_51260 10.000000
R27115 n1_M7_98364_57660 n1_M8_98340_57660 10.000000
R27116 n1_M7_98364_64060 n1_M8_98340_64060 10.000000
R27117 n1_M7_98364_70460 n1_M8_98340_70460 10.000000
R27118 n1_M7_98364_76860 n1_M8_98340_76860 10.000000
R27119 n1_M7_98364_83260 n1_M8_98340_83260 10.000000
R27120 n1_M7_98364_89660 n1_M8_98340_89660 10.000000
R27121 n1_M7_98364_96060 n1_M8_98340_96060 10.000000
R27122 n1_M7_98364_102460 n1_M8_98340_102460 10.000000
R27123 n1_M7_98364_108860 n1_M8_98340_108860 10.000000
R27124 n1_M7_98364_115260 n1_M8_98340_115260 10.000000
R27125 n1_M7_98364_121660 n1_M8_98340_121660 10.000000
R27126 n1_M7_98364_128060 n1_M8_98340_128060 10.000000
R27127 n1_M7_98364_134460 n1_M8_98340_134460 10.000000
R27128 n1_M7_98364_140860 n1_M8_98340_140860 10.000000
R27129 n1_M7_98364_147260 n1_M8_98340_147260 10.000000
R27130 n1_M7_102460_60 n1_M8_102660_60 10.000000
R27131 n1_M7_102460_6460 n1_M8_102660_6460 10.000000
R27132 n1_M7_102460_12860 n1_M8_102660_12860 10.000000
R27133 n1_M7_102460_19260 n1_M8_102660_19260 10.000000
R27134 n1_M7_102460_25660 n1_M8_102660_25660 10.000000
R27135 n1_M7_102460_32060 n1_M8_102660_32060 10.000000
R27136 n1_M7_102460_38460 n1_M8_102660_38460 10.000000
R27137 n1_M7_102460_44860 n1_M8_102660_44860 10.000000
R27138 n1_M7_102460_51260 n1_M8_102660_51260 10.000000
R27139 n1_M7_102460_57660 n1_M8_102660_57660 10.000000
R27140 n1_M7_102460_64060 n1_M8_102660_64060 10.000000
R27141 n1_M7_102460_70460 n1_M8_102660_70460 10.000000
R27142 n1_M7_102460_76860 n1_M8_102660_76860 10.000000
R27143 n1_M7_102460_83260 n1_M8_102660_83260 10.000000
R27144 n1_M7_102460_89660 n1_M8_102660_89660 10.000000
R27145 n1_M7_102460_96060 n1_M8_102660_96060 10.000000
R27146 n1_M7_102460_102460 n1_M8_102660_102460 10.000000
R27147 n1_M7_102460_108860 n1_M8_102660_108860 10.000000
R27148 n1_M7_102460_115260 n1_M8_102660_115260 10.000000
R27149 n1_M7_102460_121660 n1_M8_102660_121660 10.000000
R27150 n1_M7_102460_128060 n1_M8_102660_128060 10.000000
R27151 n1_M7_102460_134460 n1_M8_102660_134460 10.000000
R27152 n1_M7_102460_140860 n1_M8_102660_140860 10.000000
R27153 n1_M7_102460_147260 n1_M8_102660_147260 10.000000
R27154 n1_M7_106556_60 n1_M8_106980_60 10.000000
R27155 n1_M7_106556_6460 n1_M8_106980_6460 10.000000
R27156 n1_M7_106556_12860 n1_M8_106980_12860 10.000000
R27157 n1_M7_106556_19260 n1_M8_106980_19260 10.000000
R27158 n1_M7_106556_25660 n1_M8_106980_25660 10.000000
R27159 n1_M7_106556_32060 n1_M8_106980_32060 10.000000
R27160 n1_M7_106556_38460 n1_M8_106980_38460 10.000000
R27161 n1_M7_106556_44860 n1_M8_106980_44860 10.000000
R27162 n1_M7_106556_51260 n1_M8_106980_51260 10.000000
R27163 n1_M7_106556_57660 n1_M8_106980_57660 10.000000
R27164 n1_M7_106556_64060 n1_M8_106980_64060 10.000000
R27165 n1_M7_106556_70460 n1_M8_106980_70460 10.000000
R27166 n1_M7_106556_76860 n1_M8_106980_76860 10.000000
R27167 n1_M7_106556_83260 n1_M8_106980_83260 10.000000
R27168 n1_M7_106556_89660 n1_M8_106980_89660 10.000000
R27169 n1_M7_106556_96060 n1_M8_106980_96060 10.000000
R27170 n1_M7_106556_102460 n1_M8_106980_102460 10.000000
R27171 n1_M7_106556_108860 n1_M8_106980_108860 10.000000
R27172 n1_M7_106556_115260 n1_M8_106980_115260 10.000000
R27173 n1_M7_106556_121660 n1_M8_106980_121660 10.000000
R27174 n1_M7_106556_128060 n1_M8_106980_128060 10.000000
R27175 n1_M7_106556_134460 n1_M8_106980_134460 10.000000
R27176 n1_M7_106556_140860 n1_M8_106980_140860 10.000000
R27177 n1_M7_106556_147260 n1_M8_106980_147260 10.000000
R27178 n1_M7_110652_60 n1_M8_110220_60 10.000000
R27179 n1_M7_110652_6460 n1_M8_110220_6460 10.000000
R27180 n1_M7_110652_12860 n1_M8_110220_12860 10.000000
R27181 n1_M7_110652_19260 n1_M8_110220_19260 10.000000
R27182 n1_M7_110652_25660 n1_M8_110220_25660 10.000000
R27183 n1_M7_110652_32060 n1_M8_110220_32060 10.000000
R27184 n1_M7_110652_38460 n1_M8_110220_38460 10.000000
R27185 n1_M7_110652_44860 n1_M8_110220_44860 10.000000
R27186 n1_M7_110652_51260 n1_M8_110220_51260 10.000000
R27187 n1_M7_110652_57660 n1_M8_110220_57660 10.000000
R27188 n1_M7_110652_64060 n1_M8_110220_64060 10.000000
R27189 n1_M7_110652_70460 n1_M8_110220_70460 10.000000
R27190 n1_M7_110652_76860 n1_M8_110220_76860 10.000000
R27191 n1_M7_110652_83260 n1_M8_110220_83260 10.000000
R27192 n1_M7_110652_89660 n1_M8_110220_89660 10.000000
R27193 n1_M7_110652_96060 n1_M8_110220_96060 10.000000
R27194 n1_M7_110652_102460 n1_M8_110220_102460 10.000000
R27195 n1_M7_110652_108860 n1_M8_110220_108860 10.000000
R27196 n1_M7_110652_115260 n1_M8_110220_115260 10.000000
R27197 n1_M7_110652_121660 n1_M8_110220_121660 10.000000
R27198 n1_M7_110652_128060 n1_M8_110220_128060 10.000000
R27199 n1_M7_110652_134460 n1_M8_110220_134460 10.000000
R27200 n1_M7_110652_140860 n1_M8_110220_140860 10.000000
R27201 n1_M7_110652_147260 n1_M8_110220_147260 10.000000
R27202 n1_M7_114748_60 n1_M8_114540_60 10.000000
R27203 n1_M7_114748_6460 n1_M8_114540_6460 10.000000
R27204 n1_M7_114748_12860 n1_M8_114540_12860 10.000000
R27205 n1_M7_114748_19260 n1_M8_114540_19260 10.000000
R27206 n1_M7_114748_25660 n1_M8_114540_25660 10.000000
R27207 n1_M7_114748_32060 n1_M8_114540_32060 10.000000
R27208 n1_M7_114748_38460 n1_M8_114540_38460 10.000000
R27209 n1_M7_114748_44860 n1_M8_114540_44860 10.000000
R27210 n1_M7_114748_51260 n1_M8_114540_51260 10.000000
R27211 n1_M7_114748_57660 n1_M8_114540_57660 10.000000
R27212 n1_M7_114748_64060 n1_M8_114540_64060 10.000000
R27213 n1_M7_114748_70460 n1_M8_114540_70460 10.000000
R27214 n1_M7_114748_76860 n1_M8_114540_76860 10.000000
R27215 n1_M7_114748_83260 n1_M8_114540_83260 10.000000
R27216 n1_M7_114748_89660 n1_M8_114540_89660 10.000000
R27217 n1_M7_114748_96060 n1_M8_114540_96060 10.000000
R27218 n1_M7_114748_102460 n1_M8_114540_102460 10.000000
R27219 n1_M7_114748_108860 n1_M8_114540_108860 10.000000
R27220 n1_M7_114748_115260 n1_M8_114540_115260 10.000000
R27221 n1_M7_114748_121660 n1_M8_114540_121660 10.000000
R27222 n1_M7_114748_128060 n1_M8_114540_128060 10.000000
R27223 n1_M7_114748_134460 n1_M8_114540_134460 10.000000
R27224 n1_M7_114748_140860 n1_M8_114540_140860 10.000000
R27225 n1_M7_114748_147260 n1_M8_114540_147260 10.000000
R27226 n1_M7_118844_60 n1_M8_118860_60 10.000000
R27227 n1_M7_118844_6460 n1_M8_118860_6460 10.000000
R27228 n1_M7_118844_12860 n1_M8_118860_12860 10.000000
R27229 n1_M7_118844_19260 n1_M8_118860_19260 10.000000
R27230 n1_M7_118844_25660 n1_M8_118860_25660 10.000000
R27231 n1_M7_118844_32060 n1_M8_118860_32060 10.000000
R27232 n1_M7_118844_38460 n1_M8_118860_38460 10.000000
R27233 n1_M7_118844_44860 n1_M8_118860_44860 10.000000
R27234 n1_M7_118844_51260 n1_M8_118860_51260 10.000000
R27235 n1_M7_118844_57660 n1_M8_118860_57660 10.000000
R27236 n1_M7_118844_64060 n1_M8_118860_64060 10.000000
R27237 n1_M7_118844_70460 n1_M8_118860_70460 10.000000
R27238 n1_M7_118844_76860 n1_M8_118860_76860 10.000000
R27239 n1_M7_118844_83260 n1_M8_118860_83260 10.000000
R27240 n1_M7_118844_89660 n1_M8_118860_89660 10.000000
R27241 n1_M7_118844_96060 n1_M8_118860_96060 10.000000
R27242 n1_M7_118844_102460 n1_M8_118860_102460 10.000000
R27243 n1_M7_118844_108860 n1_M8_118860_108860 10.000000
R27244 n1_M7_118844_115260 n1_M8_118860_115260 10.000000
R27245 n1_M7_118844_121660 n1_M8_118860_121660 10.000000
R27246 n1_M7_118844_128060 n1_M8_118860_128060 10.000000
R27247 n1_M7_118844_134460 n1_M8_118860_134460 10.000000
R27248 n1_M7_118844_140860 n1_M8_118860_140860 10.000000
R27249 n1_M7_118844_147260 n1_M8_118860_147260 10.000000
R27250 n1_M7_122940_60 n1_M8_123180_60 10.000000
R27251 n1_M7_122940_6460 n1_M8_123180_6460 10.000000
R27252 n1_M7_122940_12860 n1_M8_123180_12860 10.000000
R27253 n1_M7_122940_19260 n1_M8_123180_19260 10.000000
R27254 n1_M7_122940_25660 n1_M8_123180_25660 10.000000
R27255 n1_M7_122940_32060 n1_M8_123180_32060 10.000000
R27256 n1_M7_122940_38460 n1_M8_123180_38460 10.000000
R27257 n1_M7_122940_44860 n1_M8_123180_44860 10.000000
R27258 n1_M7_122940_51260 n1_M8_123180_51260 10.000000
R27259 n1_M7_122940_57660 n1_M8_123180_57660 10.000000
R27260 n1_M7_122940_64060 n1_M8_123180_64060 10.000000
R27261 n1_M7_122940_70460 n1_M8_123180_70460 10.000000
R27262 n1_M7_122940_76860 n1_M8_123180_76860 10.000000
R27263 n1_M7_122940_83260 n1_M8_123180_83260 10.000000
R27264 n1_M7_122940_89660 n1_M8_123180_89660 10.000000
R27265 n1_M7_122940_96060 n1_M8_123180_96060 10.000000
R27266 n1_M7_122940_102460 n1_M8_123180_102460 10.000000
R27267 n1_M7_122940_108860 n1_M8_123180_108860 10.000000
R27268 n1_M7_122940_115260 n1_M8_123180_115260 10.000000
R27269 n1_M7_122940_121660 n1_M8_123180_121660 10.000000
R27270 n1_M7_122940_128060 n1_M8_123180_128060 10.000000
R27271 n1_M7_122940_134460 n1_M8_123180_134460 10.000000
R27272 n1_M7_122940_140860 n1_M8_123180_140860 10.000000
R27273 n1_M7_122940_147260 n1_M8_123180_147260 10.000000
R27274 n1_M7_127036_60 n1_M8_127500_60 10.000000
R27275 n1_M7_127036_6460 n1_M8_127500_6460 10.000000
R27276 n1_M7_127036_12860 n1_M8_127500_12860 10.000000
R27277 n1_M7_127036_19260 n1_M8_127500_19260 10.000000
R27278 n1_M7_127036_25660 n1_M8_127500_25660 10.000000
R27279 n1_M7_127036_32060 n1_M8_127500_32060 10.000000
R27280 n1_M7_127036_38460 n1_M8_127500_38460 10.000000
R27281 n1_M7_127036_44860 n1_M8_127500_44860 10.000000
R27282 n1_M7_127036_51260 n1_M8_127500_51260 10.000000
R27283 n1_M7_127036_57660 n1_M8_127500_57660 10.000000
R27284 n1_M7_127036_64060 n1_M8_127500_64060 10.000000
R27285 n1_M7_127036_70460 n1_M8_127500_70460 10.000000
R27286 n1_M7_127036_76860 n1_M8_127500_76860 10.000000
R27287 n1_M7_127036_83260 n1_M8_127500_83260 10.000000
R27288 n1_M7_127036_89660 n1_M8_127500_89660 10.000000
R27289 n1_M7_127036_96060 n1_M8_127500_96060 10.000000
R27290 n1_M7_127036_102460 n1_M8_127500_102460 10.000000
R27291 n1_M7_127036_108860 n1_M8_127500_108860 10.000000
R27292 n1_M7_127036_115260 n1_M8_127500_115260 10.000000
R27293 n1_M7_127036_121660 n1_M8_127500_121660 10.000000
R27294 n1_M7_127036_128060 n1_M8_127500_128060 10.000000
R27295 n1_M7_127036_134460 n1_M8_127500_134460 10.000000
R27296 n1_M7_127036_140860 n1_M8_127500_140860 10.000000
R27297 n1_M7_127036_147260 n1_M8_127500_147260 10.000000
R27298 n1_M7_131132_60 n1_M8_130740_60 10.000000
R27299 n1_M7_131132_6460 n1_M8_130740_6460 10.000000
R27300 n1_M7_131132_12860 n1_M8_130740_12860 10.000000
R27301 n1_M7_131132_19260 n1_M8_130740_19260 10.000000
R27302 n1_M7_131132_25660 n1_M8_130740_25660 10.000000
R27303 n1_M7_131132_32060 n1_M8_130740_32060 10.000000
R27304 n1_M7_131132_38460 n1_M8_130740_38460 10.000000
R27305 n1_M7_131132_44860 n1_M8_130740_44860 10.000000
R27306 n1_M7_131132_51260 n1_M8_130740_51260 10.000000
R27307 n1_M7_131132_57660 n1_M8_130740_57660 10.000000
R27308 n1_M7_131132_64060 n1_M8_130740_64060 10.000000
R27309 n1_M7_131132_70460 n1_M8_130740_70460 10.000000
R27310 n1_M7_131132_76860 n1_M8_130740_76860 10.000000
R27311 n1_M7_131132_83260 n1_M8_130740_83260 10.000000
R27312 n1_M7_131132_89660 n1_M8_130740_89660 10.000000
R27313 n1_M7_131132_96060 n1_M8_130740_96060 10.000000
R27314 n1_M7_131132_102460 n1_M8_130740_102460 10.000000
R27315 n1_M7_131132_108860 n1_M8_130740_108860 10.000000
R27316 n1_M7_131132_115260 n1_M8_130740_115260 10.000000
R27317 n1_M7_131132_121660 n1_M8_130740_121660 10.000000
R27318 n1_M7_131132_128060 n1_M8_130740_128060 10.000000
R27319 n1_M7_131132_134460 n1_M8_130740_134460 10.000000
R27320 n1_M7_131132_140860 n1_M8_130740_140860 10.000000
R27321 n1_M7_131132_147260 n1_M8_130740_147260 10.000000
R27322 n1_M7_135228_60 n1_M8_135060_60 10.000000
R27323 n1_M7_135228_6460 n1_M8_135060_6460 10.000000
R27324 n1_M7_135228_12860 n1_M8_135060_12860 10.000000
R27325 n1_M7_135228_19260 n1_M8_135060_19260 10.000000
R27326 n1_M7_135228_25660 n1_M8_135060_25660 10.000000
R27327 n1_M7_135228_32060 n1_M8_135060_32060 10.000000
R27328 n1_M7_135228_38460 n1_M8_135060_38460 10.000000
R27329 n1_M7_135228_44860 n1_M8_135060_44860 10.000000
R27330 n1_M7_135228_51260 n1_M8_135060_51260 10.000000
R27331 n1_M7_135228_57660 n1_M8_135060_57660 10.000000
R27332 n1_M7_135228_64060 n1_M8_135060_64060 10.000000
R27333 n1_M7_135228_70460 n1_M8_135060_70460 10.000000
R27334 n1_M7_135228_76860 n1_M8_135060_76860 10.000000
R27335 n1_M7_135228_83260 n1_M8_135060_83260 10.000000
R27336 n1_M7_135228_89660 n1_M8_135060_89660 10.000000
R27337 n1_M7_135228_96060 n1_M8_135060_96060 10.000000
R27338 n1_M7_135228_102460 n1_M8_135060_102460 10.000000
R27339 n1_M7_135228_108860 n1_M8_135060_108860 10.000000
R27340 n1_M7_135228_115260 n1_M8_135060_115260 10.000000
R27341 n1_M7_135228_121660 n1_M8_135060_121660 10.000000
R27342 n1_M7_135228_128060 n1_M8_135060_128060 10.000000
R27343 n1_M7_135228_134460 n1_M8_135060_134460 10.000000
R27344 n1_M7_135228_140860 n1_M8_135060_140860 10.000000
R27345 n1_M7_135228_147260 n1_M8_135060_147260 10.000000
R27346 n1_M7_139324_60 n1_M8_139380_60 10.000000
R27347 n1_M7_139324_6460 n1_M8_139380_6460 10.000000
R27348 n1_M7_139324_12860 n1_M8_139380_12860 10.000000
R27349 n1_M7_139324_19260 n1_M8_139380_19260 10.000000
R27350 n1_M7_139324_25660 n1_M8_139380_25660 10.000000
R27351 n1_M7_139324_32060 n1_M8_139380_32060 10.000000
R27352 n1_M7_139324_38460 n1_M8_139380_38460 10.000000
R27353 n1_M7_139324_44860 n1_M8_139380_44860 10.000000
R27354 n1_M7_139324_51260 n1_M8_139380_51260 10.000000
R27355 n1_M7_139324_57660 n1_M8_139380_57660 10.000000
R27356 n1_M7_139324_64060 n1_M8_139380_64060 10.000000
R27357 n1_M7_139324_70460 n1_M8_139380_70460 10.000000
R27358 n1_M7_139324_76860 n1_M8_139380_76860 10.000000
R27359 n1_M7_139324_83260 n1_M8_139380_83260 10.000000
R27360 n1_M7_139324_89660 n1_M8_139380_89660 10.000000
R27361 n1_M7_139324_96060 n1_M8_139380_96060 10.000000
R27362 n1_M7_139324_102460 n1_M8_139380_102460 10.000000
R27363 n1_M7_139324_108860 n1_M8_139380_108860 10.000000
R27364 n1_M7_139324_115260 n1_M8_139380_115260 10.000000
R27365 n1_M7_139324_121660 n1_M8_139380_121660 10.000000
R27366 n1_M7_139324_128060 n1_M8_139380_128060 10.000000
R27367 n1_M7_139324_134460 n1_M8_139380_134460 10.000000
R27368 n1_M7_139324_140860 n1_M8_139380_140860 10.000000
R27369 n1_M7_139324_147260 n1_M8_139380_147260 10.000000
R27370 n1_M7_143420_60 n1_M8_143700_60 10.000000
R27371 n1_M7_143420_6460 n1_M8_143700_6460 10.000000
R27372 n1_M7_143420_12860 n1_M8_143700_12860 10.000000
R27373 n1_M7_143420_19260 n1_M8_143700_19260 10.000000
R27374 n1_M7_143420_25660 n1_M8_143700_25660 10.000000
R27375 n1_M7_143420_32060 n1_M8_143700_32060 10.000000
R27376 n1_M7_143420_38460 n1_M8_143700_38460 10.000000
R27377 n1_M7_143420_44860 n1_M8_143700_44860 10.000000
R27378 n1_M7_143420_51260 n1_M8_143700_51260 10.000000
R27379 n1_M7_143420_57660 n1_M8_143700_57660 10.000000
R27380 n1_M7_143420_64060 n1_M8_143700_64060 10.000000
R27381 n1_M7_143420_70460 n1_M8_143700_70460 10.000000
R27382 n1_M7_143420_76860 n1_M8_143700_76860 10.000000
R27383 n1_M7_143420_83260 n1_M8_143700_83260 10.000000
R27384 n1_M7_143420_89660 n1_M8_143700_89660 10.000000
R27385 n1_M7_143420_96060 n1_M8_143700_96060 10.000000
R27386 n1_M7_143420_102460 n1_M8_143700_102460 10.000000
R27387 n1_M7_143420_108860 n1_M8_143700_108860 10.000000
R27388 n1_M7_143420_115260 n1_M8_143700_115260 10.000000
R27389 n1_M7_143420_121660 n1_M8_143700_121660 10.000000
R27390 n1_M7_143420_128060 n1_M8_143700_128060 10.000000
R27391 n1_M7_143420_134460 n1_M8_143700_134460 10.000000
R27392 n1_M7_143420_140860 n1_M8_143700_140860 10.000000
R27393 n1_M7_143420_147260 n1_M8_143700_147260 10.000000
R27394 n1_M7_147516_60 n1_M8_146940_60 10.000000
R27395 n1_M7_147516_6460 n1_M8_146940_6460 10.000000
R27396 n1_M7_147516_12860 n1_M8_146940_12860 10.000000
R27397 n1_M7_147516_19260 n1_M8_146940_19260 10.000000
R27398 n1_M7_147516_25660 n1_M8_146940_25660 10.000000
R27399 n1_M7_147516_32060 n1_M8_146940_32060 10.000000
R27400 n1_M7_147516_38460 n1_M8_146940_38460 10.000000
R27401 n1_M7_147516_44860 n1_M8_146940_44860 10.000000
R27402 n1_M7_147516_51260 n1_M8_146940_51260 10.000000
R27403 n1_M7_147516_57660 n1_M8_146940_57660 10.000000
R27404 n1_M7_147516_64060 n1_M8_146940_64060 10.000000
R27405 n1_M7_147516_70460 n1_M8_146940_70460 10.000000
R27406 n1_M7_147516_76860 n1_M8_146940_76860 10.000000
R27407 n1_M7_147516_83260 n1_M8_146940_83260 10.000000
R27408 n1_M7_147516_89660 n1_M8_146940_89660 10.000000
R27409 n1_M7_147516_96060 n1_M8_146940_96060 10.000000
R27410 n1_M7_147516_102460 n1_M8_146940_102460 10.000000
R27411 n1_M7_147516_108860 n1_M8_146940_108860 10.000000
R27412 n1_M7_147516_115260 n1_M8_146940_115260 10.000000
R27413 n1_M7_147516_121660 n1_M8_146940_121660 10.000000
R27414 n1_M7_147516_128060 n1_M8_146940_128060 10.000000
R27415 n1_M7_147516_134460 n1_M8_146940_134460 10.000000
R27416 n1_M7_147516_140860 n1_M8_146940_140860 10.000000
R27417 n1_M7_147516_147260 n1_M8_146940_147260 10.000000
V0 n1_M8_89700_89660 0 0.700000
I0 n1_M2_60_60 0 2.680541e-09
I1 n1_M2_60_2220 0 3.890593e-09
I2 n1_M2_60_4380 0 6.216023e-09
I3 n1_M2_60_5460 0 9.425325e-09
I4 n1_M2_60_7620 0 1.313292e-08
I5 n1_M2_60_9780 0 1.685512e-08
I6 n1_M2_60_11940 0 2.010967e-08
I7 n1_M2_60_14100 0 2.251167e-08
I8 n1_M2_60_16260 0 2.385236e-08
I9 n1_M2_60_18420 0 2.415339e-08
I10 n1_M2_60_19500 0 2.365756e-08
I11 n1_M2_60_21660 0 2.273948e-08
I12 n1_M2_60_23820 0 2.178067e-08
I13 n1_M2_60_25980 0 2.107470e-08
I14 n1_M2_60_28140 0 2.077671e-08
I15 n1_M2_60_30300 0 2.088599e-08
I16 n1_M2_60_32460 0 2.126434e-08
I17 n1_M2_60_33540 0 2.170312e-08
I18 n1_M2_60_35700 0 2.201678e-08
I19 n1_M2_60_37860 0 2.210793e-08
I20 n1_M2_60_40020 0 2.197433e-08
I21 n1_M2_60_42180 0 2.167050e-08
I22 n1_M2_60_44340 0 2.126987e-08
I23 n1_M2_60_46500 0 2.084778e-08
I24 n1_M2_60_47580 0 2.048430e-08
I25 n1_M2_60_49740 0 2.026316e-08
I26 n1_M2_60_51900 0 2.024917e-08
I27 n1_M2_60_54060 0 2.044576e-08
I28 n1_M2_60_56220 0 2.076386e-08
I29 n1_M2_60_58380 0 2.104002e-08
I30 n1_M2_60_59460 0 2.112090e-08
I31 n1_M2_60_61620 0 2.096063e-08
I32 n1_M2_60_63780 0 2.065230e-08
I33 n1_M2_60_65940 0 2.036217e-08
I34 n1_M2_60_68100 0 2.023595e-08
I35 n1_M2_60_70260 0 2.036580e-08
I36 n1_M2_60_72420 0 2.081406e-08
I37 n1_M2_60_73500 0 2.162421e-08
I38 n1_M2_60_75660 0 2.276948e-08
I39 n1_M2_60_77820 0 2.409867e-08
I40 n1_M2_60_79980 0 2.535512e-08
I41 n1_M2_60_82140 0 2.628080e-08
I42 n1_M2_60_84300 0 2.672802e-08
I43 n1_M2_60_86460 0 2.668937e-08
I44 n1_M2_60_87540 0 2.624340e-08
I45 n1_M2_60_89700 0 2.547858e-08
I46 n1_M2_60_91860 0 2.446094e-08
I47 n1_M2_60_94020 0 2.324665e-08
I48 n1_M2_60_96180 0 2.190326e-08
I49 n1_M2_60_98340 0 2.051375e-08
I50 n1_M2_60_100500 0 1.917500e-08
I51 n1_M2_60_101580 0 1.800060e-08
I52 n1_M2_60_103740 0 1.711426e-08
I53 n1_M2_60_105900 0 1.661223e-08
I54 n1_M2_60_108060 0 1.651984e-08
I55 n1_M2_60_110220 0 1.677681e-08
I56 n1_M2_60_112380 0 1.726002e-08
I57 n1_M2_60_113460 0 1.781840e-08
I58 n1_M2_60_115620 0 1.830140e-08
I59 n1_M2_60_117780 0 1.858735e-08
I60 n1_M2_60_119940 0 1.861112e-08
I61 n1_M2_60_122100 0 1.838010e-08
I62 n1_M2_60_124260 0 1.796105e-08
I63 n1_M2_60_126420 0 1.743688e-08
I64 n1_M2_60_127500 0 1.685093e-08
I65 n1_M2_60_129660 0 1.615835e-08
I66 n1_M2_60_131820 0 1.521641e-08
I67 n1_M2_60_133980 0 1.384081e-08
I68 n1_M2_60_136140 0 1.192373e-08
I69 n1_M2_60_138300 0 9.548219e-09
I70 n1_M2_60_140460 0 7.007182e-09
I71 n1_M2_60_141540 0 4.700763e-09
I72 n1_M2_60_143700 0 2.985143e-09
I73 n1_M2_60_145860 0 2.081834e-09
I74 n1_M2_2220_60 0 4.174712e-09
I75 n1_M2_2220_2220 0 6.038889e-09
I76 n1_M2_2220_4380 0 9.620736e-09
I77 n1_M2_2220_5460 0 1.456955e-08
I78 n1_M2_2220_7620 0 2.030809e-08
I79 n1_M2_2220_9780 0 2.610984e-08
I80 n1_M2_2220_11940 0 3.123092e-08
I81 n1_M2_2220_14100 0 3.504337e-08
I82 n1_M2_2220_16260 0 3.717174e-08
I83 n1_M2_2220_18420 0 3.761651e-08
I84 n1_M2_2220_19500 0 3.677184e-08
I85 n1_M2_2220_21660 0 3.527930e-08
I86 n1_M2_2220_23820 0 3.378932e-08
I87 n1_M2_2220_25980 0 3.276853e-08
I88 n1_M2_2220_28140 0 3.241059e-08
I89 n1_M2_2220_30300 0 3.263993e-08
I90 n1_M2_2220_32460 0 3.318863e-08
I91 n1_M2_2220_33540 0 3.373447e-08
I92 n1_M2_2220_35700 0 3.404644e-08
I93 n1_M2_2220_37860 0 3.405495e-08
I94 n1_M2_2220_40020 0 3.381964e-08
I95 n1_M2_2220_42180 0 3.343756e-08
I96 n1_M2_2220_44340 0 3.298179e-08
I97 n1_M2_2220_46500 0 3.250336e-08
I98 n1_M2_2220_47580 0 3.207813e-08
I99 n1_M2_2220_49740 0 3.183007e-08
I100 n1_M2_2220_51900 0 3.188472e-08
I101 n1_M2_2220_54060 0 3.226801e-08
I102 n1_M2_2220_56220 0 3.283117e-08
I103 n1_M2_2220_58380 0 3.328290e-08
I104 n1_M2_2220_59460 0 3.335046e-08
I105 n1_M2_2220_61620 0 3.296026e-08
I106 n1_M2_2220_63780 0 3.229302e-08
I107 n1_M2_2220_65940 0 3.166499e-08
I108 n1_M2_2220_68100 0 3.136001e-08
I109 n1_M2_2220_70260 0 3.156654e-08
I110 n1_M2_2220_72420 0 3.241196e-08
I111 n1_M2_2220_73500 0 3.397097e-08
I112 n1_M2_2220_75660 0 3.616410e-08
I113 n1_M2_2220_77820 0 3.865642e-08
I114 n1_M2_2220_79980 0 4.090622e-08
I115 n1_M2_2220_82140 0 4.239275e-08
I116 n1_M2_2220_84300 0 4.286571e-08
I117 n1_M2_2220_86460 0 4.241697e-08
I118 n1_M2_2220_87540 0 4.134548e-08
I119 n1_M2_2220_89700 0 3.994422e-08
I120 n1_M2_2220_91860 0 3.837438e-08
I121 n1_M2_2220_94020 0 3.667119e-08
I122 n1_M2_2220_96180 0 3.482147e-08
I123 n1_M2_2220_98340 0 3.283633e-08
I124 n1_M2_2220_100500 0 3.079897e-08
I125 n1_M2_2220_101580 0 2.888617e-08
I126 n1_M2_2220_103740 0 2.734179e-08
I127 n1_M2_2220_105900 0 2.638368e-08
I128 n1_M2_2220_108060 0 2.610115e-08
I129 n1_M2_2220_110220 0 2.641697e-08
I130 n1_M2_2220_112380 0 2.713217e-08
I131 n1_M2_2220_113460 0 2.800075e-08
I132 n1_M2_2220_115620 0 2.878508e-08
I133 n1_M2_2220_117780 0 2.929095e-08
I134 n1_M2_2220_119940 0 2.939648e-08
I135 n1_M2_2220_122100 0 2.908009e-08
I136 n1_M2_2220_124260 0 2.842455e-08
I137 n1_M2_2220_126420 0 2.757180e-08
I138 n1_M2_2220_127500 0 2.663212e-08
I139 n1_M2_2220_129660 0 2.557787e-08
I140 n1_M2_2220_131820 0 2.419692e-08
I141 n1_M2_2220_133980 0 2.217072e-08
I142 n1_M2_2220_136140 0 1.927528e-08
I143 n1_M2_2220_138300 0 1.559166e-08
I144 n1_M2_2220_140460 0 1.156293e-08
I145 n1_M2_2220_141540 0 7.841294e-09
I146 n1_M2_2220_143700 0 5.036101e-09
I147 n1_M2_2220_145860 0 3.546636e-09
I148 n1_M2_4380_60 0 7.141801e-09
I149 n1_M2_4380_2220 0 1.029173e-08
I150 n1_M2_4380_4380 0 1.634258e-08
I151 n1_M2_4380_5460 0 2.471209e-08
I152 n1_M2_4380_7620 0 3.445404e-08
I153 n1_M2_4380_9780 0 4.437195e-08
I154 n1_M2_4380_11940 0 5.320368e-08
I155 n1_M2_4380_14100 0 5.982388e-08
I156 n1_M2_4380_16260 0 6.350615e-08
I157 n1_M2_4380_18420 0 6.420400e-08
I158 n1_M2_4380_19500 0 6.263270e-08
I159 n1_M2_4380_21660 0 5.999858e-08
I160 n1_M2_4380_23820 0 5.750894e-08
I161 n1_M2_4380_25980 0 5.596416e-08
I162 n1_M2_4380_28140 0 5.559161e-08
I163 n1_M2_4380_30300 0 5.611375e-08
I164 n1_M2_4380_32460 0 5.697239e-08
I165 n1_M2_4380_33540 0 5.763044e-08
I166 n1_M2_4380_35700 0 5.781952e-08
I167 n1_M2_4380_37860 0 5.759401e-08
I168 n1_M2_4380_40020 0 5.718323e-08
I169 n1_M2_4380_42180 0 5.676564e-08
I170 n1_M2_4380_44340 0 5.636177e-08
I171 n1_M2_4380_46500 0 5.590544e-08
I172 n1_M2_4380_47580 0 5.542032e-08
I173 n1_M2_4380_49740 0 5.511387e-08
I174 n1_M2_4380_51900 0 5.526963e-08
I175 n1_M2_4380_54060 0 5.599467e-08
I176 n1_M2_4380_56220 0 5.703087e-08
I177 n1_M2_4380_58380 0 5.781478e-08
I178 n1_M2_4380_59460 0 5.781195e-08
I179 n1_M2_4380_61620 0 5.688397e-08
I180 n1_M2_4380_63780 0 5.539825e-08
I181 n1_M2_4380_65940 0 5.399676e-08
I182 n1_M2_4380_68100 0 5.326856e-08
I183 n1_M2_4380_70260 0 5.361891e-08
I184 n1_M2_4380_72420 0 5.532075e-08
I185 n1_M2_4380_73500 0 5.851290e-08
I186 n1_M2_4380_75660 0 6.298871e-08
I187 n1_M2_4380_77820 0 6.799332e-08
I188 n1_M2_4380_79980 0 7.234278e-08
I189 n1_M2_4380_82140 0 7.493449e-08
I190 n1_M2_4380_84300 0 7.531357e-08
I191 n1_M2_4380_86460 0 7.383954e-08
I192 n1_M2_4380_87540 0 7.135625e-08
I193 n1_M2_4380_89700 0 6.864787e-08
I194 n1_M2_4380_91860 0 6.608538e-08
I195 n1_M2_4380_94020 0 6.361805e-08
I196 n1_M2_4380_96180 0 6.099294e-08
I197 n1_M2_4380_98340 0 5.800112e-08
I198 n1_M2_4380_100500 0 5.465059e-08
I199 n1_M2_4380_101580 0 5.123671e-08
I200 n1_M2_4380_103740 0 4.827163e-08
I201 n1_M2_4380_105900 0 4.626271e-08
I202 n1_M2_4380_108060 0 4.546863e-08
I203 n1_M2_4380_110220 0 4.580122e-08
I204 n1_M2_4380_112380 0 4.691719e-08
I205 n1_M2_4380_113460 0 4.838380e-08
I206 n1_M2_4380_115620 0 4.979271e-08
I207 n1_M2_4380_117780 0 5.079890e-08
I208 n1_M2_4380_119940 0 5.114169e-08
I209 n1_M2_4380_122100 0 5.070439e-08
I210 n1_M2_4380_124260 0 4.957877e-08
I211 n1_M2_4380_126420 0 4.803747e-08
I212 n1_M2_4380_127500 0 4.636708e-08
I213 n1_M2_4380_129660 0 4.461563e-08
I214 n1_M2_4380_131820 0 4.244124e-08
I215 n1_M2_4380_133980 0 3.922604e-08
I216 n1_M2_4380_136140 0 3.446220e-08
I217 n1_M2_4380_138300 0 2.818588e-08
I218 n1_M2_4380_140460 0 2.113260e-08
I219 n1_M2_4380_141540 0 1.448515e-08
I220 n1_M2_4380_143700 0 9.402907e-09
I221 n1_M2_4380_145860 0 6.680932e-09
I222 n1_M2_5460_60 0 1.139191e-08
I223 n1_M2_5460_2220 0 1.635663e-08
I224 n1_M2_5460_4380 0 2.589054e-08
I225 n1_M2_5460_5460 0 3.908815e-08
I226 n1_M2_5460_7620 0 5.449390e-08
I227 n1_M2_5460_9780 0 7.025739e-08
I228 n1_M2_5460_11940 0 8.437469e-08
I229 n1_M2_5460_14100 0 9.498436e-08
I230 n1_M2_5460_16260 0 1.008324e-07
I231 n1_M2_5460_18420 0 1.018117e-07
I232 n1_M2_5460_19500 0 9.914745e-08
I233 n1_M2_5460_21660 0 9.491944e-08
I234 n1_M2_5460_23820 0 9.116230e-08
I235 n1_M2_5460_25980 0 8.911636e-08
I236 n1_M2_5460_28140 0 8.895935e-08
I237 n1_M2_5460_30300 0 9.001514e-08
I238 n1_M2_5460_32460 0 9.125162e-08
I239 n1_M2_5460_33540 0 9.185947e-08
I240 n1_M2_5460_35700 0 9.163995e-08
I241 n1_M2_5460_37860 0 9.097682e-08
I242 n1_M2_5460_40020 0 9.043831e-08
I243 n1_M2_5460_42180 0 9.029772e-08
I244 n1_M2_5460_44340 0 9.036695e-08
I245 n1_M2_5460_46500 0 9.024360e-08
I246 n1_M2_5460_47580 0 8.977528e-08
I247 n1_M2_5460_49740 0 8.930616e-08
I248 n1_M2_5460_51900 0 8.944668e-08
I249 n1_M2_5460_54060 0 9.051953e-08
I250 n1_M2_5460_56220 0 9.214495e-08
I251 n1_M2_5460_58380 0 9.333837e-08
I252 n1_M2_5460_59460 0 9.313736e-08
I253 n1_M2_5460_61620 0 9.128234e-08
I254 n1_M2_5460_63780 0 8.842230e-08
I255 n1_M2_5460_65940 0 8.571197e-08
I256 n1_M2_5460_68100 0 8.423319e-08
I257 n1_M2_5460_70260 0 8.474956e-08
I258 n1_M2_5460_72420 0 8.777217e-08
I259 n1_M2_5460_73500 0 9.353384e-08
I260 n1_M2_5460_75660 0 1.016040e-07
I261 n1_M2_5460_77820 0 1.105294e-07
I262 n1_M2_5460_79980 0 1.180748e-07
I263 n1_M2_5460_82140 0 1.222035e-07
I264 n1_M2_5460_84300 0 1.221738e-07
I265 n1_M2_5460_86460 0 1.188630e-07
I266 n1_M2_5460_87540 0 1.140947e-07
I267 n1_M2_5460_89700 0 1.095114e-07
I268 n1_M2_5460_91860 0 1.058181e-07
I269 n1_M2_5460_94020 0 1.027513e-07
I270 n1_M2_5460_96180 0 9.955688e-08
I271 n1_M2_5460_98340 0 9.555266e-08
I272 n1_M2_5460_100500 0 9.053316e-08
I273 n1_M2_5460_101580 0 8.493989e-08
I274 n1_M2_5460_103740 0 7.972519e-08
I275 n1_M2_5460_105900 0 7.591151e-08
I276 n1_M2_5460_108060 0 7.409227e-08
I277 n1_M2_5460_110220 0 7.421500e-08
I278 n1_M2_5460_112380 0 7.574676e-08
I279 n1_M2_5460_113460 0 7.799740e-08
I280 n1_M2_5460_115620 0 8.032712e-08
I281 n1_M2_5460_117780 0 8.216718e-08
I282 n1_M2_5460_119940 0 8.300377e-08
I283 n1_M2_5460_122100 0 8.249934e-08
I284 n1_M2_5460_124260 0 8.070436e-08
I285 n1_M2_5460_126420 0 7.810492e-08
I286 n1_M2_5460_127500 0 7.533471e-08
I287 n1_M2_5460_129660 0 7.264116e-08
I288 n1_M2_5460_131820 0 6.951255e-08
I289 n1_M2_5460_133980 0 6.482665e-08
I290 n1_M2_5460_136140 0 5.754885e-08
I291 n1_M2_5460_138300 0 4.756094e-08
I292 n1_M2_5460_140460 0 3.600836e-08
I293 n1_M2_5460_141540 0 2.490462e-08
I294 n1_M2_5460_143700 0 1.630390e-08
I295 n1_M2_5460_145860 0 1.166239e-08
I296 n1_M2_7620_60 0 1.643822e-08
I297 n1_M2_7620_2220 0 2.352139e-08
I298 n1_M2_7620_4380 0 3.711719e-08
I299 n1_M2_7620_5460 0 5.594211e-08
I300 n1_M2_7620_7620 0 7.794963e-08
I301 n1_M2_7620_9780 0 1.005240e-07
I302 n1_M2_7620_11940 0 1.207759e-07
I303 n1_M2_7620_14100 0 1.359555e-07
I304 n1_M2_7620_16260 0 1.441891e-07
I305 n1_M2_7620_18420 0 1.453503e-07
I306 n1_M2_7620_19500 0 1.413562e-07
I307 n1_M2_7620_21660 0 1.353927e-07
I308 n1_M2_7620_23820 0 1.304722e-07
I309 n1_M2_7620_25980 0 1.282601e-07
I310 n1_M2_7620_28140 0 1.287189e-07
I311 n1_M2_7620_30300 0 1.305565e-07
I312 n1_M2_7620_32460 0 1.321266e-07
I313 n1_M2_7620_33540 0 1.323811e-07
I314 n1_M2_7620_35700 0 1.314045e-07
I315 n1_M2_7620_37860 0 1.301974e-07
I316 n1_M2_7620_40020 0 1.298552e-07
I317 n1_M2_7620_42180 0 1.306963e-07
I318 n1_M2_7620_44340 0 1.320398e-07
I319 n1_M2_7620_46500 0 1.327943e-07
I320 n1_M2_7620_47580 0 1.324345e-07
I321 n1_M2_7620_49740 0 1.315131e-07
I322 n1_M2_7620_51900 0 1.312201e-07
I323 n1_M2_7620_54060 0 1.323264e-07
I324 n1_M2_7620_56220 0 1.343929e-07
I325 n1_M2_7620_58380 0 1.359066e-07
I326 n1_M2_7620_59460 0 1.353192e-07
I327 n1_M2_7620_61620 0 1.321695e-07
I328 n1_M2_7620_63780 0 1.274336e-07
I329 n1_M2_7620_65940 0 1.229128e-07
I330 n1_M2_7620_68100 0 1.203317e-07
I331 n1_M2_7620_70260 0 1.209324e-07
I332 n1_M2_7620_72420 0 1.255361e-07
I333 n1_M2_7620_73500 0 1.344793e-07
I334 n1_M2_7620_75660 0 1.470158e-07
I335 n1_M2_7620_77820 0 1.607733e-07
I336 n1_M2_7620_79980 0 1.721605e-07
I337 n1_M2_7620_82140 0 1.779609e-07
I338 n1_M2_7620_84300 0 1.771257e-07
I339 n1_M2_7620_86460 0 1.713009e-07
I340 n1_M2_7620_87540 0 1.636824e-07
I341 n1_M2_7620_89700 0 1.570854e-07
I342 n1_M2_7620_91860 0 1.526326e-07
I343 n1_M2_7620_94020 0 1.496935e-07
I344 n1_M2_7620_96180 0 1.467230e-07
I345 n1_M2_7620_98340 0 1.422685e-07
I346 n1_M2_7620_100500 0 1.357129e-07
I347 n1_M2_7620_101580 0 1.276167e-07
I348 n1_M2_7620_103740 0 1.195168e-07
I349 n1_M2_7620_105900 0 1.131838e-07
I350 n1_M2_7620_108060 0 1.097392e-07
I351 n1_M2_7620_110220 0 1.092460e-07
I352 n1_M2_7620_112380 0 1.109735e-07
I353 n1_M2_7620_113460 0 1.139539e-07
I354 n1_M2_7620_115620 0 1.173164e-07
I355 n1_M2_7620_117780 0 1.202410e-07
I356 n1_M2_7620_119940 0 1.218481e-07
I357 n1_M2_7620_122100 0 1.214121e-07
I358 n1_M2_7620_124260 0 1.188427e-07
I359 n1_M2_7620_126420 0 1.149055e-07
I360 n1_M2_7620_127500 0 1.107782e-07
I361 n1_M2_7620_129660 0 1.070763e-07
I362 n1_M2_7620_131820 0 1.031070e-07
I363 n1_M2_7620_133980 0 9.703235e-08
I364 n1_M2_7620_136140 0 8.700965e-08
I365 n1_M2_7620_138300 0 7.260457e-08
I366 n1_M2_7620_140460 0 5.544188e-08
I367 n1_M2_7620_141540 0 3.863416e-08
I368 n1_M2_7620_143700 0 2.546150e-08
I369 n1_M2_7620_145860 0 1.830593e-08
I370 n1_M2_9780_60 0 2.155670e-08
I371 n1_M2_9780_2220 0 3.075370e-08
I372 n1_M2_9780_4380 0 4.839530e-08
I373 n1_M2_9780_5460 0 7.280702e-08
I374 n1_M2_9780_7620 0 1.013290e-07
I375 n1_M2_9780_9780 0 1.305473e-07
I376 n1_M2_9780_11940 0 1.566602e-07
I377 n1_M2_9780_14100 0 1.760446e-07
I378 n1_M2_9780_16260 0 1.862937e-07
I379 n1_M2_9780_18420 0 1.874026e-07
I380 n1_M2_9780_19500 0 1.821078e-07
I381 n1_M2_9780_21660 0 1.747379e-07
I382 n1_M2_9780_23820 0 1.691929e-07
I383 n1_M2_9780_25980 0 1.673809e-07
I384 n1_M2_9780_28140 0 1.688513e-07
I385 n1_M2_9780_30300 0 1.715737e-07
I386 n1_M2_9780_32460 0 1.732989e-07
I387 n1_M2_9780_33540 0 1.728971e-07
I388 n1_M2_9780_35700 0 1.709923e-07
I389 n1_M2_9780_37860 0 1.694511e-07
I390 n1_M2_9780_40020 0 1.700010e-07
I391 n1_M2_9780_42180 0 1.728653e-07
I392 n1_M2_9780_44340 0 1.765145e-07
I393 n1_M2_9780_46500 0 1.787728e-07
I394 n1_M2_9780_47580 0 1.785354e-07
I395 n1_M2_9780_49740 0 1.766512e-07
I396 n1_M2_9780_51900 0 1.751800e-07
I397 n1_M2_9780_54060 0 1.756331e-07
I398 n1_M2_9780_56220 0 1.776621e-07
I399 n1_M2_9780_58380 0 1.792186e-07
I400 n1_M2_9780_59460 0 1.780787e-07
I401 n1_M2_9780_61620 0 1.734864e-07
I402 n1_M2_9780_63780 0 1.666903e-07
I403 n1_M2_9780_65940 0 1.601311e-07
I404 n1_M2_9780_68100 0 1.562027e-07
I405 n1_M2_9780_70260 0 1.566570e-07
I406 n1_M2_9780_72420 0 1.626316e-07
I407 n1_M2_9780_73500 0 1.745399e-07
I408 n1_M2_9780_75660 0 1.912831e-07
I409 n1_M2_9780_77820 0 2.095565e-07
I410 n1_M2_9780_79980 0 2.244381e-07
I411 n1_M2_9780_82140 0 2.315886e-07
I412 n1_M2_9780_84300 0 2.297319e-07
I413 n1_M2_9780_86460 0 2.213750e-07
I414 n1_M2_9780_87540 0 2.111719e-07
I415 n1_M2_9780_89700 0 2.031558e-07
I416 n1_M2_9780_91860 0 1.988469e-07
I417 n1_M2_9780_94020 0 1.971568e-07
I418 n1_M2_9780_96180 0 1.955969e-07
I419 n1_M2_9780_98340 0 1.917506e-07
I420 n1_M2_9780_100500 0 1.844074e-07
I421 n1_M2_9780_101580 0 1.741518e-07
I422 n1_M2_9780_103740 0 1.631405e-07
I423 n1_M2_9780_105900 0 1.540222e-07
I424 n1_M2_9780_108060 0 1.485746e-07
I425 n1_M2_9780_110220 0 1.470372e-07
I426 n1_M2_9780_112380 0 1.485003e-07
I427 n1_M2_9780_113460 0 1.517679e-07
I428 n1_M2_9780_115620 0 1.558408e-07
I429 n1_M2_9780_117780 0 1.597313e-07
I430 n1_M2_9780_119940 0 1.621702e-07
I431 n1_M2_9780_122100 0 1.619146e-07
I432 n1_M2_9780_124260 0 1.586092e-07
I433 n1_M2_9780_126420 0 1.532928e-07
I434 n1_M2_9780_127500 0 1.478044e-07
I435 n1_M2_9780_129660 0 1.432572e-07
I436 n1_M2_9780_131820 0 1.387920e-07
I437 n1_M2_9780_133980 0 1.317179e-07
I438 n1_M2_9780_136140 0 1.191773e-07
I439 n1_M2_9780_138300 0 1.002743e-07
I440 n1_M2_9780_140460 0 7.711740e-08
I441 n1_M2_9780_141540 0 5.406168e-08
I442 n1_M2_9780_143700 0 3.581250e-08
I443 n1_M2_9780_145860 0 2.584589e-08
I444 n1_M2_11940_60 0 2.604014e-08
I445 n1_M2_11940_2220 0 3.707190e-08
I446 n1_M2_11940_4380 0 5.821616e-08
I447 n1_M2_11940_5460 0 8.742746e-08
I448 n1_M2_11940_7620 0 1.214458e-07
I449 n1_M2_11940_9780 0 1.560776e-07
I450 n1_M2_11940_11940 0 1.866880e-07
I451 n1_M2_11940_14100 0 2.089821e-07
I452 n1_M2_11940_16260 0 2.203140e-07
I453 n1_M2_11940_18420 0 2.210442e-07
I454 n1_M2_11940_19500 0 2.147620e-07
I455 n1_M2_11940_21660 0 2.067185e-07
I456 n1_M2_11940_23820 0 2.013388e-07
I457 n1_M2_11940_25980 0 2.004512e-07
I458 n1_M2_11940_28140 0 2.030537e-07
I459 n1_M2_11940_30300 0 2.064615e-07
I460 n1_M2_11940_32460 0 2.080534e-07
I461 n1_M2_11940_33540 0 2.068700e-07
I462 n1_M2_11940_35700 0 2.042450e-07
I463 n1_M2_11940_37860 0 2.029566e-07
I464 n1_M2_11940_40020 0 2.052824e-07
I465 n1_M2_11940_42180 0 2.111559e-07
I466 n1_M2_11940_44340 0 2.179340e-07
I467 n1_M2_11940_46500 0 2.221165e-07
I468 n1_M2_11940_47580 0 2.219111e-07
I469 n1_M2_11940_49740 0 2.185318e-07
I470 n1_M2_11940_51900 0 2.151002e-07
I471 n1_M2_11940_54060 0 2.140910e-07
I472 n1_M2_11940_56220 0 2.154363e-07
I473 n1_M2_11940_58380 0 2.166839e-07
I474 n1_M2_11940_59460 0 2.149816e-07
I475 n1_M2_11940_61620 0 2.092148e-07
I476 n1_M2_11940_63780 0 2.007380e-07
I477 n1_M2_11940_65940 0 1.924280e-07
I478 n1_M2_11940_68100 0 1.871815e-07
I479 n1_M2_11940_70260 0 1.871519e-07
I480 n1_M2_11940_72420 0 1.937093e-07
I481 n1_M2_11940_73500 0 2.072877e-07
I482 n1_M2_11940_75660 0 2.264978e-07
I483 n1_M2_11940_77820 0 2.473915e-07
I484 n1_M2_11940_79980 0 2.642033e-07
I485 n1_M2_11940_82140 0 2.719370e-07
I486 n1_M2_11940_84300 0 2.692683e-07
I487 n1_M2_11940_86460 0 2.593667e-07
I488 n1_M2_11940_87540 0 2.479226e-07
I489 n1_M2_11940_89700 0 2.398088e-07
I490 n1_M2_11940_91860 0 2.367893e-07
I491 n1_M2_11940_94020 0 2.373818e-07
I492 n1_M2_11940_96180 0 2.382976e-07
I493 n1_M2_11940_98340 0 2.362302e-07
I494 n1_M2_11940_100500 0 2.293211e-07
I495 n1_M2_11940_101580 0 2.180397e-07
I496 n1_M2_11940_103740 0 2.050218e-07
I497 n1_M2_11940_105900 0 1.936995e-07
I498 n1_M2_11940_108060 0 1.864519e-07
I499 n1_M2_11940_110220 0 1.836632e-07
I500 n1_M2_11940_112380 0 1.842606e-07
I501 n1_M2_11940_113460 0 1.869359e-07
I502 n1_M2_11940_115620 0 1.907794e-07
I503 n1_M2_11940_117780 0 1.948768e-07
I504 n1_M2_11940_119940 0 1.977243e-07
I505 n1_M2_11940_122100 0 1.975742e-07
I506 n1_M2_11940_124260 0 1.937072e-07
I507 n1_M2_11940_126420 0 1.873063e-07
I508 n1_M2_11940_127500 0 1.807843e-07
I509 n1_M2_11940_129660 0 1.757318e-07
I510 n1_M2_11940_131820 0 1.711472e-07
I511 n1_M2_11940_133980 0 1.635168e-07
I512 n1_M2_11940_136140 0 1.489742e-07
I513 n1_M2_11940_138300 0 1.261306e-07
I514 n1_M2_11940_140460 0 9.751813e-08
I515 n1_M2_11940_141540 0 6.866838e-08
I516 n1_M2_11940_143700 0 4.566296e-08
I517 n1_M2_11940_145860 0 3.304825e-08
I518 n1_M2_14100_60 0 2.945979e-08
I519 n1_M2_14100_2220 0 4.191134e-08
I520 n1_M2_14100_4380 0 6.576300e-08
I521 n1_M2_14100_5460 0 9.864160e-08
I522 n1_M2_14100_7620 0 1.367142e-07
I523 n1_M2_14100_9780 0 1.750379e-07
I524 n1_M2_14100_11940 0 2.082704e-07
I525 n1_M2_14100_14100 0 2.317461e-07
I526 n1_M2_14100_16260 0 2.429849e-07
I527 n1_M2_14100_18420 0 2.429898e-07
I528 n1_M2_14100_19500 0 2.361400e-07
I529 n1_M2_14100_21660 0 2.282091e-07
I530 n1_M2_14100_23820 0 2.236351e-07
I531 n1_M2_14100_25980 0 2.238253e-07
I532 n1_M2_14100_28140 0 2.272228e-07
I533 n1_M2_14100_30300 0 2.307875e-07
I534 n1_M2_14100_32460 0 2.319230e-07
I535 n1_M2_14100_33540 0 2.300837e-07
I536 n1_M2_14100_35700 0 2.272723e-07
I537 n1_M2_14100_37860 0 2.269218e-07
I538 n1_M2_14100_40020 0 2.315764e-07
I539 n1_M2_14100_42180 0 2.407376e-07
I540 n1_M2_14100_44340 0 2.506820e-07
I541 n1_M2_14100_46500 0 2.567088e-07
I542 n1_M2_14100_47580 0 2.564258e-07
I543 n1_M2_14100_49740 0 2.513931e-07
I544 n1_M2_14100_51900 0 2.457126e-07
I545 n1_M2_14100_54060 0 2.427988e-07
I546 n1_M2_14100_56220 0 2.429962e-07
I547 n1_M2_14100_58380 0 2.437119e-07
I548 n1_M2_14100_59460 0 2.417002e-07
I549 n1_M2_14100_61620 0 2.355187e-07
I550 n1_M2_14100_63780 0 2.263985e-07
I551 n1_M2_14100_65940 0 2.172708e-07
I552 n1_M2_14100_68100 0 2.111712e-07
I553 n1_M2_14100_70260 0 2.104016e-07
I554 n1_M2_14100_72420 0 2.164147e-07
I555 n1_M2_14100_73500 0 2.296180e-07
I556 n1_M2_14100_75660 0 2.485049e-07
I557 n1_M2_14100_77820 0 2.690209e-07
I558 n1_M2_14100_79980 0 2.853964e-07
I559 n1_M2_14100_82140 0 2.927440e-07
I560 n1_M2_14100_84300 0 2.899157e-07
I561 n1_M2_14100_86460 0 2.802708e-07
I562 n1_M2_14100_87540 0 2.696677e-07
I563 n1_M2_14100_89700 0 2.630768e-07
I564 n1_M2_14100_91860 0 2.622482e-07
I565 n1_M2_14100_94020 0 2.655322e-07
I566 n1_M2_14100_96180 0 2.693000e-07
I567 n1_M2_14100_98340 0 2.697560e-07
I568 n1_M2_14100_100500 0 2.645544e-07
I569 n1_M2_14100_101580 0 2.539272e-07
I570 n1_M2_14100_103740 0 2.406676e-07
I571 n1_M2_14100_105900 0 2.286136e-07
I572 n1_M2_14100_108060 0 2.204425e-07
I573 n1_M2_14100_110220 0 2.165263e-07
I574 n1_M2_14100_112380 0 2.156393e-07
I575 n1_M2_14100_113460 0 2.165311e-07
I576 n1_M2_14100_115620 0 2.186791e-07
I577 n1_M2_14100_117780 0 2.216036e-07
I578 n1_M2_14100_119940 0 2.238985e-07
I579 n1_M2_14100_122100 0 2.235073e-07
I580 n1_M2_14100_124260 0 2.193179e-07
I581 n1_M2_14100_126420 0 2.124140e-07
I582 n1_M2_14100_127500 0 2.054502e-07
I583 n1_M2_14100_129660 0 2.002703e-07
I584 n1_M2_14100_131820 0 1.957440e-07
I585 n1_M2_14100_133980 0 1.877644e-07
I586 n1_M2_14100_136140 0 1.717403e-07
I587 n1_M2_14100_138300 0 1.459312e-07
I588 n1_M2_14100_140460 0 1.131918e-07
I589 n1_M2_14100_141540 0 7.994047e-08
I590 n1_M2_14100_143700 0 5.330711e-08
I591 n1_M2_14100_145860 0 3.866583e-08
I592 n1_M2_16260_60 0 3.174094e-08
I593 n1_M2_16260_2220 0 4.520901e-08
I594 n1_M2_16260_4380 0 7.101452e-08
I595 n1_M2_16260_5460 0 1.065264e-07
I596 n1_M2_16260_7620 0 1.473876e-07
I597 n1_M2_16260_9780 0 1.879397e-07
I598 n1_M2_16260_11940 0 2.222345e-07
I599 n1_M2_16260_14100 0 2.454815e-07
I600 n1_M2_16260_16260 0 2.556876e-07
I601 n1_M2_16260_18420 0 2.546852e-07
I602 n1_M2_16260_19500 0 2.475223e-07
I603 n1_M2_16260_21660 0 2.401048e-07
I604 n1_M2_16260_23820 0 2.364593e-07
I605 n1_M2_16260_25980 0 2.373686e-07
I606 n1_M2_16260_28140 0 2.408567e-07
I607 n1_M2_16260_30300 0 2.439147e-07
I608 n1_M2_16260_32460 0 2.443528e-07
I609 n1_M2_16260_33540 0 2.421416e-07
I610 n1_M2_16260_35700 0 2.396699e-07
I611 n1_M2_16260_37860 0 2.405268e-07
I612 n1_M2_16260_40020 0 2.471506e-07
I613 n1_M2_16260_42180 0 2.586434e-07
I614 n1_M2_16260_44340 0 2.706390e-07
I615 n1_M2_16260_46500 0 2.777920e-07
I616 n1_M2_16260_47580 0 2.774017e-07
I617 n1_M2_16260_49740 0 2.712162e-07
I618 n1_M2_16260_51900 0 2.638694e-07
I619 n1_M2_16260_54060 0 2.593446e-07
I620 n1_M2_16260_56220 0 2.583852e-07
I621 n1_M2_16260_58380 0 2.585950e-07
I622 n1_M2_16260_59460 0 2.567497e-07
I623 n1_M2_16260_61620 0 2.512539e-07
I624 n1_M2_16260_63780 0 2.430166e-07
I625 n1_M2_16260_65940 0 2.345630e-07
I626 n1_M2_16260_68100 0 2.285817e-07
I627 n1_M2_16260_70260 0 2.271794e-07
I628 n1_M2_16260_72420 0 2.317269e-07
I629 n1_M2_16260_73500 0 2.426070e-07
I630 n1_M2_16260_75660 0 2.584398e-07
I631 n1_M2_16260_77820 0 2.756601e-07
I632 n1_M2_16260_79980 0 2.893683e-07
I633 n1_M2_16260_82140 0 2.955552e-07
I634 n1_M2_16260_84300 0 2.934292e-07
I635 n1_M2_16260_86460 0 2.859743e-07
I636 n1_M2_16260_87540 0 2.782373e-07
I637 n1_M2_16260_89700 0 2.744642e-07
I638 n1_M2_16260_91860 0 2.761141e-07
I639 n1_M2_16260_94020 0 2.816550e-07
I640 n1_M2_16260_96180 0 2.877268e-07
I641 n1_M2_16260_98340 0 2.906702e-07
I642 n1_M2_16260_100500 0 2.880252e-07
I643 n1_M2_16260_101580 0 2.797427e-07
I644 n1_M2_16260_103740 0 2.683354e-07
I645 n1_M2_16260_105900 0 2.574296e-07
I646 n1_M2_16260_108060 0 2.494973e-07
I647 n1_M2_16260_110220 0 2.446864e-07
I648 n1_M2_16260_112380 0 2.416929e-07
I649 n1_M2_16260_113460 0 2.395654e-07
I650 n1_M2_16260_115620 0 2.384686e-07
I651 n1_M2_16260_117780 0 2.386912e-07
I652 n1_M2_16260_119940 0 2.392814e-07
I653 n1_M2_16260_122100 0 2.381617e-07
I654 n1_M2_16260_124260 0 2.338811e-07
I655 n1_M2_16260_126420 0 2.271584e-07
I656 n1_M2_16260_127500 0 2.204293e-07
I657 n1_M2_16260_129660 0 2.154294e-07
I658 n1_M2_16260_131820 0 2.108845e-07
I659 n1_M2_16260_133980 0 2.024392e-07
I660 n1_M2_16260_136140 0 1.852525e-07
I661 n1_M2_16260_138300 0 1.575116e-07
I662 n1_M2_16260_140460 0 1.222967e-07
I663 n1_M2_16260_141540 0 8.649733e-08
I664 n1_M2_16260_143700 0 5.779090e-08
I665 n1_M2_16260_145860 0 4.199432e-08
I666 n1_M2_18420_60 0 3.303505e-08
I667 n1_M2_18420_2220 0 4.718968e-08
I668 n1_M2_18420_4380 0 7.435395e-08
I669 n1_M2_18420_5460 0 1.117408e-07
I670 n1_M2_18420_7620 0 1.545700e-07
I671 n1_M2_18420_9780 0 1.965427e-07
I672 n1_M2_18420_11940 0 2.311706e-07
I673 n1_M2_18420_14100 0 2.536255e-07
I674 n1_M2_18420_16260 0 2.624786e-07
I675 n1_M2_18420_18420 0 2.603796e-07
I676 n1_M2_18420_19500 0 2.528978e-07
I677 n1_M2_18420_21660 0 2.458541e-07
I678 n1_M2_18420_23820 0 2.427137e-07
I679 n1_M2_18420_25980 0 2.436612e-07
I680 n1_M2_18420_28140 0 2.465185e-07
I681 n1_M2_18420_30300 0 2.486013e-07
I682 n1_M2_18420_32460 0 2.483067e-07
I683 n1_M2_18420_33540 0 2.460063e-07
I684 n1_M2_18420_35700 0 2.440373e-07
I685 n1_M2_18420_37860 0 2.456011e-07
I686 n1_M2_18420_40020 0 2.527415e-07
I687 n1_M2_18420_42180 0 2.644103e-07
I688 n1_M2_18420_44340 0 2.763383e-07
I689 n1_M2_18420_46500 0 2.833618e-07
I690 n1_M2_18420_47580 0 2.828703e-07
I691 n1_M2_18420_49740 0 2.765324e-07
I692 n1_M2_18420_51900 0 2.688106e-07
I693 n1_M2_18420_54060 0 2.636233e-07
I694 n1_M2_18420_56220 0 2.619387e-07
I695 n1_M2_18420_58380 0 2.618648e-07
I696 n1_M2_18420_59460 0 2.606835e-07
I697 n1_M2_18420_61620 0 2.569404e-07
I698 n1_M2_18420_63780 0 2.511423e-07
I699 n1_M2_18420_65940 0 2.450297e-07
I700 n1_M2_18420_68100 0 2.404902e-07
I701 n1_M2_18420_70260 0 2.391005e-07
I702 n1_M2_18420_72420 0 2.420086e-07
I703 n1_M2_18420_73500 0 2.496115e-07
I704 n1_M2_18420_75660 0 2.608794e-07
I705 n1_M2_18420_77820 0 2.731714e-07
I706 n1_M2_18420_79980 0 2.830354e-07
I707 n1_M2_18420_82140 0 2.878161e-07
I708 n1_M2_18420_84300 0 2.871439e-07
I709 n1_M2_18420_86460 0 2.832018e-07
I710 n1_M2_18420_87540 0 2.795413e-07
I711 n1_M2_18420_89700 0 2.791183e-07
I712 n1_M2_18420_91860 0 2.829017e-07
I713 n1_M2_18420_94020 0 2.896780e-07
I714 n1_M2_18420_96180 0 2.968574e-07
I715 n1_M2_18420_98340 0 3.015408e-07
I716 n1_M2_18420_100500 0 3.016334e-07
I717 n1_M2_18420_101580 0 2.968585e-07
I718 n1_M2_18420_103740 0 2.889974e-07
I719 n1_M2_18420_105900 0 2.807498e-07
I720 n1_M2_18420_108060 0 2.738263e-07
I721 n1_M2_18420_110220 0 2.680289e-07
I722 n1_M2_18420_112380 0 2.622244e-07
I723 n1_M2_18420_113460 0 2.561021e-07
I724 n1_M2_18420_115620 0 2.507342e-07
I725 n1_M2_18420_117780 0 2.472956e-07
I726 n1_M2_18420_119940 0 2.454390e-07
I727 n1_M2_18420_122100 0 2.432736e-07
I728 n1_M2_18420_124260 0 2.391178e-07
I729 n1_M2_18420_126420 0 2.331759e-07
I730 n1_M2_18420_127500 0 2.272903e-07
I731 n1_M2_18420_129660 0 2.227408e-07
I732 n1_M2_18420_131820 0 2.180462e-07
I733 n1_M2_18420_133980 0 2.088927e-07
I734 n1_M2_18420_136140 0 1.906447e-07
I735 n1_M2_18420_138300 0 1.617296e-07
I736 n1_M2_18420_140460 0 1.254131e-07
I737 n1_M2_18420_141540 0 8.869234e-08
I738 n1_M2_18420_143700 0 5.931618e-08
I739 n1_M2_18420_145860 0 4.316230e-08
I740 n1_M2_19500_60 0 3.355925e-08
I741 n1_M2_19500_2220 0 4.811364e-08
I742 n1_M2_19500_4380 0 7.611814e-08
I743 n1_M2_19500_5460 0 1.147436e-07
I744 n1_M2_19500_7620 0 1.589501e-07
I745 n1_M2_19500_9780 0 2.019656e-07
I746 n1_M2_19500_11940 0 2.368655e-07
I747 n1_M2_19500_14100 0 2.587613e-07
I748 n1_M2_19500_16260 0 2.666326e-07
I749 n1_M2_19500_18420 0 2.637183e-07
I750 n1_M2_19500_19500 0 2.559211e-07
I751 n1_M2_19500_21660 0 2.489232e-07
I752 n1_M2_19500_23820 0 2.457358e-07
I753 n1_M2_19500_25980 0 2.461557e-07
I754 n1_M2_19500_28140 0 2.480210e-07
I755 n1_M2_19500_30300 0 2.490874e-07
I756 n1_M2_19500_32460 0 2.482703e-07
I757 n1_M2_19500_33540 0 2.460558e-07
I758 n1_M2_19500_35700 0 2.442946e-07
I759 n1_M2_19500_37860 0 2.454116e-07
I760 n1_M2_19500_40020 0 2.509682e-07
I761 n1_M2_19500_42180 0 2.601487e-07
I762 n1_M2_19500_44340 0 2.695428e-07
I763 n1_M2_19500_46500 0 2.749502e-07
I764 n1_M2_19500_47580 0 2.742097e-07
I765 n1_M2_19500_49740 0 2.686553e-07
I766 n1_M2_19500_51900 0 2.619121e-07
I767 n1_M2_19500_54060 0 2.571947e-07
I768 n1_M2_19500_56220 0 2.554239e-07
I769 n1_M2_19500_58380 0 2.553552e-07
I770 n1_M2_19500_59460 0 2.551295e-07
I771 n1_M2_19500_61620 0 2.537271e-07
I772 n1_M2_19500_63780 0 2.513311e-07
I773 n1_M2_19500_65940 0 2.487669e-07
I774 n1_M2_19500_68100 0 2.468935e-07
I775 n1_M2_19500_70260 0 2.465496e-07
I776 n1_M2_19500_72420 0 2.485513e-07
I777 n1_M2_19500_73500 0 2.533104e-07
I778 n1_M2_19500_75660 0 2.602358e-07
I779 n1_M2_19500_77820 0 2.677473e-07
I780 n1_M2_19500_79980 0 2.739721e-07
I781 n1_M2_19500_82140 0 2.776753e-07
I782 n1_M2_19500_84300 0 2.788614e-07
I783 n1_M2_19500_86460 0 2.787693e-07
I784 n1_M2_19500_87540 0 2.792878e-07
I785 n1_M2_19500_89700 0 2.819585e-07
I786 n1_M2_19500_91860 0 2.872018e-07
I787 n1_M2_19500_94020 0 2.941628e-07
I788 n1_M2_19500_96180 0 3.012327e-07
I789 n1_M2_19500_98340 0 3.066697e-07
I790 n1_M2_19500_100500 0 3.091518e-07
I791 n1_M2_19500_101580 0 3.082807e-07
I792 n1_M2_19500_103740 0 3.047488e-07
I793 n1_M2_19500_105900 0 2.997123e-07
I794 n1_M2_19500_108060 0 2.937011e-07
I795 n1_M2_19500_110220 0 2.862529e-07
I796 n1_M2_19500_112380 0 2.768620e-07
I797 n1_M2_19500_113460 0 2.662759e-07
I798 n1_M2_19500_115620 0 2.565522e-07
I799 n1_M2_19500_117780 0 2.495586e-07
I800 n1_M2_19500_119940 0 2.453686e-07
I801 n1_M2_19500_122100 0 2.422853e-07
I802 n1_M2_19500_124260 0 2.385204e-07
I803 n1_M2_19500_126420 0 2.338101e-07
I804 n1_M2_19500_127500 0 2.292783e-07
I805 n1_M2_19500_129660 0 2.255397e-07
I806 n1_M2_19500_131820 0 2.207917e-07
I807 n1_M2_19500_133980 0 2.108523e-07
I808 n1_M2_19500_136140 0 1.915411e-07
I809 n1_M2_19500_138300 0 1.617611e-07
I810 n1_M2_19500_140460 0 1.250183e-07
I811 n1_M2_19500_141540 0 8.825242e-08
I812 n1_M2_19500_143700 0 5.900493e-08
I813 n1_M2_19500_145860 0 4.296193e-08
I814 n1_M2_21660_60 0 3.355902e-08
I815 n1_M2_21660_2220 0 4.823381e-08
I816 n1_M2_21660_4380 0 7.653216e-08
I817 n1_M2_21660_5460 0 1.156547e-07
I818 n1_M2_21660_7620 0 1.604798e-07
I819 n1_M2_21660_9780 0 2.040264e-07
I820 n1_M2_21660_11940 0 2.391620e-07
I821 n1_M2_21660_14100 0 2.609768e-07
I822 n1_M2_21660_16260 0 2.686520e-07
I823 n1_M2_21660_18420 0 2.656777e-07
I824 n1_M2_21660_19500 0 2.580241e-07
I825 n1_M2_21660_21660 0 2.511806e-07
I826 n1_M2_21660_23820 0 2.478545e-07
I827 n1_M2_21660_25980 0 2.476847e-07
I828 n1_M2_21660_28140 0 2.486888e-07
I829 n1_M2_21660_30300 0 2.490576e-07
I830 n1_M2_21660_32460 0 2.480365e-07
I831 n1_M2_21660_33540 0 2.459249e-07
I832 n1_M2_21660_35700 0 2.437994e-07
I833 n1_M2_21660_37860 0 2.431697e-07
I834 n1_M2_21660_40020 0 2.452163e-07
I835 n1_M2_21660_42180 0 2.497063e-07
I836 n1_M2_21660_44340 0 2.545858e-07
I837 n1_M2_21660_46500 0 2.570691e-07
I838 n1_M2_21660_47580 0 2.556525e-07
I839 n1_M2_21660_49740 0 2.512255e-07
I840 n1_M2_21660_51900 0 2.462419e-07
I841 n1_M2_21660_54060 0 2.428358e-07
I842 n1_M2_21660_56220 0 2.416075e-07
I843 n1_M2_21660_58380 0 2.418444e-07
I844 n1_M2_21660_59460 0 2.425808e-07
I845 n1_M2_21660_61620 0 2.433767e-07
I846 n1_M2_21660_63780 0 2.442970e-07
I847 n1_M2_21660_65940 0 2.454516e-07
I848 n1_M2_21660_68100 0 2.467961e-07
I849 n1_M2_21660_70260 0 2.484416e-07
I850 n1_M2_21660_72420 0 2.507951e-07
I851 n1_M2_21660_73500 0 2.541758e-07
I852 n1_M2_21660_75660 0 2.583118e-07
I853 n1_M2_21660_77820 0 2.625099e-07
I854 n1_M2_21660_79980 0 2.662309e-07
I855 n1_M2_21660_82140 0 2.694256e-07
I856 n1_M2_21660_84300 0 2.723936e-07
I857 n1_M2_21660_86460 0 2.755797e-07
I858 n1_M2_21660_87540 0 2.795072e-07
I859 n1_M2_21660_89700 0 2.845649e-07
I860 n1_M2_21660_91860 0 2.906989e-07
I861 n1_M2_21660_94020 0 2.973161e-07
I862 n1_M2_21660_96180 0 3.036808e-07
I863 n1_M2_21660_98340 0 3.092489e-07
I864 n1_M2_21660_100500 0 3.136352e-07
I865 n1_M2_21660_101580 0 3.163997e-07
I866 n1_M2_21660_103740 0 3.169730e-07
I867 n1_M2_21660_105900 0 3.146542e-07
I868 n1_M2_21660_108060 0 3.086690e-07
I869 n1_M2_21660_110220 0 2.985752e-07
I870 n1_M2_21660_112380 0 2.850233e-07
I871 n1_M2_21660_113460 0 2.701722e-07
I872 n1_M2_21660_115620 0 2.569704e-07
I873 n1_M2_21660_117780 0 2.475457e-07
I874 n1_M2_21660_119940 0 2.419650e-07
I875 n1_M2_21660_122100 0 2.385625e-07
I876 n1_M2_21660_124260 0 2.355510e-07
I877 n1_M2_21660_126420 0 2.324020e-07
I878 n1_M2_21660_127500 0 2.296399e-07
I879 n1_M2_21660_129660 0 2.271785e-07
I880 n1_M2_21660_131820 0 2.227609e-07
I881 n1_M2_21660_133980 0 2.122291e-07
I882 n1_M2_21660_136140 0 1.918603e-07
I883 n1_M2_21660_138300 0 1.611422e-07
I884 n1_M2_21660_140460 0 1.239450e-07
I885 n1_M2_21660_141540 0 8.720007e-08
I886 n1_M2_21660_143700 0 5.820008e-08
I887 n1_M2_21660_145860 0 4.235739e-08
I888 n1_M2_23820_60 0 3.336338e-08
I889 n1_M2_23820_2220 0 4.792575e-08
I890 n1_M2_23820_4380 0 7.600061e-08
I891 n1_M2_23820_5460 0 1.147935e-07
I892 n1_M2_23820_7620 0 1.592072e-07
I893 n1_M2_23820_9780 0 2.023316e-07
I894 n1_M2_23820_11940 0 2.371804e-07
I895 n1_M2_23820_14100 0 2.590470e-07
I896 n1_M2_23820_16260 0 2.672677e-07
I897 n1_M2_23820_18420 0 2.653045e-07
I898 n1_M2_23820_19500 0 2.588682e-07
I899 n1_M2_23820_21660 0 2.530515e-07
I900 n1_M2_23820_23820 0 2.502272e-07
I901 n1_M2_23820_25980 0 2.499552e-07
I902 n1_M2_23820_28140 0 2.505105e-07
I903 n1_M2_23820_30300 0 2.505076e-07
I904 n1_M2_23820_32460 0 2.494081e-07
I905 n1_M2_23820_33540 0 2.471862e-07
I906 n1_M2_23820_35700 0 2.440927e-07
I907 n1_M2_23820_37860 0 2.408100e-07
I908 n1_M2_23820_40020 0 2.383159e-07
I909 n1_M2_23820_42180 0 2.371231e-07
I910 n1_M2_23820_44340 0 2.366160e-07
I911 n1_M2_23820_46500 0 2.354426e-07
I912 n1_M2_23820_47580 0 2.327825e-07
I913 n1_M2_23820_49740 0 2.291618e-07
I914 n1_M2_23820_51900 0 2.259577e-07
I915 n1_M2_23820_54060 0 2.242211e-07
I916 n1_M2_23820_56220 0 2.240421e-07
I917 n1_M2_23820_58380 0 2.249038e-07
I918 n1_M2_23820_59460 0 2.264281e-07
I919 n1_M2_23820_61620 0 2.286820e-07
I920 n1_M2_23820_63780 0 2.318493e-07
I921 n1_M2_23820_65940 0 2.357662e-07
I922 n1_M2_23820_68100 0 2.399127e-07
I923 n1_M2_23820_70260 0 2.438982e-07
I924 n1_M2_23820_72420 0 2.476969e-07
I925 n1_M2_23820_73500 0 2.513367e-07
I926 n1_M2_23820_75660 0 2.545658e-07
I927 n1_M2_23820_77820 0 2.571874e-07
I928 n1_M2_23820_79980 0 2.595605e-07
I929 n1_M2_23820_82140 0 2.625031e-07
I930 n1_M2_23820_84300 0 2.666166e-07
I931 n1_M2_23820_86460 0 2.719254e-07
I932 n1_M2_23820_87540 0 2.781341e-07
I933 n1_M2_23820_89700 0 2.849113e-07
I934 n1_M2_23820_91860 0 2.918510e-07
I935 n1_M2_23820_94020 0 2.984391e-07
I936 n1_M2_23820_96180 0 3.044654e-07
I937 n1_M2_23820_98340 0 3.102677e-07
I938 n1_M2_23820_100500 0 3.162438e-07
I939 n1_M2_23820_101580 0 3.219222e-07
I940 n1_M2_23820_103740 0 3.255628e-07
I941 n1_M2_23820_105900 0 3.247473e-07
I942 n1_M2_23820_108060 0 3.176416e-07
I943 n1_M2_23820_110220 0 3.041930e-07
I944 n1_M2_23820_112380 0 2.865503e-07
I945 n1_M2_23820_113460 0 2.683698e-07
I946 n1_M2_23820_115620 0 2.532232e-07
I947 n1_M2_23820_117780 0 2.430216e-07
I948 n1_M2_23820_119940 0 2.373983e-07
I949 n1_M2_23820_122100 0 2.345245e-07
I950 n1_M2_23820_124260 0 2.326797e-07
I951 n1_M2_23820_126420 0 2.312880e-07
I952 n1_M2_23820_127500 0 2.304967e-07
I953 n1_M2_23820_129660 0 2.296223e-07
I954 n1_M2_23820_131820 0 2.258997e-07
I955 n1_M2_23820_133980 0 2.150461e-07
I956 n1_M2_23820_136140 0 1.936692e-07
I957 n1_M2_23820_138300 0 1.618261e-07
I958 n1_M2_23820_140460 0 1.238456e-07
I959 n1_M2_23820_141540 0 8.678181e-08
I960 n1_M2_23820_143700 0 5.777459e-08
I961 n1_M2_23820_145860 0 4.200210e-08
I962 n1_M2_25980_60 0 3.338747e-08
I963 n1_M2_25980_2220 0 4.775433e-08
I964 n1_M2_25980_4380 0 7.533637e-08
I965 n1_M2_25980_5460 0 1.132143e-07
I966 n1_M2_25980_7620 0 1.562829e-07
I967 n1_M2_25980_9780 0 1.978743e-07
I968 n1_M2_25980_11940 0 2.315004e-07
I969 n1_M2_25980_14100 0 2.530216e-07
I970 n1_M2_25980_16260 0 2.621064e-07
I971 n1_M2_25980_18420 0 2.620946e-07
I972 n1_M2_25980_19500 0 2.581500e-07
I973 n1_M2_25980_21660 0 2.546397e-07
I974 n1_M2_25980_23820 0 2.533542e-07
I975 n1_M2_25980_25980 0 2.536554e-07
I976 n1_M2_25980_28140 0 2.540585e-07
I977 n1_M2_25980_30300 0 2.536352e-07
I978 n1_M2_25980_32460 0 2.521223e-07
I979 n1_M2_25980_33540 0 2.492824e-07
I980 n1_M2_25980_35700 0 2.447407e-07
I981 n1_M2_25980_37860 0 2.385848e-07
I982 n1_M2_25980_40020 0 2.317165e-07
I983 n1_M2_25980_42180 0 2.252928e-07
I984 n1_M2_25980_44340 0 2.198299e-07
I985 n1_M2_25980_46500 0 2.150830e-07
I986 n1_M2_25980_47580 0 2.108048e-07
I987 n1_M2_25980_49740 0 2.073635e-07
I988 n1_M2_25980_51900 0 2.054460e-07
I989 n1_M2_25980_54060 0 2.053032e-07
I990 n1_M2_25980_56220 0 2.064639e-07
I991 n1_M2_25980_58380 0 2.082263e-07
I992 n1_M2_25980_59460 0 2.103422e-07
I993 n1_M2_25980_61620 0 2.131587e-07
I994 n1_M2_25980_63780 0 2.171349e-07
I995 n1_M2_25980_65940 0 2.222845e-07
I996 n1_M2_25980_68100 0 2.281178e-07
I997 n1_M2_25980_70260 0 2.340697e-07
I998 n1_M2_25980_72420 0 2.397294e-07
I999 n1_M2_25980_73500 0 2.446395e-07
I1000 n1_M2_25980_75660 0 2.482113e-07
I1001 n1_M2_25980_77820 0 2.502912e-07
I1002 n1_M2_25980_79980 0 2.517030e-07
I1003 n1_M2_25980_82140 0 2.539117e-07
I1004 n1_M2_25980_84300 0 2.579854e-07
I1005 n1_M2_25980_86460 0 2.640285e-07
I1006 n1_M2_25980_87540 0 2.715070e-07
I1007 n1_M2_25980_89700 0 2.797541e-07
I1008 n1_M2_25980_91860 0 2.880677e-07
I1009 n1_M2_25980_94020 0 2.957519e-07
I1010 n1_M2_25980_96180 0 3.026269e-07
I1011 n1_M2_25980_98340 0 3.093504e-07
I1012 n1_M2_25980_100500 0 3.167180e-07
I1013 n1_M2_25980_101580 0 3.242257e-07
I1014 n1_M2_25980_103740 0 3.293586e-07
I1015 n1_M2_25980_105900 0 3.285879e-07
I1016 n1_M2_25980_108060 0 3.195636e-07
I1017 n1_M2_25980_110220 0 3.028970e-07
I1018 n1_M2_25980_112380 0 2.821773e-07
I1019 n1_M2_25980_113460 0 2.622511e-07
I1020 n1_M2_25980_115620 0 2.469258e-07
I1021 n1_M2_25980_117780 0 2.375714e-07
I1022 n1_M2_25980_119940 0 2.331813e-07
I1023 n1_M2_25980_122100 0 2.316604e-07
I1024 n1_M2_25980_124260 0 2.313411e-07
I1025 n1_M2_25980_126420 0 2.316789e-07
I1026 n1_M2_25980_127500 0 2.326125e-07
I1027 n1_M2_25980_129660 0 2.330618e-07
I1028 n1_M2_25980_131820 0 2.298963e-07
I1029 n1_M2_25980_133980 0 2.187318e-07
I1030 n1_M2_25980_136140 0 1.964175e-07
I1031 n1_M2_25980_138300 0 1.634652e-07
I1032 n1_M2_25980_140460 0 1.246054e-07
I1033 n1_M2_25980_141540 0 8.704403e-08
I1034 n1_M2_25980_143700 0 5.784566e-08
I1035 n1_M2_25980_145860 0 4.203049e-08
I1036 n1_M2_28140_60 0 3.399894e-08
I1037 n1_M2_28140_2220 0 4.831129e-08
I1038 n1_M2_28140_4380 0 7.557123e-08
I1039 n1_M2_28140_5460 0 1.125513e-07
I1040 n1_M2_28140_7620 0 1.539736e-07
I1041 n1_M2_28140_9780 0 1.933882e-07
I1042 n1_M2_28140_11940 0 2.249859e-07
I1043 n1_M2_28140_14100 0 2.455107e-07
I1044 n1_M2_28140_16260 0 2.552466e-07
I1045 n1_M2_28140_18420 0 2.575083e-07
I1046 n1_M2_28140_19500 0 2.567847e-07
I1047 n1_M2_28140_21660 0 2.564439e-07
I1048 n1_M2_28140_23820 0 2.574061e-07
I1049 n1_M2_28140_25980 0 2.586295e-07
I1050 n1_M2_28140_28140 0 2.587811e-07
I1051 n1_M2_28140_30300 0 2.574227e-07
I1052 n1_M2_28140_32460 0 2.547321e-07
I1053 n1_M2_28140_33540 0 2.505655e-07
I1054 n1_M2_28140_35700 0 2.443047e-07
I1055 n1_M2_28140_37860 0 2.357309e-07
I1056 n1_M2_28140_40020 0 2.256817e-07
I1057 n1_M2_28140_42180 0 2.156249e-07
I1058 n1_M2_28140_44340 0 2.066658e-07
I1059 n1_M2_28140_46500 0 1.991863e-07
I1060 n1_M2_28140_47580 0 1.933440e-07
I1061 n1_M2_28140_49740 0 1.895642e-07
I1062 n1_M2_28140_51900 0 1.882835e-07
I1063 n1_M2_28140_54060 0 1.893320e-07
I1064 n1_M2_28140_56220 0 1.917723e-07
I1065 n1_M2_28140_58380 0 1.945060e-07
I1066 n1_M2_28140_59460 0 1.970686e-07
I1067 n1_M2_28140_61620 0 1.998464e-07
I1068 n1_M2_28140_63780 0 2.035776e-07
I1069 n1_M2_28140_65940 0 2.086858e-07
I1070 n1_M2_28140_68100 0 2.150410e-07
I1071 n1_M2_28140_70260 0 2.221762e-07
I1072 n1_M2_28140_72420 0 2.293995e-07
I1073 n1_M2_28140_73500 0 2.356725e-07
I1074 n1_M2_28140_75660 0 2.398022e-07
I1075 n1_M2_28140_77820 0 2.413157e-07
I1076 n1_M2_28140_79980 0 2.411993e-07
I1077 n1_M2_28140_82140 0 2.415060e-07
I1078 n1_M2_28140_84300 0 2.440508e-07
I1079 n1_M2_28140_86460 0 2.495241e-07
I1080 n1_M2_28140_87540 0 2.576279e-07
I1081 n1_M2_28140_89700 0 2.675910e-07
I1082 n1_M2_28140_91860 0 2.783388e-07
I1083 n1_M2_28140_94020 0 2.886405e-07
I1084 n1_M2_28140_96180 0 2.977803e-07
I1085 n1_M2_28140_98340 0 3.061086e-07
I1086 n1_M2_28140_100500 0 3.144197e-07
I1087 n1_M2_28140_101580 0 3.222986e-07
I1088 n1_M2_28140_103740 0 3.271273e-07
I1089 n1_M2_28140_105900 0 3.251637e-07
I1090 n1_M2_28140_108060 0 3.141625e-07
I1091 n1_M2_28140_110220 0 2.954211e-07
I1092 n1_M2_28140_112380 0 2.734712e-07
I1093 n1_M2_28140_113460 0 2.537194e-07
I1094 n1_M2_28140_115620 0 2.398186e-07
I1095 n1_M2_28140_117780 0 2.325307e-07
I1096 n1_M2_28140_119940 0 2.302943e-07
I1097 n1_M2_28140_122100 0 2.307603e-07
I1098 n1_M2_28140_124260 0 2.321962e-07
I1099 n1_M2_28140_126420 0 2.339604e-07
I1100 n1_M2_28140_127500 0 2.358198e-07
I1101 n1_M2_28140_129660 0 2.365613e-07
I1102 n1_M2_28140_131820 0 2.330724e-07
I1103 n1_M2_28140_133980 0 2.211604e-07
I1104 n1_M2_28140_136140 0 1.979649e-07
I1105 n1_M2_28140_138300 0 1.642724e-07
I1106 n1_M2_28140_140460 0 1.249588e-07
I1107 n1_M2_28140_141540 0 8.721057e-08
I1108 n1_M2_28140_143700 0 5.797999e-08
I1109 n1_M2_28140_145860 0 4.217693e-08
I1110 n1_M2_30300_60 0 3.532381e-08
I1111 n1_M2_30300_2220 0 4.991002e-08
I1112 n1_M2_30300_4380 0 7.743430e-08
I1113 n1_M2_30300_5460 0 1.142052e-07
I1114 n1_M2_30300_7620 0 1.545483e-07
I1115 n1_M2_30300_9780 0 1.920257e-07
I1116 n1_M2_30300_11940 0 2.214285e-07
I1117 n1_M2_30300_14100 0 2.404802e-07
I1118 n1_M2_30300_16260 0 2.502861e-07
I1119 n1_M2_30300_18420 0 2.543252e-07
I1120 n1_M2_30300_19500 0 2.564871e-07
I1121 n1_M2_30300_21660 0 2.591022e-07
I1122 n1_M2_30300_23820 0 2.621239e-07
I1123 n1_M2_30300_25980 0 2.640007e-07
I1124 n1_M2_30300_28140 0 2.634540e-07
I1125 n1_M2_30300_30300 0 2.604947e-07
I1126 n1_M2_30300_32460 0 2.558501e-07
I1127 n1_M2_30300_33540 0 2.497801e-07
I1128 n1_M2_30300_35700 0 2.418316e-07
I1129 n1_M2_30300_37860 0 2.317435e-07
I1130 n1_M2_30300_40020 0 2.202086e-07
I1131 n1_M2_30300_42180 0 2.085783e-07
I1132 n1_M2_30300_44340 0 1.979797e-07
I1133 n1_M2_30300_46500 0 1.889769e-07
I1134 n1_M2_30300_47580 0 1.819801e-07
I1135 n1_M2_30300_49740 0 1.776141e-07
I1136 n1_M2_30300_51900 0 1.763740e-07
I1137 n1_M2_30300_54060 0 1.779828e-07
I1138 n1_M2_30300_56220 0 1.812399e-07
I1139 n1_M2_30300_58380 0 1.847006e-07
I1140 n1_M2_30300_59460 0 1.876012e-07
I1141 n1_M2_30300_61620 0 1.902166e-07
I1142 n1_M2_30300_63780 0 1.934232e-07
I1143 n1_M2_30300_65940 0 1.979912e-07
I1144 n1_M2_30300_68100 0 2.041914e-07
I1145 n1_M2_30300_70260 0 2.117711e-07
I1146 n1_M2_30300_72420 0 2.198720e-07
I1147 n1_M2_30300_73500 0 2.269065e-07
I1148 n1_M2_30300_75660 0 2.309928e-07
I1149 n1_M2_30300_77820 0 2.311782e-07
I1150 n1_M2_30300_79980 0 2.284896e-07
I1151 n1_M2_30300_82140 0 2.256056e-07
I1152 n1_M2_30300_84300 0 2.253318e-07
I1153 n1_M2_30300_86460 0 2.293028e-07
I1154 n1_M2_30300_87540 0 2.377582e-07
I1155 n1_M2_30300_89700 0 2.499164e-07
I1156 n1_M2_30300_91860 0 2.641672e-07
I1157 n1_M2_30300_94020 0 2.783509e-07
I1158 n1_M2_30300_96180 0 2.906786e-07
I1159 n1_M2_30300_98340 0 3.006902e-07
I1160 n1_M2_30300_100500 0 3.089797e-07
I1161 n1_M2_30300_101580 0 3.155475e-07
I1162 n1_M2_30300_103740 0 3.184748e-07
I1163 n1_M2_30300_105900 0 3.146865e-07
I1164 n1_M2_30300_108060 0 3.024669e-07
I1165 n1_M2_30300_110220 0 2.835059e-07
I1166 n1_M2_30300_112380 0 2.625020e-07
I1167 n1_M2_30300_113460 0 2.447019e-07
I1168 n1_M2_30300_115620 0 2.333446e-07
I1169 n1_M2_30300_117780 0 2.287644e-07
I1170 n1_M2_30300_119940 0 2.291380e-07
I1171 n1_M2_30300_122100 0 2.319457e-07
I1172 n1_M2_30300_124260 0 2.352014e-07
I1173 n1_M2_30300_126420 0 2.379008e-07
I1174 n1_M2_30300_127500 0 2.395713e-07
I1175 n1_M2_30300_129660 0 2.391355e-07
I1176 n1_M2_30300_131820 0 2.340008e-07
I1177 n1_M2_30300_133980 0 2.206201e-07
I1178 n1_M2_30300_136140 0 1.965757e-07
I1179 n1_M2_30300_138300 0 1.627346e-07
I1180 n1_M2_30300_140460 0 1.237538e-07
I1181 n1_M2_30300_141540 0 8.649786e-08
I1182 n1_M2_30300_143700 0 5.767409e-08
I1183 n1_M2_30300_145860 0 4.208438e-08
I1184 n1_M2_32460_60 0 3.713325e-08
I1185 n1_M2_32460_2220 0 5.236101e-08
I1186 n1_M2_32460_4380 0 8.088585e-08
I1187 n1_M2_32460_5460 0 1.184919e-07
I1188 n1_M2_32460_7620 0 1.589283e-07
I1189 n1_M2_32460_9780 0 1.954827e-07
I1190 n1_M2_32460_11940 0 2.232569e-07
I1191 n1_M2_32460_14100 0 2.407875e-07
I1192 n1_M2_32460_16260 0 2.500143e-07
I1193 n1_M2_32460_18420 0 2.547377e-07
I1194 n1_M2_32460_19500 0 2.584685e-07
I1195 n1_M2_32460_21660 0 2.627298e-07
I1196 n1_M2_32460_23820 0 2.667105e-07
I1197 n1_M2_32460_25980 0 2.684647e-07
I1198 n1_M2_32460_28140 0 2.667363e-07
I1199 n1_M2_32460_30300 0 2.618505e-07
I1200 n1_M2_32460_32460 0 2.550077e-07
I1201 n1_M2_32460_33540 0 2.469880e-07
I1202 n1_M2_32460_35700 0 2.377563e-07
I1203 n1_M2_32460_37860 0 2.271759e-07
I1204 n1_M2_32460_40020 0 2.157014e-07
I1205 n1_M2_32460_42180 0 2.042337e-07
I1206 n1_M2_32460_44340 0 1.935277e-07
I1207 n1_M2_32460_46500 0 1.840515e-07
I1208 n1_M2_32460_47580 0 1.763725e-07
I1209 n1_M2_32460_49740 0 1.713566e-07
I1210 n1_M2_32460_51900 0 1.696789e-07
I1211 n1_M2_32460_54060 0 1.711327e-07
I1212 n1_M2_32460_56220 0 1.744899e-07
I1213 n1_M2_32460_58380 0 1.782027e-07
I1214 n1_M2_32460_59460 0 1.813480e-07
I1215 n1_M2_32460_61620 0 1.840424e-07
I1216 n1_M2_32460_63780 0 1.870878e-07
I1217 n1_M2_32460_65940 0 1.913401e-07
I1218 n1_M2_32460_68100 0 1.972902e-07
I1219 n1_M2_32460_70260 0 2.048596e-07
I1220 n1_M2_32460_72420 0 2.131001e-07
I1221 n1_M2_32460_73500 0 2.200041e-07
I1222 n1_M2_32460_75660 0 2.231237e-07
I1223 n1_M2_32460_77820 0 2.211087e-07
I1224 n1_M2_32460_79980 0 2.150630e-07
I1225 n1_M2_32460_82140 0 2.083026e-07
I1226 n1_M2_32460_84300 0 2.046522e-07
I1227 n1_M2_32460_86460 0 2.067654e-07
I1228 n1_M2_32460_87540 0 2.155187e-07
I1229 n1_M2_32460_89700 0 2.301555e-07
I1230 n1_M2_32460_91860 0 2.484168e-07
I1231 n1_M2_32460_94020 0 2.669316e-07
I1232 n1_M2_32460_96180 0 2.824820e-07
I1233 n1_M2_32460_98340 0 2.935518e-07
I1234 n1_M2_32460_100500 0 3.005898e-07
I1235 n1_M2_32460_101580 0 3.044515e-07
I1236 n1_M2_32460_103740 0 3.046020e-07
I1237 n1_M2_32460_105900 0 2.992009e-07
I1238 n1_M2_32460_108060 0 2.871291e-07
I1239 n1_M2_32460_110220 0 2.699491e-07
I1240 n1_M2_32460_112380 0 2.517450e-07
I1241 n1_M2_32460_113460 0 2.370525e-07
I1242 n1_M2_32460_115620 0 2.286454e-07
I1243 n1_M2_32460_117780 0 2.267481e-07
I1244 n1_M2_32460_119940 0 2.296224e-07
I1245 n1_M2_32460_122100 0 2.346896e-07
I1246 n1_M2_32460_124260 0 2.395647e-07
I1247 n1_M2_32460_126420 0 2.426588e-07
I1248 n1_M2_32460_127500 0 2.431853e-07
I1249 n1_M2_32460_129660 0 2.403863e-07
I1250 n1_M2_32460_131820 0 2.325618e-07
I1251 n1_M2_32460_133980 0 2.171573e-07
I1252 n1_M2_32460_136140 0 1.923205e-07
I1253 n1_M2_32460_138300 0 1.588524e-07
I1254 n1_M2_32460_140460 0 1.209013e-07
I1255 n1_M2_32460_141540 0 8.475881e-08
I1256 n1_M2_32460_143700 0 5.676313e-08
I1257 n1_M2_32460_145860 0 4.158953e-08
I1258 n1_M2_33540_60 0 3.888354e-08
I1259 n1_M2_33540_2220 0 5.496838e-08
I1260 n1_M2_33540_4380 0 8.499978e-08
I1261 n1_M2_33540_5460 0 1.243053e-07
I1262 n1_M2_33540_7620 0 1.660085e-07
I1263 n1_M2_33540_9780 0 2.028954e-07
I1264 n1_M2_33540_11940 0 2.300230e-07
I1265 n1_M2_33540_14100 0 2.463995e-07
I1266 n1_M2_33540_16260 0 2.546158e-07
I1267 n1_M2_33540_18420 0 2.588359e-07
I1268 n1_M2_33540_19500 0 2.624396e-07
I1269 n1_M2_33540_21660 0 2.665302e-07
I1270 n1_M2_33540_23820 0 2.699558e-07
I1271 n1_M2_33540_25980 0 2.706887e-07
I1272 n1_M2_33540_28140 0 2.675643e-07
I1273 n1_M2_33540_30300 0 2.610469e-07
I1274 n1_M2_33540_32460 0 2.525550e-07
I1275 n1_M2_33540_33540 0 2.432347e-07
I1276 n1_M2_33540_35700 0 2.334573e-07
I1277 n1_M2_33540_37860 0 2.232372e-07
I1278 n1_M2_33540_40020 0 2.127505e-07
I1279 n1_M2_33540_42180 0 2.023370e-07
I1280 n1_M2_33540_44340 0 1.922661e-07
I1281 n1_M2_33540_46500 0 1.828419e-07
I1282 n1_M2_33540_47580 0 1.747528e-07
I1283 n1_M2_33540_49740 0 1.690671e-07
I1284 n1_M2_33540_51900 0 1.666131e-07
I1285 n1_M2_33540_54060 0 1.673093e-07
I1286 n1_M2_33540_56220 0 1.700931e-07
I1287 n1_M2_33540_58380 0 1.735906e-07
I1288 n1_M2_33540_59460 0 1.769273e-07
I1289 n1_M2_33540_61620 0 1.800693e-07
I1290 n1_M2_33540_63780 0 1.835520e-07
I1291 n1_M2_33540_65940 0 1.880348e-07
I1292 n1_M2_33540_68100 0 1.939791e-07
I1293 n1_M2_33540_70260 0 2.013422e-07
I1294 n1_M2_33540_72420 0 2.090976e-07
I1295 n1_M2_33540_73500 0 2.149901e-07
I1296 n1_M2_33540_75660 0 2.162983e-07
I1297 n1_M2_33540_77820 0 2.115670e-07
I1298 n1_M2_33540_79980 0 2.021110e-07
I1299 n1_M2_33540_82140 0 1.917782e-07
I1300 n1_M2_33540_84300 0 1.851430e-07
I1301 n1_M2_33540_86460 0 1.856260e-07
I1302 n1_M2_33540_87540 0 1.946456e-07
I1303 n1_M2_33540_89700 0 2.115136e-07
I1304 n1_M2_33540_91860 0 2.333905e-07
I1305 n1_M2_33540_94020 0 2.557026e-07
I1306 n1_M2_33540_96180 0 2.737802e-07
I1307 n1_M2_33540_98340 0 2.850934e-07
I1308 n1_M2_33540_100500 0 2.901259e-07
I1309 n1_M2_33540_101580 0 2.908947e-07
I1310 n1_M2_33540_103740 0 2.885592e-07
I1311 n1_M2_33540_105900 0 2.826198e-07
I1312 n1_M2_33540_108060 0 2.723042e-07
I1313 n1_M2_33540_110220 0 2.585087e-07
I1314 n1_M2_33540_112380 0 2.441703e-07
I1315 n1_M2_33540_113460 0 2.328783e-07
I1316 n1_M2_33540_115620 0 2.270616e-07
I1317 n1_M2_33540_117780 0 2.271330e-07
I1318 n1_M2_33540_119940 0 2.317013e-07
I1319 n1_M2_33540_122100 0 2.382635e-07
I1320 n1_M2_33540_124260 0 2.440750e-07
I1321 n1_M2_33540_126420 0 2.469781e-07
I1322 n1_M2_33540_127500 0 2.458946e-07
I1323 n1_M2_33540_129660 0 2.404166e-07
I1324 n1_M2_33540_131820 0 2.297620e-07
I1325 n1_M2_33540_133980 0 2.123694e-07
I1326 n1_M2_33540_136140 0 1.869154e-07
I1327 n1_M2_33540_138300 0 1.540655e-07
I1328 n1_M2_33540_140460 0 1.173859e-07
I1329 n1_M2_33540_141540 0 8.255035e-08
I1330 n1_M2_33540_143700 0 5.551216e-08
I1331 n1_M2_33540_145860 0 4.081904e-08
I1332 n1_M2_35700_60 0 3.990043e-08
I1333 n1_M2_35700_2220 0 5.675995e-08
I1334 n1_M2_35700_4380 0 8.826186e-08
I1335 n1_M2_35700_5460 0 1.294657e-07
I1336 n1_M2_35700_7620 0 1.729977e-07
I1337 n1_M2_35700_9780 0 2.110910e-07
I1338 n1_M2_35700_11940 0 2.384952e-07
I1339 n1_M2_35700_14100 0 2.543140e-07
I1340 n1_M2_35700_16260 0 2.614769e-07
I1341 n1_M2_35700_18420 0 2.644142e-07
I1342 n1_M2_35700_19500 0 2.665413e-07
I1343 n1_M2_35700_21660 0 2.689207e-07
I1344 n1_M2_35700_23820 0 2.705184e-07
I1345 n1_M2_35700_25980 0 2.695956e-07
I1346 n1_M2_35700_28140 0 2.652177e-07
I1347 n1_M2_35700_30300 0 2.578580e-07
I1348 n1_M2_35700_32460 0 2.488459e-07
I1349 n1_M2_35700_33540 0 2.393639e-07
I1350 n1_M2_35700_35700 0 2.299496e-07
I1351 n1_M2_35700_37860 0 2.206596e-07
I1352 n1_M2_35700_40020 0 2.114078e-07
I1353 n1_M2_35700_42180 0 2.020780e-07
I1354 n1_M2_35700_44340 0 1.925931e-07
I1355 n1_M2_35700_46500 0 1.831918e-07
I1356 n1_M2_35700_47580 0 1.746920e-07
I1357 n1_M2_35700_49740 0 1.682874e-07
I1358 n1_M2_35700_51900 0 1.648693e-07
I1359 n1_M2_35700_54060 0 1.644692e-07
I1360 n1_M2_35700_56220 0 1.662993e-07
I1361 n1_M2_35700_58380 0 1.693370e-07
I1362 n1_M2_35700_59460 0 1.728905e-07
I1363 n1_M2_35700_61620 0 1.767886e-07
I1364 n1_M2_35700_63780 0 1.811983e-07
I1365 n1_M2_35700_65940 0 1.864142e-07
I1366 n1_M2_35700_68100 0 1.926731e-07
I1367 n1_M2_35700_70260 0 1.997957e-07
I1368 n1_M2_35700_72420 0 2.066219e-07
I1369 n1_M2_35700_73500 0 2.108144e-07
I1370 n1_M2_35700_75660 0 2.097526e-07
I1371 n1_M2_35700_77820 0 2.022767e-07
I1372 n1_M2_35700_79980 0 1.900665e-07
I1373 n1_M2_35700_82140 0 1.772746e-07
I1374 n1_M2_35700_84300 0 1.687305e-07
I1375 n1_M2_35700_86460 0 1.681411e-07
I1376 n1_M2_35700_87540 0 1.772375e-07
I1377 n1_M2_35700_89700 0 1.954740e-07
I1378 n1_M2_35700_91860 0 2.197196e-07
I1379 n1_M2_35700_94020 0 2.445723e-07
I1380 n1_M2_35700_96180 0 2.642686e-07
I1381 n1_M2_35700_98340 0 2.755235e-07
I1382 n1_M2_35700_100500 0 2.789588e-07
I1383 n1_M2_35700_101580 0 2.776960e-07
I1384 n1_M2_35700_103740 0 2.744001e-07
I1385 n1_M2_35700_105900 0 2.696111e-07
I1386 n1_M2_35700_108060 0 2.625309e-07
I1387 n1_M2_35700_110220 0 2.530528e-07
I1388 n1_M2_35700_112380 0 2.428078e-07
I1389 n1_M2_35700_113460 0 2.344981e-07
I1390 n1_M2_35700_115620 0 2.303743e-07
I1391 n1_M2_35700_117780 0 2.311781e-07
I1392 n1_M2_35700_119940 0 2.359667e-07
I1393 n1_M2_35700_122100 0 2.424794e-07
I1394 n1_M2_35700_124260 0 2.479034e-07
I1395 n1_M2_35700_126420 0 2.498369e-07
I1396 n1_M2_35700_127500 0 2.470784e-07
I1397 n1_M2_35700_129660 0 2.394574e-07
I1398 n1_M2_35700_131820 0 2.267715e-07
I1399 n1_M2_35700_133980 0 2.080762e-07
I1400 n1_M2_35700_136140 0 1.823486e-07
I1401 n1_M2_35700_138300 0 1.501050e-07
I1402 n1_M2_35700_140460 0 1.144678e-07
I1403 n1_M2_35700_141540 0 8.066417e-08
I1404 n1_M2_35700_143700 0 5.437512e-08
I1405 n1_M2_35700_145860 0 4.005877e-08
I1406 n1_M2_37860_60 0 3.965463e-08
I1407 n1_M2_37860_2220 0 5.688729e-08
I1408 n1_M2_37860_4380 0 8.920244e-08
I1409 n1_M2_37860_5460 0 1.316539e-07
I1410 n1_M2_37860_7620 0 1.766587e-07
I1411 n1_M2_37860_9780 0 2.160633e-07
I1412 n1_M2_37860_11940 0 2.442376e-07
I1413 n1_M2_37860_14100 0 2.600875e-07
I1414 n1_M2_37860_16260 0 2.665284e-07
I1415 n1_M2_37860_18420 0 2.680459e-07
I1416 n1_M2_37860_19500 0 2.681306e-07
I1417 n1_M2_37860_21660 0 2.680535e-07
I1418 n1_M2_37860_23820 0 2.672268e-07
I1419 n1_M2_37860_25980 0 2.644727e-07
I1420 n1_M2_37860_28140 0 2.592199e-07
I1421 n1_M2_37860_30300 0 2.519120e-07
I1422 n1_M2_37860_32460 0 2.435844e-07
I1423 n1_M2_37860_33540 0 2.351398e-07
I1424 n1_M2_37860_35700 0 2.269643e-07
I1425 n1_M2_37860_37860 0 2.189696e-07
I1426 n1_M2_37860_40020 0 2.108272e-07
I1427 n1_M2_37860_42180 0 2.021625e-07
I1428 n1_M2_37860_44340 0 1.928017e-07
I1429 n1_M2_37860_46500 0 1.830895e-07
I1430 n1_M2_37860_47580 0 1.740077e-07
I1431 n1_M2_37860_49740 0 1.668111e-07
I1432 n1_M2_37860_51900 0 1.623784e-07
I1433 n1_M2_37860_54060 0 1.608300e-07
I1434 n1_M2_37860_56220 0 1.616769e-07
I1435 n1_M2_37860_58380 0 1.642779e-07
I1436 n1_M2_37860_59460 0 1.681366e-07
I1437 n1_M2_37860_61620 0 1.729476e-07
I1438 n1_M2_37860_63780 0 1.785193e-07
I1439 n1_M2_37860_65940 0 1.847650e-07
I1440 n1_M2_37860_68100 0 1.916014e-07
I1441 n1_M2_37860_70260 0 1.985548e-07
I1442 n1_M2_37860_72420 0 2.042439e-07
I1443 n1_M2_37860_73500 0 2.063784e-07
I1444 n1_M2_37860_75660 0 2.027828e-07
I1445 n1_M2_37860_77820 0 1.929502e-07
I1446 n1_M2_37860_79980 0 1.790181e-07
I1447 n1_M2_37860_82140 0 1.651560e-07
I1448 n1_M2_37860_84300 0 1.559102e-07
I1449 n1_M2_37860_86460 0 1.547581e-07
I1450 n1_M2_37860_87540 0 1.634816e-07
I1451 n1_M2_37860_89700 0 1.817743e-07
I1452 n1_M2_37860_91860 0 2.066474e-07
I1453 n1_M2_37860_94020 0 2.325174e-07
I1454 n1_M2_37860_96180 0 2.531545e-07
I1455 n1_M2_37860_98340 0 2.648613e-07
I1456 n1_M2_37860_100500 0 2.683011e-07
I1457 n1_M2_37860_101580 0 2.672383e-07
I1458 n1_M2_37860_103740 0 2.652523e-07
I1459 n1_M2_37860_105900 0 2.634271e-07
I1460 n1_M2_37860_108060 0 2.606692e-07
I1461 n1_M2_37860_110220 0 2.558486e-07
I1462 n1_M2_37860_112380 0 2.494576e-07
I1463 n1_M2_37860_113460 0 2.435103e-07
I1464 n1_M2_37860_115620 0 2.401491e-07
I1465 n1_M2_37860_117780 0 2.403695e-07
I1466 n1_M2_37860_119940 0 2.436262e-07
I1467 n1_M2_37860_122100 0 2.480926e-07
I1468 n1_M2_37860_124260 0 2.513509e-07
I1469 n1_M2_37860_126420 0 2.512786e-07
I1470 n1_M2_37860_127500 0 2.468188e-07
I1471 n1_M2_37860_129660 0 2.378771e-07
I1472 n1_M2_37860_131820 0 2.243329e-07
I1473 n1_M2_37860_133980 0 2.053046e-07
I1474 n1_M2_37860_136140 0 1.797336e-07
I1475 n1_M2_37860_138300 0 1.479739e-07
I1476 n1_M2_37860_140460 0 1.129227e-07
I1477 n1_M2_37860_141540 0 7.963179e-08
I1478 n1_M2_37860_143700 0 5.369492e-08
I1479 n1_M2_37860_145860 0 3.955258e-08
I1480 n1_M2_40020_60 0 3.801934e-08
I1481 n1_M2_40020_2220 0 5.503782e-08
I1482 n1_M2_40020_4380 0 8.711147e-08
I1483 n1_M2_40020_5460 0 1.295453e-07
I1484 n1_M2_40020_7620 0 1.749026e-07
I1485 n1_M2_40020_9780 0 2.149612e-07
I1486 n1_M2_40020_11940 0 2.438253e-07
I1487 n1_M2_40020_14100 0 2.600515e-07
I1488 n1_M2_40020_16260 0 2.662413e-07
I1489 n1_M2_40020_18420 0 2.666902e-07
I1490 n1_M2_40020_19500 0 2.649048e-07
I1491 n1_M2_40020_21660 0 2.624588e-07
I1492 n1_M2_40020_23820 0 2.593389e-07
I1493 n1_M2_40020_25980 0 2.550150e-07
I1494 n1_M2_40020_28140 0 2.493348e-07
I1495 n1_M2_40020_30300 0 2.427490e-07
I1496 n1_M2_40020_32460 0 2.359680e-07
I1497 n1_M2_40020_33540 0 2.294605e-07
I1498 n1_M2_40020_35700 0 2.232230e-07
I1499 n1_M2_40020_37860 0 2.168361e-07
I1500 n1_M2_40020_40020 0 2.097097e-07
I1501 n1_M2_40020_42180 0 2.013582e-07
I1502 n1_M2_40020_44340 0 1.917186e-07
I1503 n1_M2_40020_46500 0 1.813897e-07
I1504 n1_M2_40020_47580 0 1.715632e-07
I1505 n1_M2_40020_49740 0 1.635403e-07
I1506 n1_M2_40020_51900 0 1.581680e-07
I1507 n1_M2_40020_54060 0 1.556418e-07
I1508 n1_M2_40020_56220 0 1.557248e-07
I1509 n1_M2_40020_58380 0 1.580661e-07
I1510 n1_M2_40020_59460 0 1.622883e-07
I1511 n1_M2_40020_61620 0 1.679641e-07
I1512 n1_M2_40020_63780 0 1.746448e-07
I1513 n1_M2_40020_65940 0 1.819557e-07
I1514 n1_M2_40020_68100 0 1.894809e-07
I1515 n1_M2_40020_70260 0 1.963529e-07
I1516 n1_M2_40020_72420 0 2.009154e-07
I1517 n1_M2_40020_73500 0 2.010292e-07
I1518 n1_M2_40020_75660 0 1.951864e-07
I1519 n1_M2_40020_77820 0 1.837069e-07
I1520 n1_M2_40020_79980 0 1.691438e-07
I1521 n1_M2_40020_82140 0 1.554023e-07
I1522 n1_M2_40020_84300 0 1.463391e-07
I1523 n1_M2_40020_86460 0 1.448359e-07
I1524 n1_M2_40020_87540 0 1.525387e-07
I1525 n1_M2_40020_89700 0 1.694794e-07
I1526 n1_M2_40020_91860 0 1.932510e-07
I1527 n1_M2_40020_94020 0 2.187831e-07
I1528 n1_M2_40020_96180 0 2.400504e-07
I1529 n1_M2_40020_98340 0 2.532280e-07
I1530 n1_M2_40020_100500 0 2.587411e-07
I1531 n1_M2_40020_101580 0 2.603086e-07
I1532 n1_M2_40020_103740 0 2.617046e-07
I1533 n1_M2_40020_105900 0 2.641344e-07
I1534 n1_M2_40020_108060 0 2.661927e-07
I1535 n1_M2_40020_110220 0 2.660010e-07
I1536 n1_M2_40020_112380 0 2.632380e-07
I1537 n1_M2_40020_113460 0 2.593774e-07
I1538 n1_M2_40020_115620 0 2.563413e-07
I1539 n1_M2_40020_117780 0 2.551356e-07
I1540 n1_M2_40020_119940 0 2.554894e-07
I1541 n1_M2_40020_122100 0 2.561930e-07
I1542 n1_M2_40020_124260 0 2.556723e-07
I1543 n1_M2_40020_126420 0 2.525636e-07
I1544 n1_M2_40020_127500 0 2.462033e-07
I1545 n1_M2_40020_129660 0 2.364692e-07
I1546 n1_M2_40020_131820 0 2.229396e-07
I1547 n1_M2_40020_133980 0 2.043409e-07
I1548 n1_M2_40020_136140 0 1.792662e-07
I1549 n1_M2_40020_138300 0 1.478496e-07
I1550 n1_M2_40020_140460 0 1.129254e-07
I1551 n1_M2_40020_141540 0 7.961098e-08
I1552 n1_M2_40020_143700 0 5.360160e-08
I1553 n1_M2_40020_145860 0 3.940977e-08
I1554 n1_M2_42180_60 0 3.535804e-08
I1555 n1_M2_42180_2220 0 5.162187e-08
I1556 n1_M2_42180_4380 0 8.243351e-08
I1557 n1_M2_42180_5460 0 1.235173e-07
I1558 n1_M2_42180_7620 0 1.678707e-07
I1559 n1_M2_42180_9780 0 2.075248e-07
I1560 n1_M2_42180_11940 0 2.365205e-07
I1561 n1_M2_42180_14100 0 2.530560e-07
I1562 n1_M2_42180_16260 0 2.592535e-07
I1563 n1_M2_42180_18420 0 2.590490e-07
I1564 n1_M2_42180_19500 0 2.558926e-07
I1565 n1_M2_42180_21660 0 2.516532e-07
I1566 n1_M2_42180_23820 0 2.468515e-07
I1567 n1_M2_42180_25980 0 2.415141e-07
I1568 n1_M2_42180_28140 0 2.358510e-07
I1569 n1_M2_42180_30300 0 2.303665e-07
I1570 n1_M2_42180_32460 0 2.255407e-07
I1571 n1_M2_42180_33540 0 2.214382e-07
I1572 n1_M2_42180_35700 0 2.175887e-07
I1573 n1_M2_42180_37860 0 2.131304e-07
I1574 n1_M2_42180_40020 0 2.071618e-07
I1575 n1_M2_42180_42180 0 1.991257e-07
I1576 n1_M2_42180_44340 0 1.891514e-07
I1577 n1_M2_42180_46500 0 1.781605e-07
I1578 n1_M2_42180_47580 0 1.675981e-07
I1579 n1_M2_42180_49740 0 1.588500e-07
I1580 n1_M2_42180_51900 0 1.527623e-07
I1581 n1_M2_42180_54060 0 1.495891e-07
I1582 n1_M2_42180_56220 0 1.492416e-07
I1583 n1_M2_42180_58380 0 1.515058e-07
I1584 n1_M2_42180_59460 0 1.560301e-07
I1585 n1_M2_42180_61620 0 1.623100e-07
I1586 n1_M2_42180_63780 0 1.697858e-07
I1587 n1_M2_42180_65940 0 1.779185e-07
I1588 n1_M2_42180_68100 0 1.859888e-07
I1589 n1_M2_42180_70260 0 1.927216e-07
I1590 n1_M2_42180_72420 0 1.962306e-07
I1591 n1_M2_42180_73500 0 1.946420e-07
I1592 n1_M2_42180_75660 0 1.871915e-07
I1593 n1_M2_42180_77820 0 1.749663e-07
I1594 n1_M2_42180_79980 0 1.607417e-07
I1595 n1_M2_42180_82140 0 1.479277e-07
I1596 n1_M2_42180_84300 0 1.395003e-07
I1597 n1_M2_42180_86460 0 1.376125e-07
I1598 n1_M2_42180_87540 0 1.437094e-07
I1599 n1_M2_42180_89700 0 1.582390e-07
I1600 n1_M2_42180_91860 0 1.796853e-07
I1601 n1_M2_42180_94020 0 2.040025e-07
I1602 n1_M2_42180_96180 0 2.258522e-07
I1603 n1_M2_42180_98340 0 2.414201e-07
I1604 n1_M2_42180_100500 0 2.505519e-07
I1605 n1_M2_42180_101580 0 2.562830e-07
I1606 n1_M2_42180_103740 0 2.620276e-07
I1607 n1_M2_42180_105900 0 2.689455e-07
I1608 n1_M2_42180_108060 0 2.755727e-07
I1609 n1_M2_42180_110220 0 2.797204e-07
I1610 n1_M2_42180_112380 0 2.805558e-07
I1611 n1_M2_42180_113460 0 2.789969e-07
I1612 n1_M2_42180_115620 0 2.764844e-07
I1613 n1_M2_42180_117780 0 2.737606e-07
I1614 n1_M2_42180_119940 0 2.707418e-07
I1615 n1_M2_42180_122100 0 2.669693e-07
I1616 n1_M2_42180_124260 0 2.619516e-07
I1617 n1_M2_42180_126420 0 2.552933e-07
I1618 n1_M2_42180_127500 0 2.468318e-07
I1619 n1_M2_42180_129660 0 2.364141e-07
I1620 n1_M2_42180_131820 0 2.232061e-07
I1621 n1_M2_42180_133980 0 2.053490e-07
I1622 n1_M2_42180_136140 0 1.808883e-07
I1623 n1_M2_42180_138300 0 1.496394e-07
I1624 n1_M2_42180_140460 0 1.144300e-07
I1625 n1_M2_42180_141540 0 8.060414e-08
I1626 n1_M2_42180_143700 0 5.412074e-08
I1627 n1_M2_42180_145860 0 3.966144e-08
I1628 n1_M2_44340_60 0 3.236501e-08
I1629 n1_M2_44340_2220 0 4.758372e-08
I1630 n1_M2_44340_4380 0 7.654193e-08
I1631 n1_M2_44340_5460 0 1.154128e-07
I1632 n1_M2_44340_7620 0 1.577421e-07
I1633 n1_M2_44340_9780 0 1.959976e-07
I1634 n1_M2_44340_11940 0 2.243314e-07
I1635 n1_M2_44340_14100 0 2.406778e-07
I1636 n1_M2_44340_16260 0 2.466938e-07
I1637 n1_M2_44340_18420 0 2.459427e-07
I1638 n1_M2_44340_19500 0 2.418125e-07
I1639 n1_M2_44340_21660 0 2.364265e-07
I1640 n1_M2_44340_23820 0 2.307087e-07
I1641 n1_M2_44340_25980 0 2.250431e-07
I1642 n1_M2_44340_28140 0 2.198506e-07
I1643 n1_M2_44340_30300 0 2.156798e-07
I1644 n1_M2_44340_32460 0 2.128964e-07
I1645 n1_M2_44340_33540 0 2.112966e-07
I1646 n1_M2_44340_35700 0 2.100168e-07
I1647 n1_M2_44340_37860 0 2.077583e-07
I1648 n1_M2_44340_40020 0 2.032768e-07
I1649 n1_M2_44340_42180 0 1.959002e-07
I1650 n1_M2_44340_44340 0 1.859058e-07
I1651 n1_M2_44340_46500 0 1.745169e-07
I1652 n1_M2_44340_47580 0 1.634588e-07
I1653 n1_M2_44340_49740 0 1.542711e-07
I1654 n1_M2_44340_51900 0 1.478507e-07
I1655 n1_M2_44340_54060 0 1.444728e-07
I1656 n1_M2_44340_56220 0 1.440601e-07
I1657 n1_M2_44340_58380 0 1.463808e-07
I1658 n1_M2_44340_59460 0 1.510537e-07
I1659 n1_M2_44340_61620 0 1.575759e-07
I1660 n1_M2_44340_63780 0 1.654088e-07
I1661 n1_M2_44340_65940 0 1.739318e-07
I1662 n1_M2_44340_68100 0 1.821500e-07
I1663 n1_M2_44340_70260 0 1.884461e-07
I1664 n1_M2_44340_72420 0 1.908553e-07
I1665 n1_M2_44340_73500 0 1.879076e-07
I1666 n1_M2_44340_75660 0 1.795525e-07
I1667 n1_M2_44340_77820 0 1.674217e-07
I1668 n1_M2_44340_79980 0 1.542445e-07
I1669 n1_M2_44340_82140 0 1.427913e-07
I1670 n1_M2_44340_84300 0 1.351655e-07
I1671 n1_M2_44340_86460 0 1.328524e-07
I1672 n1_M2_44340_87540 0 1.371242e-07
I1673 n1_M2_44340_89700 0 1.488683e-07
I1674 n1_M2_44340_91860 0 1.675648e-07
I1675 n1_M2_44340_94020 0 1.903935e-07
I1676 n1_M2_44340_96180 0 2.128831e-07
I1677 n1_M2_44340_98340 0 2.312171e-07
I1678 n1_M2_44340_100500 0 2.443992e-07
I1679 n1_M2_44340_101580 0 2.544057e-07
I1680 n1_M2_44340_103740 0 2.640598e-07
I1681 n1_M2_44340_105900 0 2.745753e-07
I1682 n1_M2_44340_108060 0 2.848186e-07
I1683 n1_M2_44340_110220 0 2.927078e-07
I1684 n1_M2_44340_112380 0 2.970618e-07
I1685 n1_M2_44340_113460 0 2.980956e-07
I1686 n1_M2_44340_115620 0 2.965130e-07
I1687 n1_M2_44340_117780 0 2.926665e-07
I1688 n1_M2_44340_119940 0 2.866984e-07
I1689 n1_M2_44340_122100 0 2.789540e-07
I1690 n1_M2_44340_124260 0 2.699567e-07
I1691 n1_M2_44340_126420 0 2.601278e-07
I1692 n1_M2_44340_127500 0 2.497178e-07
I1693 n1_M2_44340_129660 0 2.386015e-07
I1694 n1_M2_44340_131820 0 2.256590e-07
I1695 n1_M2_44340_133980 0 2.085003e-07
I1696 n1_M2_44340_136140 0 1.845605e-07
I1697 n1_M2_44340_138300 0 1.532431e-07
I1698 n1_M2_44340_140460 0 1.173606e-07
I1699 n1_M2_44340_141540 0 8.257847e-08
I1700 n1_M2_44340_143700 0 5.524924e-08
I1701 n1_M2_44340_145860 0 4.031669e-08
I1702 n1_M2_46500_60 0 2.975477e-08
I1703 n1_M2_46500_2220 0 4.395001e-08
I1704 n1_M2_46500_4380 0 7.102830e-08
I1705 n1_M2_46500_5460 0 1.075089e-07
I1706 n1_M2_46500_7620 0 1.474092e-07
I1707 n1_M2_46500_9780 0 1.836336e-07
I1708 n1_M2_46500_11940 0 2.105384e-07
I1709 n1_M2_46500_14100 0 2.259496e-07
I1710 n1_M2_46500_16260 0 2.312265e-07
I1711 n1_M2_46500_18420 0 2.296949e-07
I1712 n1_M2_46500_19500 0 2.247427e-07
I1713 n1_M2_46500_21660 0 2.187064e-07
I1714 n1_M2_46500_23820 0 2.127595e-07
I1715 n1_M2_46500_25980 0 2.074264e-07
I1716 n1_M2_46500_28140 0 2.031487e-07
I1717 n1_M2_46500_30300 0 2.004442e-07
I1718 n1_M2_46500_32460 0 1.996257e-07
I1719 n1_M2_46500_33540 0 2.003743e-07
I1720 n1_M2_46500_35700 0 2.016035e-07
I1721 n1_M2_46500_37860 0 2.016964e-07
I1722 n1_M2_46500_40020 0 1.990867e-07
I1723 n1_M2_46500_42180 0 1.929044e-07
I1724 n1_M2_46500_44340 0 1.834419e-07
I1725 n1_M2_46500_46500 0 1.721282e-07
I1726 n1_M2_46500_47580 0 1.609698e-07
I1727 n1_M2_46500_49740 0 1.517370e-07
I1728 n1_M2_46500_51900 0 1.454356e-07
I1729 n1_M2_46500_54060 0 1.423226e-07
I1730 n1_M2_46500_56220 0 1.422099e-07
I1731 n1_M2_46500_58380 0 1.447417e-07
I1732 n1_M2_46500_59460 0 1.494999e-07
I1733 n1_M2_46500_61620 0 1.560593e-07
I1734 n1_M2_46500_63780 0 1.639658e-07
I1735 n1_M2_46500_65940 0 1.725178e-07
I1736 n1_M2_46500_68100 0 1.804447e-07
I1737 n1_M2_46500_70260 0 1.858903e-07
I1738 n1_M2_46500_72420 0 1.870075e-07
I1739 n1_M2_46500_73500 0 1.828614e-07
I1740 n1_M2_46500_75660 0 1.740362e-07
I1741 n1_M2_46500_77820 0 1.624613e-07
I1742 n1_M2_46500_79980 0 1.506085e-07
I1743 n1_M2_46500_82140 0 1.405902e-07
I1744 n1_M2_46500_84300 0 1.337780e-07
I1745 n1_M2_46500_86460 0 1.311382e-07
I1746 n1_M2_46500_87540 0 1.338139e-07
I1747 n1_M2_46500_89700 0 1.430746e-07
I1748 n1_M2_46500_91860 0 1.593049e-07
I1749 n1_M2_46500_94020 0 1.808269e-07
I1750 n1_M2_46500_96180 0 2.039612e-07
I1751 n1_M2_46500_98340 0 2.248011e-07
I1752 n1_M2_46500_100500 0 2.414143e-07
I1753 n1_M2_46500_101580 0 2.546619e-07
I1754 n1_M2_46500_103740 0 2.668361e-07
I1755 n1_M2_46500_105900 0 2.794289e-07
I1756 n1_M2_46500_108060 0 2.919526e-07
I1757 n1_M2_46500_110220 0 3.026600e-07
I1758 n1_M2_46500_112380 0 3.100212e-07
I1759 n1_M2_46500_113460 0 3.133997e-07
I1760 n1_M2_46500_115620 0 3.127032e-07
I1761 n1_M2_46500_117780 0 3.080369e-07
I1762 n1_M2_46500_119940 0 2.999484e-07
I1763 n1_M2_46500_122100 0 2.895389e-07
I1764 n1_M2_46500_124260 0 2.780054e-07
I1765 n1_M2_46500_126420 0 2.661598e-07
I1766 n1_M2_46500_127500 0 2.544273e-07
I1767 n1_M2_46500_129660 0 2.427602e-07
I1768 n1_M2_46500_131820 0 2.299705e-07
I1769 n1_M2_46500_133980 0 2.133277e-07
I1770 n1_M2_46500_136140 0 1.897215e-07
I1771 n1_M2_46500_138300 0 1.581188e-07
I1772 n1_M2_46500_140460 0 1.212965e-07
I1773 n1_M2_46500_141540 0 8.527135e-08
I1774 n1_M2_46500_143700 0 5.685547e-08
I1775 n1_M2_46500_145860 0 4.131359e-08
I1776 n1_M2_47580_60 0 2.800609e-08
I1777 n1_M2_47580_2220 0 4.142861e-08
I1778 n1_M2_47580_4380 0 6.702370e-08
I1779 n1_M2_47580_5460 0 1.014719e-07
I1780 n1_M2_47580_7620 0 1.390636e-07
I1781 n1_M2_47580_9780 0 1.730241e-07
I1782 n1_M2_47580_11940 0 1.979530e-07
I1783 n1_M2_47580_14100 0 2.117528e-07
I1784 n1_M2_47580_16260 0 2.157243e-07
I1785 n1_M2_47580_18420 0 2.131345e-07
I1786 n1_M2_47580_19500 0 2.074276e-07
I1787 n1_M2_47580_21660 0 2.010895e-07
I1788 n1_M2_47580_23820 0 1.954065e-07
I1789 n1_M2_47580_25980 0 1.908808e-07
I1790 n1_M2_47580_28140 0 1.878266e-07
I1791 n1_M2_47580_30300 0 1.866396e-07
I1792 n1_M2_47580_32460 0 1.875900e-07
I1793 n1_M2_47580_33540 0 1.903752e-07
I1794 n1_M2_47580_35700 0 1.938932e-07
I1795 n1_M2_47580_37860 0 1.963926e-07
I1796 n1_M2_47580_40020 0 1.960410e-07
I1797 n1_M2_47580_42180 0 1.916689e-07
I1798 n1_M2_47580_44340 0 1.833960e-07
I1799 n1_M2_47580_46500 0 1.727098e-07
I1800 n1_M2_47580_47580 0 1.618714e-07
I1801 n1_M2_47580_49740 0 1.529503e-07
I1802 n1_M2_47580_51900 0 1.471325e-07
I1803 n1_M2_47580_54060 0 1.446598e-07
I1804 n1_M2_47580_56220 0 1.451859e-07
I1805 n1_M2_47580_58380 0 1.482028e-07
I1806 n1_M2_47580_59460 0 1.532743e-07
I1807 n1_M2_47580_61620 0 1.600725e-07
I1808 n1_M2_47580_63780 0 1.681883e-07
I1809 n1_M2_47580_65940 0 1.767581e-07
I1810 n1_M2_47580_68100 0 1.842115e-07
I1811 n1_M2_47580_70260 0 1.885537e-07
I1812 n1_M2_47580_72420 0 1.882117e-07
I1813 n1_M2_47580_73500 0 1.828506e-07
I1814 n1_M2_47580_75660 0 1.735904e-07
I1815 n1_M2_47580_77820 0 1.624956e-07
I1816 n1_M2_47580_79980 0 1.517261e-07
I1817 n1_M2_47580_82140 0 1.428570e-07
I1818 n1_M2_47580_84300 0 1.367311e-07
I1819 n1_M2_47580_86460 0 1.339334e-07
I1820 n1_M2_47580_87540 0 1.354693e-07
I1821 n1_M2_47580_89700 0 1.428477e-07
I1822 n1_M2_47580_91860 0 1.571382e-07
I1823 n1_M2_47580_94020 0 1.775676e-07
I1824 n1_M2_47580_96180 0 2.010707e-07
I1825 n1_M2_47580_98340 0 2.235990e-07
I1826 n1_M2_47580_100500 0 2.423789e-07
I1827 n1_M2_47580_101580 0 2.573435e-07
I1828 n1_M2_47580_103740 0 2.704588e-07
I1829 n1_M2_47580_105900 0 2.836623e-07
I1830 n1_M2_47580_108060 0 2.971957e-07
I1831 n1_M2_47580_110220 0 3.096099e-07
I1832 n1_M2_47580_112380 0 3.189154e-07
I1833 n1_M2_47580_113460 0 3.236071e-07
I1834 n1_M2_47580_115620 0 3.230206e-07
I1835 n1_M2_47580_117780 0 3.173958e-07
I1836 n1_M2_47580_119940 0 3.079156e-07
I1837 n1_M2_47580_122100 0 2.962747e-07
I1838 n1_M2_47580_124260 0 2.838628e-07
I1839 n1_M2_47580_126420 0 2.713805e-07
I1840 n1_M2_47580_127500 0 2.591547e-07
I1841 n1_M2_47580_129660 0 2.472190e-07
I1842 n1_M2_47580_131820 0 2.344979e-07
I1843 n1_M2_47580_133980 0 2.181525e-07
I1844 n1_M2_47580_136140 0 1.947158e-07
I1845 n1_M2_47580_138300 0 1.627997e-07
I1846 n1_M2_47580_140460 0 1.251203e-07
I1847 n1_M2_47580_141540 0 8.796683e-08
I1848 n1_M2_47580_143700 0 5.855027e-08
I1849 n1_M2_47580_145860 0 4.243878e-08
I1850 n1_M2_49740_60 0 2.729779e-08
I1851 n1_M2_49740_2220 0 4.029190e-08
I1852 n1_M2_49740_4380 0 6.497666e-08
I1853 n1_M2_49740_5460 0 9.798617e-08
I1854 n1_M2_49740_7620 0 1.336584e-07
I1855 n1_M2_49740_9780 0 1.654090e-07
I1856 n1_M2_49740_11940 0 1.881270e-07
I1857 n1_M2_49740_14100 0 1.999851e-07
I1858 n1_M2_49740_16260 0 2.024405e-07
I1859 n1_M2_49740_18420 0 1.988094e-07
I1860 n1_M2_49740_19500 0 1.925550e-07
I1861 n1_M2_49740_21660 0 1.861945e-07
I1862 n1_M2_49740_23820 0 1.810164e-07
I1863 n1_M2_49740_25980 0 1.774359e-07
I1864 n1_M2_49740_28140 0 1.755994e-07
I1865 n1_M2_49740_30300 0 1.757490e-07
I1866 n1_M2_49740_32460 0 1.781266e-07
I1867 n1_M2_49740_33540 0 1.825545e-07
I1868 n1_M2_49740_35700 0 1.881060e-07
I1869 n1_M2_49740_37860 0 1.930700e-07
I1870 n1_M2_49740_40020 0 1.953920e-07
I1871 n1_M2_49740_42180 0 1.934832e-07
I1872 n1_M2_49740_44340 0 1.870878e-07
I1873 n1_M2_49740_46500 0 1.775908e-07
I1874 n1_M2_49740_47580 0 1.674610e-07
I1875 n1_M2_49740_49740 0 1.591163e-07
I1876 n1_M2_49740_51900 0 1.540034e-07
I1877 n1_M2_49740_54060 0 1.524159e-07
I1878 n1_M2_49740_56220 0 1.539022e-07
I1879 n1_M2_49740_58380 0 1.578463e-07
I1880 n1_M2_49740_59460 0 1.638049e-07
I1881 n1_M2_49740_61620 0 1.714852e-07
I1882 n1_M2_49740_63780 0 1.803922e-07
I1883 n1_M2_49740_65940 0 1.893807e-07
I1884 n1_M2_49740_68100 0 1.965631e-07
I1885 n1_M2_49740_70260 0 1.998859e-07
I1886 n1_M2_49740_72420 0 1.981190e-07
I1887 n1_M2_49740_73500 0 1.914891e-07
I1888 n1_M2_49740_75660 0 1.815456e-07
I1889 n1_M2_49740_77820 0 1.704454e-07
I1890 n1_M2_49740_79980 0 1.601501e-07
I1891 n1_M2_49740_82140 0 1.519189e-07
I1892 n1_M2_49740_84300 0 1.462590e-07
I1893 n1_M2_49740_86460 0 1.434337e-07
I1894 n1_M2_49740_87540 0 1.442174e-07
I1895 n1_M2_49740_89700 0 1.501511e-07
I1896 n1_M2_49740_91860 0 1.627269e-07
I1897 n1_M2_49740_94020 0 1.818291e-07
I1898 n1_M2_49740_96180 0 2.048736e-07
I1899 n1_M2_49740_98340 0 2.277345e-07
I1900 n1_M2_49740_100500 0 2.470470e-07
I1901 n1_M2_49740_101580 0 2.621269e-07
I1902 n1_M2_49740_103740 0 2.748225e-07
I1903 n1_M2_49740_105900 0 2.875298e-07
I1904 n1_M2_49740_108060 0 3.010567e-07
I1905 n1_M2_49740_110220 0 3.140298e-07
I1906 n1_M2_49740_112380 0 3.238986e-07
I1907 n1_M2_49740_113460 0 3.284584e-07
I1908 n1_M2_49740_115620 0 3.268875e-07
I1909 n1_M2_49740_117780 0 3.199742e-07
I1910 n1_M2_49740_119940 0 3.096452e-07
I1911 n1_M2_49740_122100 0 2.979122e-07
I1912 n1_M2_49740_124260 0 2.859020e-07
I1913 n1_M2_49740_126420 0 2.738369e-07
I1914 n1_M2_49740_127500 0 2.617660e-07
I1915 n1_M2_49740_129660 0 2.497740e-07
I1916 n1_M2_49740_131820 0 2.369922e-07
I1917 n1_M2_49740_133980 0 2.206992e-07
I1918 n1_M2_49740_136140 0 1.973548e-07
I1919 n1_M2_49740_138300 0 1.653888e-07
I1920 n1_M2_49740_140460 0 1.274067e-07
I1921 n1_M2_49740_141540 0 8.975693e-08
I1922 n1_M2_49740_143700 0 5.983876e-08
I1923 n1_M2_49740_145860 0 4.341803e-08
I1924 n1_M2_51900_60 0 2.760109e-08
I1925 n1_M2_51900_2220 0 4.051170e-08
I1926 n1_M2_51900_4380 0 6.486697e-08
I1927 n1_M2_51900_5460 0 9.706428e-08
I1928 n1_M2_51900_7620 0 1.312958e-07
I1929 n1_M2_51900_9780 0 1.610774e-07
I1930 n1_M2_51900_11940 0 1.816613e-07
I1931 n1_M2_51900_14100 0 1.916685e-07
I1932 n1_M2_51900_16260 0 1.928536e-07
I1933 n1_M2_51900_18420 0 1.885740e-07
I1934 n1_M2_51900_19500 0 1.821654e-07
I1935 n1_M2_51900_21660 0 1.760040e-07
I1936 n1_M2_51900_23820 0 1.712967e-07
I1937 n1_M2_51900_25980 0 1.684018e-07
I1938 n1_M2_51900_28140 0 1.673792e-07
I1939 n1_M2_51900_30300 0 1.683871e-07
I1940 n1_M2_51900_32460 0 1.716993e-07
I1941 n1_M2_51900_33540 0 1.773549e-07
I1942 n1_M2_51900_35700 0 1.847315e-07
I1943 n1_M2_51900_37860 0 1.922600e-07
I1944 n1_M2_51900_40020 0 1.976618e-07
I1945 n1_M2_51900_42180 0 1.988170e-07
I1946 n1_M2_51900_44340 0 1.949395e-07
I1947 n1_M2_51900_46500 0 1.871966e-07
I1948 n1_M2_51900_47580 0 1.782221e-07
I1949 n1_M2_51900_49740 0 1.707985e-07
I1950 n1_M2_51900_51900 0 1.666885e-07
I1951 n1_M2_51900_54060 0 1.663180e-07
I1952 n1_M2_51900_56220 0 1.692190e-07
I1953 n1_M2_51900_58380 0 1.747243e-07
I1954 n1_M2_51900_59460 0 1.823609e-07
I1955 n1_M2_51900_61620 0 1.917609e-07
I1956 n1_M2_51900_63780 0 2.022030e-07
I1957 n1_M2_51900_65940 0 2.121832e-07
I1958 n1_M2_51900_68100 0 2.195213e-07
I1959 n1_M2_51900_70260 0 2.221587e-07
I1960 n1_M2_51900_72420 0 2.191752e-07
I1961 n1_M2_51900_73500 0 2.112332e-07
I1962 n1_M2_51900_75660 0 2.002247e-07
I1963 n1_M2_51900_77820 0 1.884826e-07
I1964 n1_M2_51900_79980 0 1.780120e-07
I1965 n1_M2_51900_82140 0 1.700041e-07
I1966 n1_M2_51900_84300 0 1.647398e-07
I1967 n1_M2_51900_86460 0 1.620893e-07
I1968 n1_M2_51900_87540 0 1.623964e-07
I1969 n1_M2_51900_89700 0 1.669795e-07
I1970 n1_M2_51900_91860 0 1.775038e-07
I1971 n1_M2_51900_94020 0 1.943387e-07
I1972 n1_M2_51900_96180 0 2.153682e-07
I1973 n1_M2_51900_98340 0 2.365891e-07
I1974 n1_M2_51900_100500 0 2.544073e-07
I1975 n1_M2_51900_101580 0 2.678740e-07
I1976 n1_M2_51900_103740 0 2.788714e-07
I1977 n1_M2_51900_105900 0 2.901239e-07
I1978 n1_M2_51900_108060 0 3.027064e-07
I1979 n1_M2_51900_110220 0 3.150877e-07
I1980 n1_M2_51900_112380 0 3.241945e-07
I1981 n1_M2_51900_113460 0 3.274454e-07
I1982 n1_M2_51900_115620 0 3.242542e-07
I1983 n1_M2_51900_117780 0 3.161351e-07
I1984 n1_M2_51900_119940 0 3.055952e-07
I1985 n1_M2_51900_122100 0 2.946036e-07
I1986 n1_M2_51900_124260 0 2.837360e-07
I1987 n1_M2_51900_126420 0 2.726315e-07
I1988 n1_M2_51900_127500 0 2.610487e-07
I1989 n1_M2_51900_129660 0 2.490938e-07
I1990 n1_M2_51900_131820 0 2.361151e-07
I1991 n1_M2_51900_133980 0 2.196798e-07
I1992 n1_M2_51900_136140 0 1.964680e-07
I1993 n1_M2_51900_138300 0 1.649246e-07
I1994 n1_M2_51900_140460 0 1.274721e-07
I1995 n1_M2_51900_141540 0 9.023762e-08
I1996 n1_M2_51900_143700 0 6.052980e-08
I1997 n1_M2_51900_145860 0 4.417074e-08
I1998 n1_M2_54060_60 0 2.879771e-08
I1999 n1_M2_54060_2220 0 4.193951e-08
I2000 n1_M2_54060_4380 0 6.650285e-08
I2001 n1_M2_54060_5460 0 9.849138e-08
I2002 n1_M2_54060_7620 0 1.317989e-07
I2003 n1_M2_54060_9780 0 1.599824e-07
I2004 n1_M2_54060_11940 0 1.787303e-07
I2005 n1_M2_54060_14100 0 1.872484e-07
I2006 n1_M2_54060_16260 0 1.876608e-07
I2007 n1_M2_54060_18420 0 1.832914e-07
I2008 n1_M2_54060_19500 0 1.771611e-07
I2009 n1_M2_54060_21660 0 1.713247e-07
I2010 n1_M2_54060_23820 0 1.668446e-07
I2011 n1_M2_54060_25980 0 1.640957e-07
I2012 n1_M2_54060_28140 0 1.631987e-07
I2013 n1_M2_54060_30300 0 1.643695e-07
I2014 n1_M2_54060_32460 0 1.680167e-07
I2015 n1_M2_54060_33540 0 1.744699e-07
I2016 n1_M2_54060_35700 0 1.834590e-07
I2017 n1_M2_54060_37860 0 1.935650e-07
I2018 n1_M2_54060_40020 0 2.022466e-07
I2019 n1_M2_54060_42180 0 2.067964e-07
I2020 n1_M2_54060_44340 0 2.058670e-07
I2021 n1_M2_54060_46500 0 2.004076e-07
I2022 n1_M2_54060_47580 0 1.932224e-07
I2023 n1_M2_54060_49740 0 1.874502e-07
I2024 n1_M2_54060_51900 0 1.851558e-07
I2025 n1_M2_54060_54060 0 1.868890e-07
I2026 n1_M2_54060_56220 0 1.921520e-07
I2027 n1_M2_54060_58380 0 2.001789e-07
I2028 n1_M2_54060_59460 0 2.103820e-07
I2029 n1_M2_54060_61620 0 2.222336e-07
I2030 n1_M2_54060_63780 0 2.347560e-07
I2031 n1_M2_54060_65940 0 2.461356e-07
I2032 n1_M2_54060_68100 0 2.539778e-07
I2033 n1_M2_54060_70260 0 2.562177e-07
I2034 n1_M2_54060_72420 0 2.521124e-07
I2035 n1_M2_54060_73500 0 2.426000e-07
I2036 n1_M2_54060_75660 0 2.299181e-07
I2037 n1_M2_54060_77820 0 2.168191e-07
I2038 n1_M2_54060_79980 0 2.057021e-07
I2039 n1_M2_54060_82140 0 1.979144e-07
I2040 n1_M2_54060_84300 0 1.934781e-07
I2041 n1_M2_54060_86460 0 1.916188e-07
I2042 n1_M2_54060_87540 0 1.919073e-07
I2043 n1_M2_54060_89700 0 1.951178e-07
I2044 n1_M2_54060_91860 0 2.028559e-07
I2045 n1_M2_54060_94020 0 2.158926e-07
I2046 n1_M2_54060_96180 0 2.326927e-07
I2047 n1_M2_54060_98340 0 2.496990e-07
I2048 n1_M2_54060_100500 0 2.635347e-07
I2049 n1_M2_54060_101580 0 2.733613e-07
I2050 n1_M2_54060_103740 0 2.811967e-07
I2051 n1_M2_54060_105900 0 2.898883e-07
I2052 n1_M2_54060_108060 0 3.004677e-07
I2053 n1_M2_54060_110220 0 3.111356e-07
I2054 n1_M2_54060_112380 0 3.185208e-07
I2055 n1_M2_54060_113460 0 3.200453e-07
I2056 n1_M2_54060_115620 0 3.155430e-07
I2057 n1_M2_54060_117780 0 3.070506e-07
I2058 n1_M2_54060_119940 0 2.972077e-07
I2059 n1_M2_54060_122100 0 2.875875e-07
I2060 n1_M2_54060_124260 0 2.781710e-07
I2061 n1_M2_54060_126420 0 2.681948e-07
I2062 n1_M2_54060_127500 0 2.572784e-07
I2063 n1_M2_54060_129660 0 2.455359e-07
I2064 n1_M2_54060_131820 0 2.324551e-07
I2065 n1_M2_54060_133980 0 2.159303e-07
I2066 n1_M2_54060_136140 0 1.930324e-07
I2067 n1_M2_54060_138300 0 1.623594e-07
I2068 n1_M2_54060_140460 0 1.261050e-07
I2069 n1_M2_54060_141540 0 8.997621e-08
I2070 n1_M2_54060_143700 0 6.099834e-08
I2071 n1_M2_54060_145860 0 4.496409e-08
I2072 n1_M2_56220_60 0 3.073304e-08
I2073 n1_M2_56220_2220 0 4.438178e-08
I2074 n1_M2_56220_4380 0 6.963546e-08
I2075 n1_M2_56220_5460 0 1.019843e-07
I2076 n1_M2_56220_7620 0 1.349019e-07
I2077 n1_M2_56220_9780 0 1.619260e-07
I2078 n1_M2_56220_11940 0 1.792092e-07
I2079 n1_M2_56220_14100 0 1.866152e-07
I2080 n1_M2_56220_16260 0 1.866725e-07
I2081 n1_M2_56220_18420 0 1.826188e-07
I2082 n1_M2_56220_19500 0 1.770378e-07
I2083 n1_M2_56220_21660 0 1.715439e-07
I2084 n1_M2_56220_23820 0 1.670078e-07
I2085 n1_M2_56220_25980 0 1.638690e-07
I2086 n1_M2_56220_28140 0 1.624234e-07
I2087 n1_M2_56220_30300 0 1.630737e-07
I2088 n1_M2_56220_32460 0 1.664613e-07
I2089 n1_M2_56220_33540 0 1.732449e-07
I2090 n1_M2_56220_35700 0 1.834810e-07
I2091 n1_M2_56220_37860 0 1.958378e-07
I2092 n1_M2_56220_40020 0 2.074756e-07
I2093 n1_M2_56220_42180 0 2.151520e-07
I2094 n1_M2_56220_44340 0 2.171011e-07
I2095 n1_M2_56220_46500 0 2.142222e-07
I2096 n1_M2_56220_47580 0 2.095981e-07
I2097 n1_M2_56220_49740 0 2.067346e-07
I2098 n1_M2_56220_51900 0 2.079143e-07
I2099 n1_M2_56220_54060 0 2.136394e-07
I2100 n1_M2_56220_56220 0 2.231347e-07
I2101 n1_M2_56220_58380 0 2.352632e-07
I2102 n1_M2_56220_59460 0 2.491291e-07
I2103 n1_M2_56220_61620 0 2.640246e-07
I2104 n1_M2_56220_63780 0 2.788684e-07
I2105 n1_M2_56220_65940 0 2.917497e-07
I2106 n1_M2_56220_68100 0 3.001690e-07
I2107 n1_M2_56220_70260 0 3.019646e-07
I2108 n1_M2_56220_72420 0 2.963467e-07
I2109 n1_M2_56220_73500 0 2.843940e-07
I2110 n1_M2_56220_75660 0 2.688501e-07
I2111 n1_M2_56220_77820 0 2.533321e-07
I2112 n1_M2_56220_79980 0 2.411125e-07
I2113 n1_M2_56220_82140 0 2.339138e-07
I2114 n1_M2_56220_84300 0 2.313473e-07
I2115 n1_M2_56220_86460 0 2.315658e-07
I2116 n1_M2_56220_87540 0 2.328531e-07
I2117 n1_M2_56220_89700 0 2.349998e-07
I2118 n1_M2_56220_91860 0 2.392821e-07
I2119 n1_M2_56220_94020 0 2.468341e-07
I2120 n1_M2_56220_96180 0 2.569158e-07
I2121 n1_M2_56220_98340 0 2.668510e-07
I2122 n1_M2_56220_100500 0 2.740060e-07
I2123 n1_M2_56220_101580 0 2.780481e-07
I2124 n1_M2_56220_103740 0 2.812054e-07
I2125 n1_M2_56220_105900 0 2.862161e-07
I2126 n1_M2_56220_108060 0 2.938020e-07
I2127 n1_M2_56220_110220 0 3.019053e-07
I2128 n1_M2_56220_112380 0 3.071790e-07
I2129 n1_M2_56220_113460 0 3.073611e-07
I2130 n1_M2_56220_115620 0 3.026281e-07
I2131 n1_M2_56220_117780 0 2.950382e-07
I2132 n1_M2_56220_119940 0 2.867946e-07
I2133 n1_M2_56220_122100 0 2.788493e-07
I2134 n1_M2_56220_124260 0 2.708029e-07
I2135 n1_M2_56220_126420 0 2.618882e-07
I2136 n1_M2_56220_127500 0 2.518469e-07
I2137 n1_M2_56220_129660 0 2.407878e-07
I2138 n1_M2_56220_131820 0 2.281541e-07
I2139 n1_M2_56220_133980 0 2.119975e-07
I2140 n1_M2_56220_136140 0 1.897226e-07
I2141 n1_M2_56220_138300 0 1.601129e-07
I2142 n1_M2_56220_140460 0 1.251746e-07
I2143 n1_M2_56220_141540 0 9.020914e-08
I2144 n1_M2_56220_143700 0 6.197004e-08
I2145 n1_M2_56220_145860 0 4.624990e-08
I2146 n1_M2_58380_60 0 3.320142e-08
I2147 n1_M2_58380_2220 0 4.756906e-08
I2148 n1_M2_58380_4380 0 7.389628e-08
I2149 n1_M2_58380_5460 0 1.070860e-07
I2150 n1_M2_58380_7620 0 1.401041e-07
I2151 n1_M2_58380_9780 0 1.663966e-07
I2152 n1_M2_58380_11940 0 1.825391e-07
I2153 n1_M2_58380_14100 0 1.890445e-07
I2154 n1_M2_58380_16260 0 1.888592e-07
I2155 n1_M2_58380_18420 0 1.851598e-07
I2156 n1_M2_58380_19500 0 1.801147e-07
I2157 n1_M2_58380_21660 0 1.748996e-07
I2158 n1_M2_58380_23820 0 1.701739e-07
I2159 n1_M2_58380_25980 0 1.664198e-07
I2160 n1_M2_58380_28140 0 1.641110e-07
I2161 n1_M2_58380_30300 0 1.638685e-07
I2162 n1_M2_58380_32460 0 1.665926e-07
I2163 n1_M2_58380_33540 0 1.732429e-07
I2164 n1_M2_58380_35700 0 1.841096e-07
I2165 n1_M2_58380_37860 0 1.978500e-07
I2166 n1_M2_58380_40020 0 2.113335e-07
I2167 n1_M2_58380_42180 0 2.209647e-07
I2168 n1_M2_58380_44340 0 2.248835e-07
I2169 n1_M2_58380_46500 0 2.242839e-07
I2170 n1_M2_58380_47580 0 2.227743e-07
I2171 n1_M2_58380_49740 0 2.243167e-07
I2172 n1_M2_58380_51900 0 2.313117e-07
I2173 n1_M2_58380_54060 0 2.439064e-07
I2174 n1_M2_58380_56220 0 2.605635e-07
I2175 n1_M2_58380_58380 0 2.792528e-07
I2176 n1_M2_58380_59460 0 2.984323e-07
I2177 n1_M2_58380_61620 0 3.172055e-07
I2178 n1_M2_58380_63780 0 3.346553e-07
I2179 n1_M2_58380_65940 0 3.490817e-07
I2180 n1_M2_58380_68100 0 3.579814e-07
I2181 n1_M2_58380_70260 0 3.589172e-07
I2182 n1_M2_58380_72420 0 3.507708e-07
I2183 n1_M2_58380_73500 0 3.346775e-07
I2184 n1_M2_58380_75660 0 3.141930e-07
I2185 n1_M2_58380_77820 0 2.944129e-07
I2186 n1_M2_58380_79980 0 2.800965e-07
I2187 n1_M2_58380_82140 0 2.736415e-07
I2188 n1_M2_58380_84300 0 2.741165e-07
I2189 n1_M2_58380_86460 0 2.781299e-07
I2190 n1_M2_58380_87540 0 2.820561e-07
I2191 n1_M2_58380_89700 0 2.841192e-07
I2192 n1_M2_58380_91860 0 2.848718e-07
I2193 n1_M2_58380_94020 0 2.857214e-07
I2194 n1_M2_58380_96180 0 2.869737e-07
I2195 n1_M2_58380_98340 0 2.873508e-07
I2196 n1_M2_58380_100500 0 2.855504e-07
I2197 n1_M2_58380_101580 0 2.821450e-07
I2198 n1_M2_58380_103740 0 2.796171e-07
I2199 n1_M2_58380_105900 0 2.803567e-07
I2200 n1_M2_58380_108060 0 2.845434e-07
I2201 n1_M2_58380_110220 0 2.898933e-07
I2202 n1_M2_58380_112380 0 2.933377e-07
I2203 n1_M2_58380_113460 0 2.930707e-07
I2204 n1_M2_58380_115620 0 2.893527e-07
I2205 n1_M2_58380_117780 0 2.837004e-07
I2206 n1_M2_58380_119940 0 2.774289e-07
I2207 n1_M2_58380_122100 0 2.708628e-07
I2208 n1_M2_58380_124260 0 2.636266e-07
I2209 n1_M2_58380_126420 0 2.554493e-07
I2210 n1_M2_58380_127500 0 2.464859e-07
I2211 n1_M2_58380_129660 0 2.368121e-07
I2212 n1_M2_58380_131820 0 2.255450e-07
I2213 n1_M2_58380_133980 0 2.105226e-07
I2214 n1_M2_58380_136140 0 1.892050e-07
I2215 n1_M2_58380_138300 0 1.605011e-07
I2216 n1_M2_58380_140460 0 1.263785e-07
I2217 n1_M2_58380_141540 0 9.197254e-08
I2218 n1_M2_58380_143700 0 6.397243e-08
I2219 n1_M2_58380_145860 0 4.829238e-08
I2220 n1_M2_59460_60 0 3.592419e-08
I2221 n1_M2_59460_2220 0 5.111985e-08
I2222 n1_M2_59460_4380 0 7.873562e-08
I2223 n1_M2_59460_5460 0 1.130777e-07
I2224 n1_M2_59460_7620 0 1.465758e-07
I2225 n1_M2_59460_9780 0 1.725168e-07
I2226 n1_M2_59460_11940 0 1.877903e-07
I2227 n1_M2_59460_14100 0 1.934511e-07
I2228 n1_M2_59460_16260 0 1.928344e-07
I2229 n1_M2_59460_18420 0 1.891520e-07
I2230 n1_M2_59460_19500 0 1.843357e-07
I2231 n1_M2_59460_21660 0 1.792725e-07
I2232 n1_M2_59460_23820 0 1.744468e-07
I2233 n1_M2_59460_25980 0 1.703084e-07
I2234 n1_M2_59460_28140 0 1.673939e-07
I2235 n1_M2_59460_30300 0 1.664436e-07
I2236 n1_M2_59460_32460 0 1.685236e-07
I2237 n1_M2_59460_33540 0 1.747595e-07
I2238 n1_M2_59460_35700 0 1.854995e-07
I2239 n1_M2_59460_37860 0 1.992614e-07
I2240 n1_M2_59460_40020 0 2.126779e-07
I2241 n1_M2_59460_42180 0 2.220983e-07
I2242 n1_M2_59460_44340 0 2.260357e-07
I2243 n1_M2_59460_46500 0 2.264658e-07
I2244 n1_M2_59460_47580 0 2.278934e-07
I2245 n1_M2_59460_49740 0 2.349241e-07
I2246 n1_M2_59460_51900 0 2.500287e-07
I2247 n1_M2_59460_54060 0 2.726781e-07
I2248 n1_M2_59460_56220 0 3.000108e-07
I2249 n1_M2_59460_58380 0 3.284712e-07
I2250 n1_M2_59460_59460 0 3.554149e-07
I2251 n1_M2_59460_61620 0 3.796470e-07
I2252 n1_M2_59460_63780 0 4.006045e-07
I2253 n1_M2_59460_65940 0 4.170486e-07
I2254 n1_M2_59460_68100 0 4.265285e-07
I2255 n1_M2_59460_70260 0 4.261317e-07
I2256 n1_M2_59460_72420 0 4.141362e-07
I2257 n1_M2_59460_73500 0 3.916734e-07
I2258 n1_M2_59460_75660 0 3.634301e-07
I2259 n1_M2_59460_77820 0 3.366062e-07
I2260 n1_M2_59460_79980 0 3.181217e-07
I2261 n1_M2_59460_82140 0 3.115035e-07
I2262 n1_M2_59460_84300 0 3.153722e-07
I2263 n1_M2_59460_86460 0 3.245224e-07
I2264 n1_M2_59460_87540 0 3.328850e-07
I2265 n1_M2_59460_89700 0 3.364738e-07
I2266 n1_M2_59460_91860 0 3.345663e-07
I2267 n1_M2_59460_94020 0 3.285939e-07
I2268 n1_M2_59460_96180 0 3.200669e-07
I2269 n1_M2_59460_98340 0 3.095940e-07
I2270 n1_M2_59460_100500 0 2.977636e-07
I2271 n1_M2_59460_101580 0 2.863903e-07
I2272 n1_M2_59460_103740 0 2.782043e-07
I2273 n1_M2_59460_105900 0 2.750199e-07
I2274 n1_M2_59460_108060 0 2.762821e-07
I2275 n1_M2_59460_110220 0 2.794763e-07
I2276 n1_M2_59460_112380 0 2.819020e-07
I2277 n1_M2_59460_113460 0 2.821596e-07
I2278 n1_M2_59460_115620 0 2.802873e-07
I2279 n1_M2_59460_117780 0 2.768643e-07
I2280 n1_M2_59460_119940 0 2.721403e-07
I2281 n1_M2_59460_122100 0 2.660131e-07
I2282 n1_M2_59460_124260 0 2.585869e-07
I2283 n1_M2_59460_126420 0 2.505310e-07
I2284 n1_M2_59460_127500 0 2.426499e-07
I2285 n1_M2_59460_129660 0 2.349442e-07
I2286 n1_M2_59460_131820 0 2.259085e-07
I2287 n1_M2_59460_133980 0 2.127306e-07
I2288 n1_M2_59460_136140 0 1.925581e-07
I2289 n1_M2_59460_138300 0 1.643302e-07
I2290 n1_M2_59460_140460 0 1.301801e-07
I2291 n1_M2_59460_141540 0 9.541839e-08
I2292 n1_M2_59460_143700 0 6.694860e-08
I2293 n1_M2_59460_145860 0 5.093871e-08
I2294 n1_M2_61620_60 0 3.854448e-08
I2295 n1_M2_61620_2220 0 5.454095e-08
I2296 n1_M2_61620_4380 0 8.343651e-08
I2297 n1_M2_61620_5460 0 1.190177e-07
I2298 n1_M2_61620_7620 0 1.532377e-07
I2299 n1_M2_61620_9780 0 1.791918e-07
I2300 n1_M2_61620_11940 0 1.939226e-07
I2301 n1_M2_61620_14100 0 1.988152e-07
I2302 n1_M2_61620_16260 0 1.974857e-07
I2303 n1_M2_61620_18420 0 1.932893e-07
I2304 n1_M2_61620_19500 0 1.881976e-07
I2305 n1_M2_61620_21660 0 1.830836e-07
I2306 n1_M2_61620_23820 0 1.783750e-07
I2307 n1_M2_61620_25980 0 1.744256e-07
I2308 n1_M2_61620_28140 0 1.716701e-07
I2309 n1_M2_61620_30300 0 1.707817e-07
I2310 n1_M2_61620_32460 0 1.727881e-07
I2311 n1_M2_61620_33540 0 1.787262e-07
I2312 n1_M2_61620_35700 0 1.887244e-07
I2313 n1_M2_61620_37860 0 2.009817e-07
I2314 n1_M2_61620_40020 0 2.119627e-07
I2315 n1_M2_61620_42180 0 2.183208e-07
I2316 n1_M2_61620_44340 0 2.194868e-07
I2317 n1_M2_61620_46500 0 2.187646e-07
I2318 n1_M2_61620_47580 0 2.219672e-07
I2319 n1_M2_61620_49740 0 2.345657e-07
I2320 n1_M2_61620_51900 0 2.591151e-07
I2321 n1_M2_61620_54060 0 2.942070e-07
I2322 n1_M2_61620_56220 0 3.352597e-07
I2323 n1_M2_61620_58380 0 3.767010e-07
I2324 n1_M2_61620_59460 0 4.143438e-07
I2325 n1_M2_61620_61620 0 4.464242e-07
I2326 n1_M2_61620_63780 0 4.726638e-07
I2327 n1_M2_61620_65940 0 4.923264e-07
I2328 n1_M2_61620_68100 0 5.030149e-07
I2329 n1_M2_61620_70260 0 5.012133e-07
I2330 n1_M2_61620_72420 0 4.844046e-07
I2331 n1_M2_61620_73500 0 4.536285e-07
I2332 n1_M2_61620_75660 0 4.148560e-07
I2333 n1_M2_61620_77820 0 3.777996e-07
I2334 n1_M2_61620_79980 0 3.521059e-07
I2335 n1_M2_61620_82140 0 3.430004e-07
I2336 n1_M2_61620_84300 0 3.490711e-07
I2337 n1_M2_61620_86460 0 3.634332e-07
I2338 n1_M2_61620_87540 0 3.773687e-07
I2339 n1_M2_61620_89700 0 3.841953e-07
I2340 n1_M2_61620_91860 0 3.813353e-07
I2341 n1_M2_61620_94020 0 3.698278e-07
I2342 n1_M2_61620_96180 0 3.523213e-07
I2343 n1_M2_61620_98340 0 3.315642e-07
I2344 n1_M2_61620_100500 0 3.103679e-07
I2345 n1_M2_61620_101580 0 2.919444e-07
I2346 n1_M2_61620_103740 0 2.791926e-07
I2347 n1_M2_61620_105900 0 2.731867e-07
I2348 n1_M2_61620_108060 0 2.725545e-07
I2349 n1_M2_61620_110220 0 2.745603e-07
I2350 n1_M2_61620_112380 0 2.768429e-07
I2351 n1_M2_61620_113460 0 2.782434e-07
I2352 n1_M2_61620_115620 0 2.783388e-07
I2353 n1_M2_61620_117780 0 2.766406e-07
I2354 n1_M2_61620_119940 0 2.724429e-07
I2355 n1_M2_61620_122100 0 2.655245e-07
I2356 n1_M2_61620_124260 0 2.568060e-07
I2357 n1_M2_61620_126420 0 2.481267e-07
I2358 n1_M2_61620_127500 0 2.410291e-07
I2359 n1_M2_61620_129660 0 2.353971e-07
I2360 n1_M2_61620_131820 0 2.289233e-07
I2361 n1_M2_61620_133980 0 2.178568e-07
I2362 n1_M2_61620_136140 0 1.987673e-07
I2363 n1_M2_61620_138300 0 1.705451e-07
I2364 n1_M2_61620_140460 0 1.356413e-07
I2365 n1_M2_61620_141540 0 9.979891e-08
I2366 n1_M2_61620_143700 0 7.033146e-08
I2367 n1_M2_61620_145860 0 5.372945e-08
I2368 n1_M2_63780_60 0 4.067150e-08
I2369 n1_M2_63780_2220 0 5.729909e-08
I2370 n1_M2_63780_4380 0 8.723272e-08
I2371 n1_M2_63780_5460 0 1.239077e-07
I2372 n1_M2_63780_7620 0 1.589573e-07
I2373 n1_M2_63780_9780 0 1.853070e-07
I2374 n1_M2_63780_11940 0 1.999736e-07
I2375 n1_M2_63780_14100 0 2.043845e-07
I2376 n1_M2_63780_16260 0 2.022408e-07
I2377 n1_M2_63780_18420 0 1.970916e-07
I2378 n1_M2_63780_19500 0 1.912191e-07
I2379 n1_M2_63780_21660 0 1.857967e-07
I2380 n1_M2_63780_23820 0 1.813805e-07
I2381 n1_M2_63780_25980 0 1.782326e-07
I2382 n1_M2_63780_28140 0 1.765670e-07
I2383 n1_M2_63780_30300 0 1.768090e-07
I2384 n1_M2_63780_32460 0 1.797068e-07
I2385 n1_M2_63780_33540 0 1.858881e-07
I2386 n1_M2_63780_35700 0 1.949119e-07
I2387 n1_M2_63780_37860 0 2.044274e-07
I2388 n1_M2_63780_40020 0 2.107743e-07
I2389 n1_M2_63780_42180 0 2.112605e-07
I2390 n1_M2_63780_44340 0 2.067528e-07
I2391 n1_M2_63780_46500 0 2.023662e-07
I2392 n1_M2_63780_47580 0 2.055347e-07
I2393 n1_M2_63780_49740 0 2.227264e-07
I2394 n1_M2_63780_51900 0 2.565922e-07
I2395 n1_M2_63780_54060 0 3.048010e-07
I2396 n1_M2_63780_56220 0 3.609745e-07
I2397 n1_M2_63780_58380 0 4.173876e-07
I2398 n1_M2_63780_59460 0 4.680685e-07
I2399 n1_M2_63780_61620 0 5.103469e-07
I2400 n1_M2_63780_63780 0 5.439067e-07
I2401 n1_M2_63780_65940 0 5.683322e-07
I2402 n1_M2_63780_68100 0 5.812509e-07
I2403 n1_M2_63780_70260 0 5.785631e-07
I2404 n1_M2_63780_72420 0 5.569117e-07
I2405 n1_M2_63780_73500 0 5.171231e-07
I2406 n1_M2_63780_75660 0 4.663357e-07
I2407 n1_M2_63780_77820 0 4.167851e-07
I2408 n1_M2_63780_79980 0 3.810777e-07
I2409 n1_M2_63780_82140 0 3.665954e-07
I2410 n1_M2_63780_84300 0 3.724583e-07
I2411 n1_M2_63780_86460 0 3.905838e-07
I2412 n1_M2_63780_87540 0 4.098451e-07
I2413 n1_M2_63780_89700 0 4.208078e-07
I2414 n1_M2_63780_91860 0 4.187587e-07
I2415 n1_M2_63780_94020 0 4.039892e-07
I2416 n1_M2_63780_96180 0 3.800042e-07
I2417 n1_M2_63780_98340 0 3.515208e-07
I2418 n1_M2_63780_100500 0 3.234297e-07
I2419 n1_M2_63780_101580 0 3.001475e-07
I2420 n1_M2_63780_103740 0 2.845592e-07
I2421 n1_M2_63780_105900 0 2.769605e-07
I2422 n1_M2_63780_108060 0 2.752899e-07
I2423 n1_M2_63780_110220 0 2.767281e-07
I2424 n1_M2_63780_112380 0 2.792276e-07
I2425 n1_M2_63780_113460 0 2.816962e-07
I2426 n1_M2_63780_115620 0 2.831313e-07
I2427 n1_M2_63780_117780 0 2.820919e-07
I2428 n1_M2_63780_119940 0 2.772333e-07
I2429 n1_M2_63780_122100 0 2.685186e-07
I2430 n1_M2_63780_124260 0 2.577871e-07
I2431 n1_M2_63780_126420 0 2.479563e-07
I2432 n1_M2_63780_127500 0 2.411766e-07
I2433 n1_M2_63780_129660 0 2.371751e-07
I2434 n1_M2_63780_131820 0 2.328810e-07
I2435 n1_M2_63780_133980 0 2.236303e-07
I2436 n1_M2_63780_136140 0 2.053854e-07
I2437 n1_M2_63780_138300 0 1.769443e-07
I2438 n1_M2_63780_140460 0 1.410746e-07
I2439 n1_M2_63780_141540 0 1.039874e-07
I2440 n1_M2_63780_143700 0 7.342974e-08
I2441 n1_M2_63780_145860 0 5.620182e-08
I2442 n1_M2_65940_60 0 4.199536e-08
I2443 n1_M2_65940_2220 0 5.898375e-08
I2444 n1_M2_65940_4380 0 8.954681e-08
I2445 n1_M2_65940_5460 0 1.269939e-07
I2446 n1_M2_65940_7620 0 1.628563e-07
I2447 n1_M2_65940_9780 0 1.899583e-07
I2448 n1_M2_65940_11940 0 2.051416e-07
I2449 n1_M2_65940_14100 0 2.095915e-07
I2450 n1_M2_65940_16260 0 2.068636e-07
I2451 n1_M2_65940_18420 0 2.006672e-07
I2452 n1_M2_65940_19500 0 1.937541e-07
I2453 n1_M2_65940_21660 0 1.878278e-07
I2454 n1_M2_65940_23820 0 1.837482e-07
I2455 n1_M2_65940_25980 0 1.817575e-07
I2456 n1_M2_65940_28140 0 1.818328e-07
I2457 n1_M2_65940_30300 0 1.840693e-07
I2458 n1_M2_65940_32460 0 1.887666e-07
I2459 n1_M2_65940_33540 0 1.958697e-07
I2460 n1_M2_65940_35700 0 2.040449e-07
I2461 n1_M2_65940_37860 0 2.101668e-07
I2462 n1_M2_65940_40020 0 2.104664e-07
I2463 n1_M2_65940_42180 0 2.031792e-07
I2464 n1_M2_65940_44340 0 1.909822e-07
I2465 n1_M2_65940_46500 0 1.810753e-07
I2466 n1_M2_65940_47580 0 1.825878e-07
I2467 n1_M2_65940_49740 0 2.029081e-07
I2468 n1_M2_65940_51900 0 2.447026e-07
I2469 n1_M2_65940_54060 0 3.047636e-07
I2470 n1_M2_65940_56220 0 3.751155e-07
I2471 n1_M2_65940_58380 0 4.461161e-07
I2472 n1_M2_65940_59460 0 5.100857e-07
I2473 n1_M2_65940_61620 0 5.632653e-07
I2474 n1_M2_65940_63780 0 6.049744e-07
I2475 n1_M2_65940_65940 0 6.348932e-07
I2476 n1_M2_65940_68100 0 6.506995e-07
I2477 n1_M2_65940_70260 0 6.479051e-07
I2478 n1_M2_65940_72420 0 6.224550e-07
I2479 n1_M2_65940_73500 0 5.748640e-07
I2480 n1_M2_65940_75660 0 5.130830e-07
I2481 n1_M2_65940_77820 0 4.514190e-07
I2482 n1_M2_65940_79980 0 4.051320e-07
I2483 n1_M2_65940_82140 0 3.837666e-07
I2484 n1_M2_65940_84300 0 3.872893e-07
I2485 n1_M2_65940_86460 0 4.069259e-07
I2486 n1_M2_65940_87540 0 4.297120e-07
I2487 n1_M2_65940_89700 0 4.440013e-07
I2488 n1_M2_65940_91860 0 4.433399e-07
I2489 n1_M2_65940_94020 0 4.273782e-07
I2490 n1_M2_65940_96180 0 4.002136e-07
I2491 n1_M2_65940_98340 0 3.679368e-07
I2492 n1_M2_65940_100500 0 3.367566e-07
I2493 n1_M2_65940_101580 0 3.116182e-07
I2494 n1_M2_65940_103740 0 2.950532e-07
I2495 n1_M2_65940_105900 0 2.866793e-07
I2496 n1_M2_65940_108060 0 2.841273e-07
I2497 n1_M2_65940_110220 0 2.848274e-07
I2498 n1_M2_65940_112380 0 2.871087e-07
I2499 n1_M2_65940_113460 0 2.898275e-07
I2500 n1_M2_65940_115620 0 2.913928e-07
I2501 n1_M2_65940_117780 0 2.896846e-07
I2502 n1_M2_65940_119940 0 2.831412e-07
I2503 n1_M2_65940_122100 0 2.721537e-07
I2504 n1_M2_65940_124260 0 2.593511e-07
I2505 n1_M2_65940_126420 0 2.483361e-07
I2506 n1_M2_65940_127500 0 2.415251e-07
I2507 n1_M2_65940_129660 0 2.384373e-07
I2508 n1_M2_65940_131820 0 2.354817e-07
I2509 n1_M2_65940_133980 0 2.274178e-07
I2510 n1_M2_65940_136140 0 2.098050e-07
I2511 n1_M2_65940_138300 0 1.813319e-07
I2512 n1_M2_65940_140460 0 1.449118e-07
I2513 n1_M2_65940_141540 0 1.070319e-07
I2514 n1_M2_65940_143700 0 7.573764e-08
I2515 n1_M2_65940_145860 0 5.807279e-08
I2516 n1_M2_68100_60 0 4.242962e-08
I2517 n1_M2_68100_2220 0 5.949865e-08
I2518 n1_M2_68100_4380 0 9.025739e-08
I2519 n1_M2_68100_5460 0 1.280983e-07
I2520 n1_M2_68100_7620 0 1.646488e-07
I2521 n1_M2_68100_9780 0 1.927114e-07
I2522 n1_M2_68100_11940 0 2.088758e-07
I2523 n1_M2_68100_14100 0 2.139155e-07
I2524 n1_M2_68100_16260 0 2.110862e-07
I2525 n1_M2_68100_18420 0 2.041806e-07
I2526 n1_M2_68100_19500 0 1.964133e-07
I2527 n1_M2_68100_21660 0 1.900536e-07
I2528 n1_M2_68100_23820 0 1.863198e-07
I2529 n1_M2_68100_25980 0 1.855018e-07
I2530 n1_M2_68100_28140 0 1.874122e-07
I2531 n1_M2_68100_30300 0 1.918660e-07
I2532 n1_M2_68100_32460 0 1.986991e-07
I2533 n1_M2_68100_33540 0 2.070637e-07
I2534 n1_M2_68100_35700 0 2.145636e-07
I2535 n1_M2_68100_37860 0 2.171844e-07
I2536 n1_M2_68100_40020 0 2.110831e-07
I2537 n1_M2_68100_42180 0 1.955813e-07
I2538 n1_M2_68100_44340 0 1.752948e-07
I2539 n1_M2_68100_46500 0 1.594606e-07
I2540 n1_M2_68100_47580 0 1.586649e-07
I2541 n1_M2_68100_49740 0 1.809034e-07
I2542 n1_M2_68100_51900 0 2.286464e-07
I2543 n1_M2_68100_54060 0 2.978304e-07
I2544 n1_M2_68100_56220 0 3.791602e-07
I2545 n1_M2_68100_58380 0 4.614992e-07
I2546 n1_M2_68100_59460 0 5.358338e-07
I2547 n1_M2_68100_61620 0 5.974987e-07
I2548 n1_M2_68100_63780 0 6.454604e-07
I2549 n1_M2_68100_65940 0 6.795113e-07
I2550 n1_M2_68100_68100 0 6.975681e-07
I2551 n1_M2_68100_70260 0 6.951135e-07
I2552 n1_M2_68100_72420 0 6.677162e-07
I2553 n1_M2_68100_73500 0 6.155767e-07
I2554 n1_M2_68100_75660 0 5.469738e-07
I2555 n1_M2_68100_77820 0 4.774165e-07
I2556 n1_M2_68100_79980 0 4.238768e-07
I2557 n1_M2_68100_82140 0 3.973644e-07
I2558 n1_M2_68100_84300 0 3.984080e-07
I2559 n1_M2_68100_86460 0 4.177262e-07
I2560 n1_M2_68100_87540 0 4.411849e-07
I2561 n1_M2_68100_89700 0 4.560063e-07
I2562 n1_M2_68100_91860 0 4.552024e-07
I2563 n1_M2_68100_94020 0 4.386204e-07
I2564 n1_M2_68100_96180 0 4.110009e-07
I2565 n1_M2_68100_98340 0 3.790175e-07
I2566 n1_M2_68100_100500 0 3.489439e-07
I2567 n1_M2_68100_101580 0 3.251342e-07
I2568 n1_M2_68100_103740 0 3.092482e-07
I2569 n1_M2_68100_105900 0 3.004056e-07
I2570 n1_M2_68100_108060 0 2.964904e-07
I2571 n1_M2_68100_110220 0 2.956585e-07
I2572 n1_M2_68100_112380 0 2.967582e-07
I2573 n1_M2_68100_113460 0 2.985289e-07
I2574 n1_M2_68100_115620 0 2.988445e-07
I2575 n1_M2_68100_117780 0 2.952288e-07
I2576 n1_M2_68100_119940 0 2.863242e-07
I2577 n1_M2_68100_122100 0 2.731215e-07
I2578 n1_M2_68100_124260 0 2.587814e-07
I2579 n1_M2_68100_126420 0 2.470615e-07
I2580 n1_M2_68100_127500 0 2.402031e-07
I2581 n1_M2_68100_129660 0 2.374529e-07
I2582 n1_M2_68100_131820 0 2.350209e-07
I2583 n1_M2_68100_133980 0 2.275564e-07
I2584 n1_M2_68100_136140 0 2.105254e-07
I2585 n1_M2_68100_138300 0 1.825054e-07
I2586 n1_M2_68100_140460 0 1.463152e-07
I2587 n1_M2_68100_141540 0 1.084281e-07
I2588 n1_M2_68100_143700 0 7.698633e-08
I2589 n1_M2_68100_145860 0 5.918991e-08
I2590 n1_M2_70260_60 0 4.218147e-08
I2591 n1_M2_70260_2220 0 5.914580e-08
I2592 n1_M2_70260_4380 0 8.980721e-08
I2593 n1_M2_70260_5460 0 1.277556e-07
I2594 n1_M2_70260_7620 0 1.648072e-07
I2595 n1_M2_70260_9780 0 1.937819e-07
I2596 n1_M2_70260_11940 0 2.110285e-07
I2597 n1_M2_70260_14100 0 2.169310e-07
I2598 n1_M2_70260_16260 0 2.144711e-07
I2599 n1_M2_70260_18420 0 2.074863e-07
I2600 n1_M2_70260_19500 0 1.995147e-07
I2601 n1_M2_70260_21660 0 1.932029e-07
I2602 n1_M2_70260_23820 0 1.899885e-07
I2603 n1_M2_70260_25980 0 1.901834e-07
I2604 n1_M2_70260_28140 0 1.935174e-07
I2605 n1_M2_70260_30300 0 1.996663e-07
I2606 n1_M2_70260_32460 0 2.081434e-07
I2607 n1_M2_70260_33540 0 2.174128e-07
I2608 n1_M2_70260_35700 0 2.240897e-07
I2609 n1_M2_70260_37860 0 2.233594e-07
I2610 n1_M2_70260_40020 0 2.114087e-07
I2611 n1_M2_70260_42180 0 1.886759e-07
I2612 n1_M2_70260_44340 0 1.615497e-07
I2613 n1_M2_70260_46500 0 1.409107e-07
I2614 n1_M2_70260_47580 0 1.382918e-07
I2615 n1_M2_70260_49740 0 1.618318e-07
I2616 n1_M2_70260_51900 0 2.135191e-07
I2617 n1_M2_70260_54060 0 2.883812e-07
I2618 n1_M2_70260_56220 0 3.759843e-07
I2619 n1_M2_70260_58380 0 4.640841e-07
I2620 n1_M2_70260_59460 0 5.428643e-07
I2621 n1_M2_70260_61620 0 6.073323e-07
I2622 n1_M2_70260_63780 0 6.566176e-07
I2623 n1_M2_70260_65940 0 6.910452e-07
I2624 n1_M2_70260_68100 0 7.091729e-07
I2625 n1_M2_70260_70260 0 7.069144e-07
I2626 n1_M2_70260_72420 0 6.798876e-07
I2627 n1_M2_70260_73500 0 6.280664e-07
I2628 n1_M2_70260_75660 0 5.595248e-07
I2629 n1_M2_70260_77820 0 4.898139e-07
I2630 n1_M2_70260_79980 0 4.361508e-07
I2631 n1_M2_70260_82140 0 4.096745e-07
I2632 n1_M2_70260_84300 0 4.106069e-07
I2633 n1_M2_70260_86460 0 4.289708e-07
I2634 n1_M2_70260_87540 0 4.500734e-07
I2635 n1_M2_70260_89700 0 4.613626e-07
I2636 n1_M2_70260_91860 0 4.570267e-07
I2637 n1_M2_70260_94020 0 4.384885e-07
I2638 n1_M2_70260_96180 0 4.115577e-07
I2639 n1_M2_70260_98340 0 3.828151e-07
I2640 n1_M2_70260_100500 0 3.572595e-07
I2641 n1_M2_70260_101580 0 3.373998e-07
I2642 n1_M2_70260_103740 0 3.234364e-07
I2643 n1_M2_70260_105900 0 3.141641e-07
I2644 n1_M2_70260_108060 0 3.082798e-07
I2645 n1_M2_70260_110220 0 3.051243e-07
I2646 n1_M2_70260_112380 0 3.042005e-07
I2647 n1_M2_70260_113460 0 3.040883e-07
I2648 n1_M2_70260_115620 0 3.021899e-07
I2649 n1_M2_70260_117780 0 2.959445e-07
I2650 n1_M2_70260_119940 0 2.845111e-07
I2651 n1_M2_70260_122100 0 2.695609e-07
I2652 n1_M2_70260_124260 0 2.545253e-07
I2653 n1_M2_70260_126420 0 2.428606e-07
I2654 n1_M2_70260_127500 0 2.362710e-07
I2655 n1_M2_70260_129660 0 2.336750e-07
I2656 n1_M2_70260_131820 0 2.313327e-07
I2657 n1_M2_70260_133980 0 2.241489e-07
I2658 n1_M2_70260_136140 0 2.077480e-07
I2659 n1_M2_70260_138300 0 1.806184e-07
I2660 n1_M2_70260_140460 0 1.453236e-07
I2661 n1_M2_70260_141540 0 1.081119e-07
I2662 n1_M2_70260_143700 0 7.705486e-08
I2663 n1_M2_70260_145860 0 5.941288e-08
I2664 n1_M2_72420_60 0 4.165223e-08
I2665 n1_M2_72420_2220 0 5.847509e-08
I2666 n1_M2_72420_4380 0 8.897464e-08
I2667 n1_M2_72420_5460 0 1.269266e-07
I2668 n1_M2_72420_7620 0 1.642903e-07
I2669 n1_M2_72420_9780 0 1.938741e-07
I2670 n1_M2_72420_11940 0 2.118606e-07
I2671 n1_M2_72420_14100 0 2.184452e-07
I2672 n1_M2_72420_16260 0 2.165530e-07
I2673 n1_M2_72420_18420 0 2.101225e-07
I2674 n1_M2_72420_19500 0 2.028321e-07
I2675 n1_M2_72420_21660 0 1.973750e-07
I2676 n1_M2_72420_23820 0 1.951035e-07
I2677 n1_M2_72420_25980 0 1.961974e-07
I2678 n1_M2_72420_28140 0 2.003174e-07
I2679 n1_M2_72420_30300 0 2.071400e-07
I2680 n1_M2_72420_32460 0 2.160814e-07
I2681 n1_M2_72420_33540 0 2.252044e-07
I2682 n1_M2_72420_35700 0 2.304620e-07
I2683 n1_M2_72420_37860 0 2.265515e-07
I2684 n1_M2_72420_40020 0 2.098618e-07
I2685 n1_M2_72420_42180 0 1.818332e-07
I2686 n1_M2_72420_44340 0 1.501751e-07
I2687 n1_M2_72420_46500 0 1.267491e-07
I2688 n1_M2_72420_47580 0 1.233905e-07
I2689 n1_M2_72420_49740 0 1.479270e-07
I2690 n1_M2_72420_51900 0 2.016393e-07
I2691 n1_M2_72420_54060 0 2.785970e-07
I2692 n1_M2_72420_56220 0 3.673234e-07
I2693 n1_M2_72420_58380 0 4.547436e-07
I2694 n1_M2_72420_59460 0 5.307685e-07
I2695 n1_M2_72420_61620 0 5.908404e-07
I2696 n1_M2_72420_63780 0 6.350733e-07
I2697 n1_M2_72420_65940 0 6.650108e-07
I2698 n1_M2_72420_68100 0 6.803699e-07
I2699 n1_M2_72420_70260 0 6.779529e-07
I2700 n1_M2_72420_72420 0 6.538274e-07
I2701 n1_M2_72420_73500 0 6.078249e-07
I2702 n1_M2_72420_75660 0 5.472625e-07
I2703 n1_M2_72420_77820 0 4.864791e-07
I2704 n1_M2_72420_79980 0 4.412927e-07
I2705 n1_M2_72420_82140 0 4.214300e-07
I2706 n1_M2_72420_84300 0 4.257864e-07
I2707 n1_M2_72420_86460 0 4.434394e-07
I2708 n1_M2_72420_87540 0 4.597286e-07
I2709 n1_M2_72420_89700 0 4.636117e-07
I2710 n1_M2_72420_91860 0 4.520236e-07
I2711 n1_M2_72420_94020 0 4.292358e-07
I2712 n1_M2_72420_96180 0 4.026209e-07
I2713 n1_M2_72420_98340 0 3.782706e-07
I2714 n1_M2_72420_100500 0 3.589631e-07
I2715 n1_M2_72420_101580 0 3.444566e-07
I2716 n1_M2_72420_103740 0 3.330797e-07
I2717 n1_M2_72420_105900 0 3.234338e-07
I2718 n1_M2_72420_108060 0 3.153967e-07
I2719 n1_M2_72420_110220 0 3.097441e-07
I2720 n1_M2_72420_112380 0 3.066616e-07
I2721 n1_M2_72420_113460 0 3.045200e-07
I2722 n1_M2_72420_115620 0 3.003051e-07
I2723 n1_M2_72420_117780 0 2.915349e-07
I2724 n1_M2_72420_119940 0 2.780165e-07
I2725 n1_M2_72420_122100 0 2.620694e-07
I2726 n1_M2_72420_124260 0 2.472022e-07
I2727 n1_M2_72420_126420 0 2.363307e-07
I2728 n1_M2_72420_127500 0 2.304688e-07
I2729 n1_M2_72420_129660 0 2.281977e-07
I2730 n1_M2_72420_131820 0 2.259269e-07
I2731 n1_M2_72420_133980 0 2.189443e-07
I2732 n1_M2_72420_136140 0 2.031311e-07
I2733 n1_M2_72420_138300 0 1.769405e-07
I2734 n1_M2_72420_140460 0 1.426966e-07
I2735 n1_M2_72420_141540 0 1.063995e-07
I2736 n1_M2_72420_143700 0 7.597743e-08
I2737 n1_M2_72420_145860 0 5.865164e-08
I2738 n1_M2_73500_60 0 4.120081e-08
I2739 n1_M2_73500_2220 0 5.795168e-08
I2740 n1_M2_73500_4380 0 8.838719e-08
I2741 n1_M2_73500_5460 0 1.263726e-07
I2742 n1_M2_73500_7620 0 1.638793e-07
I2743 n1_M2_73500_9780 0 1.936307e-07
I2744 n1_M2_73500_11940 0 2.117386e-07
I2745 n1_M2_73500_14100 0 2.184787e-07
I2746 n1_M2_73500_16260 0 2.170184e-07
I2747 n1_M2_73500_18420 0 2.115194e-07
I2748 n1_M2_73500_19500 0 2.056536e-07
I2749 n1_M2_73500_21660 0 2.018330e-07
I2750 n1_M2_73500_23820 0 2.009886e-07
I2751 n1_M2_73500_25980 0 2.029491e-07
I2752 n1_M2_73500_28140 0 2.072357e-07
I2753 n1_M2_73500_30300 0 2.135919e-07
I2754 n1_M2_73500_32460 0 2.215488e-07
I2755 n1_M2_73500_33540 0 2.291488e-07
I2756 n1_M2_73500_35700 0 2.321876e-07
I2757 n1_M2_73500_37860 0 2.253407e-07
I2758 n1_M2_73500_40020 0 2.053719e-07
I2759 n1_M2_73500_42180 0 1.744324e-07
I2760 n1_M2_73500_44340 0 1.408677e-07
I2761 n1_M2_73500_46500 0 1.167265e-07
I2762 n1_M2_73500_47580 0 1.135385e-07
I2763 n1_M2_73500_49740 0 1.385249e-07
I2764 n1_M2_73500_51900 0 1.922253e-07
I2765 n1_M2_73500_54060 0 2.678694e-07
I2766 n1_M2_73500_56220 0 3.531345e-07
I2767 n1_M2_73500_58380 0 4.344000e-07
I2768 n1_M2_73500_59460 0 5.017348e-07
I2769 n1_M2_73500_61620 0 5.516059e-07
I2770 n1_M2_73500_63780 0 5.857555e-07
I2771 n1_M2_73500_65940 0 6.074976e-07
I2772 n1_M2_73500_68100 0 6.181225e-07
I2773 n1_M2_73500_70260 0 6.156634e-07
I2774 n1_M2_73500_72420 0 5.968965e-07
I2775 n1_M2_73500_73500 0 5.614857e-07
I2776 n1_M2_73500_75660 0 5.154398e-07
I2777 n1_M2_73500_77820 0 4.707887e-07
I2778 n1_M2_73500_79980 0 4.406047e-07
I2779 n1_M2_73500_82140 0 4.320558e-07
I2780 n1_M2_73500_84300 0 4.421279e-07
I2781 n1_M2_73500_86460 0 4.590681e-07
I2782 n1_M2_73500_87540 0 4.689334e-07
I2783 n1_M2_73500_89700 0 4.631240e-07
I2784 n1_M2_73500_91860 0 4.421415e-07
I2785 n1_M2_73500_94020 0 4.135829e-07
I2786 n1_M2_73500_96180 0 3.864746e-07
I2787 n1_M2_73500_98340 0 3.662306e-07
I2788 n1_M2_73500_100500 0 3.531219e-07
I2789 n1_M2_73500_101580 0 3.439668e-07
I2790 n1_M2_73500_103740 0 3.352258e-07
I2791 n1_M2_73500_105900 0 3.254358e-07
I2792 n1_M2_73500_108060 0 3.157376e-07
I2793 n1_M2_73500_110220 0 3.082782e-07
I2794 n1_M2_73500_112380 0 3.037840e-07
I2795 n1_M2_73500_113460 0 3.003440e-07
I2796 n1_M2_73500_115620 0 2.945689e-07
I2797 n1_M2_73500_117780 0 2.841145e-07
I2798 n1_M2_73500_119940 0 2.694035e-07
I2799 n1_M2_73500_122100 0 2.532841e-07
I2800 n1_M2_73500_124260 0 2.392431e-07
I2801 n1_M2_73500_126420 0 2.296539e-07
I2802 n1_M2_73500_127500 0 2.249102e-07
I2803 n1_M2_73500_129660 0 2.233002e-07
I2804 n1_M2_73500_131820 0 2.213342e-07
I2805 n1_M2_73500_133980 0 2.145715e-07
I2806 n1_M2_73500_136140 0 1.990889e-07
I2807 n1_M2_73500_138300 0 1.733802e-07
I2808 n1_M2_73500_140460 0 1.397154e-07
I2809 n1_M2_73500_141540 0 1.040135e-07
I2810 n1_M2_73500_143700 0 7.409737e-08
I2811 n1_M2_73500_145860 0 5.706841e-08
I2812 n1_M2_75660_60 0 4.092516e-08
I2813 n1_M2_75660_2220 0 5.766199e-08
I2814 n1_M2_75660_4380 0 8.810171e-08
I2815 n1_M2_75660_5460 0 1.261068e-07
I2816 n1_M2_75660_7620 0 1.635529e-07
I2817 n1_M2_75660_9780 0 1.930321e-07
I2818 n1_M2_75660_11940 0 2.106667e-07
I2819 n1_M2_75660_14100 0 2.170132e-07
I2820 n1_M2_75660_16260 0 2.156901e-07
I2821 n1_M2_75660_18420 0 2.111658e-07
I2822 n1_M2_75660_19500 0 2.070157e-07
I2823 n1_M2_75660_21660 0 2.051693e-07
I2824 n1_M2_75660_23820 0 2.059276e-07
I2825 n1_M2_75660_25980 0 2.086166e-07
I2826 n1_M2_75660_28140 0 2.125282e-07
I2827 n1_M2_75660_30300 0 2.174596e-07
I2828 n1_M2_75660_32460 0 2.231917e-07
I2829 n1_M2_75660_33540 0 2.281140e-07
I2830 n1_M2_75660_35700 0 2.284168e-07
I2831 n1_M2_75660_37860 0 2.192373e-07
I2832 n1_M2_75660_40020 0 1.977977e-07
I2833 n1_M2_75660_42180 0 1.664987e-07
I2834 n1_M2_75660_44340 0 1.335140e-07
I2835 n1_M2_75660_46500 0 1.103058e-07
I2836 n1_M2_75660_47580 0 1.076457e-07
I2837 n1_M2_75660_49740 0 1.320691e-07
I2838 n1_M2_75660_51900 0 1.835767e-07
I2839 n1_M2_75660_54060 0 2.549435e-07
I2840 n1_M2_75660_56220 0 3.334761e-07
I2841 n1_M2_75660_58380 0 4.054570e-07
I2842 n1_M2_75660_59460 0 4.614236e-07
I2843 n1_M2_75660_61620 0 4.990084e-07
I2844 n1_M2_75660_63780 0 5.216230e-07
I2845 n1_M2_75660_65940 0 5.343931e-07
I2846 n1_M2_75660_68100 0 5.402911e-07
I2847 n1_M2_75660_70260 0 5.387349e-07
I2848 n1_M2_75660_72420 0 5.272781e-07
I2849 n1_M2_75660_73500 0 5.052363e-07
I2850 n1_M2_75660_75660 0 4.768065e-07
I2851 n1_M2_75660_77820 0 4.509969e-07
I2852 n1_M2_75660_79980 0 4.374813e-07
I2853 n1_M2_75660_82140 0 4.405700e-07
I2854 n1_M2_75660_84300 0 4.555635e-07
I2855 n1_M2_75660_86460 0 4.705523e-07
I2856 n1_M2_75660_87540 0 4.730967e-07
I2857 n1_M2_75660_89700 0 4.574817e-07
I2858 n1_M2_75660_91860 0 4.276229e-07
I2859 n1_M2_75660_94020 0 3.938547e-07
I2860 n1_M2_75660_96180 0 3.662830e-07
I2861 n1_M2_75660_98340 0 3.494669e-07
I2862 n1_M2_75660_100500 0 3.414581e-07
I2863 n1_M2_75660_101580 0 3.366786e-07
I2864 n1_M2_75660_103740 0 3.302069e-07
I2865 n1_M2_75660_105900 0 3.207064e-07
I2866 n1_M2_75660_108060 0 3.104309e-07
I2867 n1_M2_75660_110220 0 3.025587e-07
I2868 n1_M2_75660_112380 0 2.980580e-07
I2869 n1_M2_75660_113460 0 2.946151e-07
I2870 n1_M2_75660_115620 0 2.884722e-07
I2871 n1_M2_75660_117780 0 2.774123e-07
I2872 n1_M2_75660_119940 0 2.623710e-07
I2873 n1_M2_75660_122100 0 2.466171e-07
I2874 n1_M2_75660_124260 0 2.336393e-07
I2875 n1_M2_75660_126420 0 2.254515e-07
I2876 n1_M2_75660_127500 0 2.220369e-07
I2877 n1_M2_75660_129660 0 2.214489e-07
I2878 n1_M2_75660_131820 0 2.201341e-07
I2879 n1_M2_75660_133980 0 2.136452e-07
I2880 n1_M2_75660_136140 0 1.980777e-07
I2881 n1_M2_75660_138300 0 1.720356e-07
I2882 n1_M2_75660_140460 0 1.380050e-07
I2883 n1_M2_75660_141540 0 1.021082e-07
I2884 n1_M2_75660_143700 0 7.220284e-08
I2885 n1_M2_75660_145860 0 5.525365e-08
I2886 n1_M2_77820_60 0 4.061678e-08
I2887 n1_M2_77820_2220 0 5.726972e-08
I2888 n1_M2_77820_4380 0 8.755823e-08
I2889 n1_M2_77820_5460 0 1.253285e-07
I2890 n1_M2_77820_7620 0 1.623699e-07
I2891 n1_M2_77820_9780 0 1.911886e-07
I2892 n1_M2_77820_11940 0 2.079849e-07
I2893 n1_M2_77820_14100 0 2.136483e-07
I2894 n1_M2_77820_16260 0 2.122519e-07
I2895 n1_M2_77820_18420 0 2.085219e-07
I2896 n1_M2_77820_19500 0 2.058723e-07
I2897 n1_M2_77820_21660 0 2.057115e-07
I2898 n1_M2_77820_23820 0 2.077157e-07
I2899 n1_M2_77820_25980 0 2.107251e-07
I2900 n1_M2_77820_28140 0 2.137869e-07
I2901 n1_M2_77820_30300 0 2.167133e-07
I2902 n1_M2_77820_32460 0 2.195830e-07
I2903 n1_M2_77820_33540 0 2.213898e-07
I2904 n1_M2_77820_35700 0 2.191561e-07
I2905 n1_M2_77820_37860 0 2.088349e-07
I2906 n1_M2_77820_40020 0 1.880626e-07
I2907 n1_M2_77820_42180 0 1.589602e-07
I2908 n1_M2_77820_44340 0 1.287704e-07
I2909 n1_M2_77820_46500 0 1.077531e-07
I2910 n1_M2_77820_47580 0 1.056577e-07
I2911 n1_M2_77820_49740 0 1.284139e-07
I2912 n1_M2_77820_51900 0 1.758331e-07
I2913 n1_M2_77820_54060 0 2.408166e-07
I2914 n1_M2_77820_56220 0 3.110248e-07
I2915 n1_M2_77820_58380 0 3.732629e-07
I2916 n1_M2_77820_59460 0 4.187412e-07
I2917 n1_M2_77820_61620 0 4.459402e-07
I2918 n1_M2_77820_63780 0 4.593312e-07
I2919 n1_M2_77820_65940 0 4.653288e-07
I2920 n1_M2_77820_68100 0 4.683571e-07
I2921 n1_M2_77820_70260 0 4.691816e-07
I2922 n1_M2_77820_72420 0 4.660308e-07
I2923 n1_M2_77820_73500 0 4.575700e-07
I2924 n1_M2_77820_75660 0 4.457882e-07
I2925 n1_M2_77820_77820 0 4.364442e-07
I2926 n1_M2_77820_79980 0 4.359737e-07
I2927 n1_M2_77820_82140 0 4.464488e-07
I2928 n1_M2_77820_84300 0 4.624645e-07
I2929 n1_M2_77820_86460 0 4.730186e-07
I2930 n1_M2_77820_87540 0 4.678904e-07
I2931 n1_M2_77820_89700 0 4.441966e-07
I2932 n1_M2_77820_91860 0 4.083493e-07
I2933 n1_M2_77820_94020 0 3.720559e-07
I2934 n1_M2_77820_96180 0 3.454055e-07
I2935 n1_M2_77820_98340 0 3.318174e-07
I2936 n1_M2_77820_100500 0 3.276875e-07
I2937 n1_M2_77820_101580 0 3.260226e-07
I2938 n1_M2_77820_103740 0 3.213417e-07
I2939 n1_M2_77820_105900 0 3.127264e-07
I2940 n1_M2_77820_108060 0 3.033081e-07
I2941 n1_M2_77820_110220 0 2.968212e-07
I2942 n1_M2_77820_112380 0 2.940656e-07
I2943 n1_M2_77820_113460 0 2.921138e-07
I2944 n1_M2_77820_115620 0 2.867571e-07
I2945 n1_M2_77820_117780 0 2.758444e-07
I2946 n1_M2_77820_119940 0 2.607620e-07
I2947 n1_M2_77820_122100 0 2.452243e-07
I2948 n1_M2_77820_124260 0 2.329128e-07
I2949 n1_M2_77820_126420 0 2.257876e-07
I2950 n1_M2_77820_127500 0 2.236672e-07
I2951 n1_M2_77820_129660 0 2.243864e-07
I2952 n1_M2_77820_131820 0 2.240882e-07
I2953 n1_M2_77820_133980 0 2.179709e-07
I2954 n1_M2_77820_136140 0 2.019187e-07
I2955 n1_M2_77820_138300 0 1.746724e-07
I2956 n1_M2_77820_140460 0 1.391762e-07
I2957 n1_M2_77820_141540 0 1.020537e-07
I2958 n1_M2_77820_143700 0 7.140794e-08
I2959 n1_M2_77820_145860 0 5.415503e-08
I2960 n1_M2_79980_60 0 3.991445e-08
I2961 n1_M2_79980_2220 0 5.624866e-08
I2962 n1_M2_79980_4380 0 8.594297e-08
I2963 n1_M2_79980_5460 0 1.229083e-07
I2964 n1_M2_79980_7620 0 1.589889e-07
I2965 n1_M2_79980_9780 0 1.867566e-07
I2966 n1_M2_79980_11940 0 2.025551e-07
I2967 n1_M2_79980_14100 0 2.075305e-07
I2968 n1_M2_79980_16260 0 2.060279e-07
I2969 n1_M2_79980_18420 0 2.028528e-07
I2970 n1_M2_79980_19500 0 2.011932e-07
I2971 n1_M2_79980_21660 0 2.020157e-07
I2972 n1_M2_79980_23820 0 2.045492e-07
I2973 n1_M2_79980_25980 0 2.073263e-07
I2974 n1_M2_79980_28140 0 2.092435e-07
I2975 n1_M2_79980_30300 0 2.101246e-07
I2976 n1_M2_79980_32460 0 2.103292e-07
I2977 n1_M2_79980_33540 0 2.095411e-07
I2978 n1_M2_79980_35700 0 2.058070e-07
I2979 n1_M2_79980_37860 0 1.960276e-07
I2980 n1_M2_79980_40020 0 1.781241e-07
I2981 n1_M2_79980_42180 0 1.535191e-07
I2982 n1_M2_79980_44340 0 1.280123e-07
I2983 n1_M2_79980_46500 0 1.102982e-07
I2984 n1_M2_79980_47580 0 1.089948e-07
I2985 n1_M2_79980_49740 0 1.295471e-07
I2986 n1_M2_79980_51900 0 1.719085e-07
I2987 n1_M2_79980_54060 0 2.296762e-07
I2988 n1_M2_79980_56220 0 2.916027e-07
I2989 n1_M2_79980_58380 0 3.456301e-07
I2990 n1_M2_79980_59460 0 3.837410e-07
I2991 n1_M2_79980_61620 0 4.047030e-07
I2992 n1_M2_79980_63780 0 4.131175e-07
I2993 n1_M2_79980_65940 0 4.158852e-07
I2994 n1_M2_79980_68100 0 4.184770e-07
I2995 n1_M2_79980_70260 0 4.228642e-07
I2996 n1_M2_79980_72420 0 4.277639e-07
I2997 n1_M2_79980_73500 0 4.308679e-07
I2998 n1_M2_79980_75660 0 4.317215e-07
I2999 n1_M2_79980_77820 0 4.330186e-07
I3000 n1_M2_79980_79980 0 4.387154e-07
I3001 n1_M2_79980_82140 0 4.498521e-07
I3002 n1_M2_79980_84300 0 4.616544e-07
I3003 n1_M2_79980_86460 0 4.650962e-07
I3004 n1_M2_79980_87540 0 4.525966e-07
I3005 n1_M2_79980_89700 0 4.236362e-07
I3006 n1_M2_79980_91860 0 3.858587e-07
I3007 n1_M2_79980_94020 0 3.507716e-07
I3008 n1_M2_79980_96180 0 3.272471e-07
I3009 n1_M2_79980_98340 0 3.172373e-07
I3010 n1_M2_79980_100500 0 3.160605e-07
I3011 n1_M2_79980_101580 0 3.163665e-07
I3012 n1_M2_79980_103740 0 3.130447e-07
I3013 n1_M2_79980_105900 0 3.059784e-07
I3014 n1_M2_79980_108060 0 2.989925e-07
I3015 n1_M2_79980_110220 0 2.958967e-07
I3016 n1_M2_79980_112380 0 2.968382e-07
I3017 n1_M2_79980_113460 0 2.979273e-07
I3018 n1_M2_79980_115620 0 2.942840e-07
I3019 n1_M2_79980_117780 0 2.837179e-07
I3020 n1_M2_79980_119940 0 2.680977e-07
I3021 n1_M2_79980_122100 0 2.517912e-07
I3022 n1_M2_79980_124260 0 2.390197e-07
I3023 n1_M2_79980_126420 0 2.320504e-07
I3024 n1_M2_79980_127500 0 2.307478e-07
I3025 n1_M2_79980_129660 0 2.326985e-07
I3026 n1_M2_79980_131820 0 2.335156e-07
I3027 n1_M2_79980_133980 0 2.277653e-07
I3028 n1_M2_79980_136140 0 2.109326e-07
I3029 n1_M2_79980_138300 0 1.818598e-07
I3030 n1_M2_79980_140460 0 1.440471e-07
I3031 n1_M2_79980_141540 0 1.047945e-07
I3032 n1_M2_79980_143700 0 7.265221e-08
I3033 n1_M2_79980_145860 0 5.466490e-08
I3034 n1_M2_82140_60 0 3.854986e-08
I3035 n1_M2_82140_2220 0 5.423348e-08
I3036 n1_M2_82140_4380 0 8.272181e-08
I3037 n1_M2_82140_5460 0 1.181224e-07
I3038 n1_M2_82140_7620 0 1.525427e-07
I3039 n1_M2_82140_9780 0 1.788198e-07
I3040 n1_M2_82140_11940 0 1.935064e-07
I3041 n1_M2_82140_14100 0 1.978789e-07
I3042 n1_M2_82140_16260 0 1.963098e-07
I3043 n1_M2_82140_18420 0 1.934797e-07
I3044 n1_M2_82140_19500 0 1.923063e-07
I3045 n1_M2_82140_21660 0 1.934410e-07
I3046 n1_M2_82140_23820 0 1.958893e-07
I3047 n1_M2_82140_25980 0 1.981008e-07
I3048 n1_M2_82140_28140 0 1.989717e-07
I3049 n1_M2_82140_30300 0 1.983806e-07
I3050 n1_M2_82140_32460 0 1.969198e-07
I3051 n1_M2_82140_33540 0 1.948744e-07
I3052 n1_M2_82140_35700 0 1.912292e-07
I3053 n1_M2_82140_37860 0 1.837384e-07
I3054 n1_M2_82140_40020 0 1.704813e-07
I3055 n1_M2_82140_42180 0 1.520236e-07
I3056 n1_M2_82140_44340 0 1.325810e-07
I3057 n1_M2_82140_46500 0 1.192010e-07
I3058 n1_M2_82140_47580 0 1.193603e-07
I3059 n1_M2_82140_49740 0 1.380857e-07
I3060 n1_M2_82140_51900 0 1.756616e-07
I3061 n1_M2_82140_54060 0 2.267514e-07
I3062 n1_M2_82140_56220 0 2.817012e-07
I3063 n1_M2_82140_58380 0 3.299806e-07
I3064 n1_M2_82140_59460 0 3.643050e-07
I3065 n1_M2_82140_61620 0 3.831489e-07
I3066 n1_M2_82140_63780 0 3.903806e-07
I3067 n1_M2_82140_65940 0 3.926713e-07
I3068 n1_M2_82140_68100 0 3.961999e-07
I3069 n1_M2_82140_70260 0 4.040498e-07
I3070 n1_M2_82140_72420 0 4.153209e-07
I3071 n1_M2_82140_73500 0 4.265610e-07
I3072 n1_M2_82140_75660 0 4.348577e-07
I3073 n1_M2_82140_77820 0 4.402650e-07
I3074 n1_M2_82140_79980 0 4.451920e-07
I3075 n1_M2_82140_82140 0 4.508832e-07
I3076 n1_M2_82140_84300 0 4.543612e-07
I3077 n1_M2_82140_86460 0 4.492919e-07
I3078 n1_M2_82140_87540 0 4.307396e-07
I3079 n1_M2_82140_89700 0 3.998115e-07
I3080 n1_M2_82140_91860 0 3.641463e-07
I3081 n1_M2_82140_94020 0 3.337583e-07
I3082 n1_M2_82140_96180 0 3.154166e-07
I3083 n1_M2_82140_98340 0 3.094165e-07
I3084 n1_M2_82140_100500 0 3.105012e-07
I3085 n1_M2_82140_101580 0 3.118482e-07
I3086 n1_M2_82140_103740 0 3.095347e-07
I3087 n1_M2_82140_105900 0 3.046490e-07
I3088 n1_M2_82140_108060 0 3.016264e-07
I3089 n1_M2_82140_110220 0 3.039452e-07
I3090 n1_M2_82140_112380 0 3.105931e-07
I3091 n1_M2_82140_113460 0 3.162640e-07
I3092 n1_M2_82140_115620 0 3.150848e-07
I3093 n1_M2_82140_117780 0 3.046938e-07
I3094 n1_M2_82140_119940 0 2.875331e-07
I3095 n1_M2_82140_122100 0 2.689100e-07
I3096 n1_M2_82140_124260 0 2.539573e-07
I3097 n1_M2_82140_126420 0 2.455620e-07
I3098 n1_M2_82140_127500 0 2.437869e-07
I3099 n1_M2_82140_129660 0 2.459731e-07
I3100 n1_M2_82140_131820 0 2.471558e-07
I3101 n1_M2_82140_133980 0 2.412440e-07
I3102 n1_M2_82140_136140 0 2.233019e-07
I3103 n1_M2_82140_138300 0 1.921892e-07
I3104 n1_M2_82140_140460 0 1.518235e-07
I3105 n1_M2_82140_141540 0 1.100928e-07
I3106 n1_M2_82140_143700 0 7.605432e-08
I3107 n1_M2_82140_145860 0 5.705724e-08
I3108 n1_M2_84300_60 0 3.652138e-08
I3109 n1_M2_84300_2220 0 5.125669e-08
I3110 n1_M2_84300_4380 0 7.799456e-08
I3111 n1_M2_84300_5460 0 1.111592e-07
I3112 n1_M2_84300_7620 0 1.433009e-07
I3113 n1_M2_84300_9780 0 1.676830e-07
I3114 n1_M2_84300_11940 0 1.811091e-07
I3115 n1_M2_84300_14100 0 1.848768e-07
I3116 n1_M2_84300_16260 0 1.832068e-07
I3117 n1_M2_84300_18420 0 1.805405e-07
I3118 n1_M2_84300_19500 0 1.795458e-07
I3119 n1_M2_84300_21660 0 1.806848e-07
I3120 n1_M2_84300_23820 0 1.828982e-07
I3121 n1_M2_84300_25980 0 1.846951e-07
I3122 n1_M2_84300_28140 0 1.850851e-07
I3123 n1_M2_84300_30300 0 1.840566e-07
I3124 n1_M2_84300_32460 0 1.823770e-07
I3125 n1_M2_84300_33540 0 1.807317e-07
I3126 n1_M2_84300_35700 0 1.787561e-07
I3127 n1_M2_84300_37860 0 1.748208e-07
I3128 n1_M2_84300_40020 0 1.671027e-07
I3129 n1_M2_84300_42180 0 1.554412e-07
I3130 n1_M2_84300_44340 0 1.426783e-07
I3131 n1_M2_84300_46500 0 1.343743e-07
I3132 n1_M2_84300_47580 0 1.369190e-07
I3133 n1_M2_84300_49740 0 1.549180e-07
I3134 n1_M2_84300_51900 0 1.890186e-07
I3135 n1_M2_84300_54060 0 2.350685e-07
I3136 n1_M2_84300_56220 0 2.851661e-07
I3137 n1_M2_84300_58380 0 3.303530e-07
I3138 n1_M2_84300_59460 0 3.638422e-07
I3139 n1_M2_84300_61620 0 3.832814e-07
I3140 n1_M2_84300_63780 0 3.911804e-07
I3141 n1_M2_84300_65940 0 3.935487e-07
I3142 n1_M2_84300_68100 0 3.971669e-07
I3143 n1_M2_84300_70260 0 4.063455e-07
I3144 n1_M2_84300_72420 0 4.207364e-07
I3145 n1_M2_84300_73500 0 4.359271e-07
I3146 n1_M2_84300_75660 0 4.468473e-07
I3147 n1_M2_84300_77820 0 4.514255e-07
I3148 n1_M2_84300_79980 0 4.512278e-07
I3149 n1_M2_84300_82140 0 4.484479e-07
I3150 n1_M2_84300_84300 0 4.424710e-07
I3151 n1_M2_84300_86460 0 4.298178e-07
I3152 n1_M2_84300_87540 0 4.078275e-07
I3153 n1_M2_84300_89700 0 3.784187e-07
I3154 n1_M2_84300_91860 0 3.482689e-07
I3155 n1_M2_84300_94020 0 3.251491e-07
I3156 n1_M2_84300_96180 0 3.133980e-07
I3157 n1_M2_84300_98340 0 3.117647e-07
I3158 n1_M2_84300_100500 0 3.148375e-07
I3159 n1_M2_84300_101580 0 3.168563e-07
I3160 n1_M2_84300_103740 0 3.155380e-07
I3161 n1_M2_84300_105900 0 3.134101e-07
I3162 n1_M2_84300_108060 0 3.154988e-07
I3163 n1_M2_84300_110220 0 3.247297e-07
I3164 n1_M2_84300_112380 0 3.386007e-07
I3165 n1_M2_84300_113460 0 3.500481e-07
I3166 n1_M2_84300_115620 0 3.519361e-07
I3167 n1_M2_84300_117780 0 3.415916e-07
I3168 n1_M2_84300_119940 0 3.220303e-07
I3169 n1_M2_84300_122100 0 2.996078e-07
I3170 n1_M2_84300_124260 0 2.805207e-07
I3171 n1_M2_84300_126420 0 2.684184e-07
I3172 n1_M2_84300_127500 0 2.636885e-07
I3173 n1_M2_84300_129660 0 2.636089e-07
I3174 n1_M2_84300_131820 0 2.629398e-07
I3175 n1_M2_84300_133980 0 2.553011e-07
I3176 n1_M2_84300_136140 0 2.355649e-07
I3177 n1_M2_84300_138300 0 2.025065e-07
I3178 n1_M2_84300_140460 0 1.600722e-07
I3179 n1_M2_84300_141540 0 1.163207e-07
I3180 n1_M2_84300_143700 0 8.062113e-08
I3181 n1_M2_84300_145860 0 6.067521e-08
I3182 n1_M2_86460_60 0 3.411092e-08
I3183 n1_M2_86460_2220 0 4.775575e-08
I3184 n1_M2_86460_4380 0 7.248938e-08
I3185 n1_M2_86460_5460 0 1.031159e-07
I3186 n1_M2_86460_7620 0 1.327118e-07
I3187 n1_M2_86460_9780 0 1.550258e-07
I3188 n1_M2_86460_11940 0 1.671025e-07
I3189 n1_M2_86460_14100 0 1.701887e-07
I3190 n1_M2_86460_16260 0 1.682877e-07
I3191 n1_M2_86460_18420 0 1.656171e-07
I3192 n1_M2_86460_19500 0 1.646928e-07
I3193 n1_M2_86460_21660 0 1.658984e-07
I3194 n1_M2_86460_23820 0 1.681700e-07
I3195 n1_M2_86460_25980 0 1.700916e-07
I3196 n1_M2_86460_28140 0 1.708066e-07
I3197 n1_M2_86460_30300 0 1.704388e-07
I3198 n1_M2_86460_32460 0 1.698753e-07
I3199 n1_M2_86460_33540 0 1.699764e-07
I3200 n1_M2_86460_35700 0 1.706817e-07
I3201 n1_M2_86460_37860 0 1.707099e-07
I3202 n1_M2_86460_40020 0 1.683506e-07
I3203 n1_M2_86460_42180 0 1.630339e-07
I3204 n1_M2_86460_44340 0 1.566587e-07
I3205 n1_M2_86460_46500 0 1.536160e-07
I3206 n1_M2_86460_47580 0 1.593259e-07
I3207 n1_M2_86460_49740 0 1.779542e-07
I3208 n1_M2_86460_51900 0 2.104546e-07
I3209 n1_M2_86460_54060 0 2.537847e-07
I3210 n1_M2_86460_56220 0 3.016452e-07
I3211 n1_M2_86460_58380 0 3.463531e-07
I3212 n1_M2_86460_59460 0 3.811615e-07
I3213 n1_M2_86460_61620 0 4.023675e-07
I3214 n1_M2_86460_63780 0 4.107030e-07
I3215 n1_M2_86460_65940 0 4.113577e-07
I3216 n1_M2_86460_68100 0 4.118574e-07
I3217 n1_M2_86460_70260 0 4.181182e-07
I3218 n1_M2_86460_72420 0 4.308844e-07
I3219 n1_M2_86460_73500 0 4.454290e-07
I3220 n1_M2_86460_75660 0 4.551941e-07
I3221 n1_M2_86460_77820 0 4.565251e-07
I3222 n1_M2_86460_79980 0 4.504226e-07
I3223 n1_M2_86460_82140 0 4.400246e-07
I3224 n1_M2_86460_84300 0 4.268521e-07
I3225 n1_M2_86460_86460 0 4.098673e-07
I3226 n1_M2_86460_87540 0 3.880814e-07
I3227 n1_M2_86460_89700 0 3.635439e-07
I3228 n1_M2_86460_91860 0 3.414697e-07
I3229 n1_M2_86460_94020 0 3.272988e-07
I3230 n1_M2_86460_96180 0 3.232661e-07
I3231 n1_M2_86460_98340 0 3.270534e-07
I3232 n1_M2_86460_100500 0 3.333910e-07
I3233 n1_M2_86460_101580 0 3.375238e-07
I3234 n1_M2_86460_103740 0 3.384943e-07
I3235 n1_M2_86460_105900 0 3.399651e-07
I3236 n1_M2_86460_108060 0 3.474807e-07
I3237 n1_M2_86460_110220 0 3.635972e-07
I3238 n1_M2_86460_112380 0 3.846117e-07
I3239 n1_M2_86460_113460 0 4.019073e-07
I3240 n1_M2_86460_115620 0 4.070987e-07
I3241 n1_M2_86460_117780 0 3.970103e-07
I3242 n1_M2_86460_119940 0 3.749003e-07
I3243 n1_M2_86460_122100 0 3.478030e-07
I3244 n1_M2_86460_124260 0 3.226974e-07
I3245 n1_M2_86460_126420 0 3.039212e-07
I3246 n1_M2_86460_127500 0 2.923905e-07
I3247 n1_M2_86460_129660 0 2.858194e-07
I3248 n1_M2_86460_131820 0 2.794129e-07
I3249 n1_M2_86460_133980 0 2.672310e-07
I3250 n1_M2_86460_136140 0 2.443765e-07
I3251 n1_M2_86460_138300 0 2.094390e-07
I3252 n1_M2_86460_140460 0 1.658474e-07
I3253 n1_M2_86460_141540 0 1.211735e-07
I3254 n1_M2_86460_143700 0 8.464989e-08
I3255 n1_M2_86460_145860 0 6.417397e-08
I3256 n1_M2_87540_60 0 3.176050e-08
I3257 n1_M2_87540_2220 0 4.438598e-08
I3258 n1_M2_87540_4380 0 6.725973e-08
I3259 n1_M2_87540_5460 0 9.555690e-08
I3260 n1_M2_87540_7620 0 1.228491e-07
I3261 n1_M2_87540_9780 0 1.433113e-07
I3262 n1_M2_87540_11940 0 1.541594e-07
I3263 n1_M2_87540_14100 0 1.565458e-07
I3264 n1_M2_87540_16260 0 1.542779e-07
I3265 n1_M2_87540_18420 0 1.514514e-07
I3266 n1_M2_87540_19500 0 1.505661e-07
I3267 n1_M2_87540_21660 0 1.520202e-07
I3268 n1_M2_87540_23820 0 1.547455e-07
I3269 n1_M2_87540_25980 0 1.573387e-07
I3270 n1_M2_87540_28140 0 1.590234e-07
I3271 n1_M2_87540_30300 0 1.600386e-07
I3272 n1_M2_87540_32460 0 1.613360e-07
I3273 n1_M2_87540_33540 0 1.637710e-07
I3274 n1_M2_87540_35700 0 1.673063e-07
I3275 n1_M2_87540_37860 0 1.707995e-07
I3276 n1_M2_87540_40020 0 1.727080e-07
I3277 n1_M2_87540_42180 0 1.724100e-07
I3278 n1_M2_87540_44340 0 1.713456e-07
I3279 n1_M2_87540_46500 0 1.731298e-07
I3280 n1_M2_87540_47580 0 1.824119e-07
I3281 n1_M2_87540_49740 0 2.029558e-07
I3282 n1_M2_87540_51900 0 2.359460e-07
I3283 n1_M2_87540_54060 0 2.792360e-07
I3284 n1_M2_87540_56220 0 3.277198e-07
I3285 n1_M2_87540_58380 0 3.744127e-07
I3286 n1_M2_87540_59460 0 4.120022e-07
I3287 n1_M2_87540_61620 0 4.349786e-07
I3288 n1_M2_87540_63780 0 4.420962e-07
I3289 n1_M2_87540_65940 0 4.377844e-07
I3290 n1_M2_87540_68100 0 4.305938e-07
I3291 n1_M2_87540_70260 0 4.285457e-07
I3292 n1_M2_87540_72420 0 4.342415e-07
I3293 n1_M2_87540_73500 0 4.436265e-07
I3294 n1_M2_87540_75660 0 4.496130e-07
I3295 n1_M2_87540_77820 0 4.475061e-07
I3296 n1_M2_87540_79980 0 4.376207e-07
I3297 n1_M2_87540_82140 0 4.233551e-07
I3298 n1_M2_87540_84300 0 4.074552e-07
I3299 n1_M2_87540_86460 0 3.904930e-07
I3300 n1_M2_87540_87540 0 3.725251e-07
I3301 n1_M2_87540_89700 0 3.553940e-07
I3302 n1_M2_87540_91860 0 3.429469e-07
I3303 n1_M2_87540_94020 0 3.389152e-07
I3304 n1_M2_87540_96180 0 3.444088e-07
I3305 n1_M2_87540_98340 0 3.568687e-07
I3306 n1_M2_87540_100500 0 3.712376e-07
I3307 n1_M2_87540_101580 0 3.828184e-07
I3308 n1_M2_87540_103740 0 3.903984e-07
I3309 n1_M2_87540_105900 0 3.974307e-07
I3310 n1_M2_87540_108060 0 4.096539e-07
I3311 n1_M2_87540_110220 0 4.300971e-07
I3312 n1_M2_87540_112380 0 4.553147e-07
I3313 n1_M2_87540_113460 0 4.763900e-07
I3314 n1_M2_87540_115620 0 4.841866e-07
I3315 n1_M2_87540_117780 0 4.746919e-07
I3316 n1_M2_87540_119940 0 4.505255e-07
I3317 n1_M2_87540_122100 0 4.183994e-07
I3318 n1_M2_87540_124260 0 3.853486e-07
I3319 n1_M2_87540_126420 0 3.562104e-07
I3320 n1_M2_87540_127500 0 3.328277e-07
I3321 n1_M2_87540_129660 0 3.141927e-07
I3322 n1_M2_87540_131820 0 2.969599e-07
I3323 n1_M2_87540_133980 0 2.764792e-07
I3324 n1_M2_87540_136140 0 2.485091e-07
I3325 n1_M2_87540_138300 0 2.113388e-07
I3326 n1_M2_87540_140460 0 1.673435e-07
I3327 n1_M2_87540_141540 0 1.229302e-07
I3328 n1_M2_87540_143700 0 8.663572e-08
I3329 n1_M2_87540_145860 0 6.622288e-08
I3330 n1_M2_89700_60 0 2.988658e-08
I3331 n1_M2_89700_2220 0 4.175607e-08
I3332 n1_M2_89700_4380 0 6.327169e-08
I3333 n1_M2_89700_5460 0 8.990631e-08
I3334 n1_M2_89700_7620 0 1.155964e-07
I3335 n1_M2_89700_9780 0 1.347903e-07
I3336 n1_M2_89700_11940 0 1.447637e-07
I3337 n1_M2_89700_14100 0 1.465526e-07
I3338 n1_M2_89700_16260 0 1.438385e-07
I3339 n1_M2_89700_18420 0 1.407164e-07
I3340 n1_M2_89700_19500 0 1.397867e-07
I3341 n1_M2_89700_21660 0 1.415269e-07
I3342 n1_M2_89700_23820 0 1.448579e-07
I3343 n1_M2_89700_25980 0 1.483317e-07
I3344 n1_M2_89700_28140 0 1.511835e-07
I3345 n1_M2_89700_30300 0 1.537134e-07
I3346 n1_M2_89700_32460 0 1.568774e-07
I3347 n1_M2_89700_33540 0 1.614153e-07
I3348 n1_M2_89700_35700 0 1.671550e-07
I3349 n1_M2_89700_37860 0 1.729804e-07
I3350 n1_M2_89700_40020 0 1.775741e-07
I3351 n1_M2_89700_42180 0 1.805408e-07
I3352 n1_M2_89700_44340 0 1.832736e-07
I3353 n1_M2_89700_46500 0 1.890138e-07
I3354 n1_M2_89700_47580 0 2.019333e-07
I3355 n1_M2_89700_49740 0 2.255371e-07
I3356 n1_M2_89700_51900 0 2.611742e-07
I3357 n1_M2_89700_54060 0 3.072230e-07
I3358 n1_M2_89700_56220 0 3.590888e-07
I3359 n1_M2_89700_58380 0 4.096898e-07
I3360 n1_M2_89700_59460 0 4.505760e-07
I3361 n1_M2_89700_61620 0 4.742976e-07
I3362 n1_M2_89700_63780 0 4.778541e-07
I3363 n1_M2_89700_65940 0 4.652237e-07
I3364 n1_M2_89700_68100 0 4.462207e-07
I3365 n1_M2_89700_70260 0 4.312618e-07
I3366 n1_M2_89700_72420 0 4.254062e-07
I3367 n1_M2_89700_73500 0 4.262350e-07
I3368 n1_M2_89700_75660 0 4.271276e-07
I3369 n1_M2_89700_77820 0 4.228356e-07
I3370 n1_M2_89700_79980 0 4.126289e-07
I3371 n1_M2_89700_82140 0 3.991125e-07
I3372 n1_M2_89700_84300 0 3.850165e-07
I3373 n1_M2_89700_86460 0 3.715863e-07
I3374 n1_M2_89700_87540 0 3.595182e-07
I3375 n1_M2_89700_89700 0 3.506159e-07
I3376 n1_M2_89700_91860 0 3.481038e-07
I3377 n1_M2_89700_94020 0 3.552857e-07
I3378 n1_M2_89700_96180 0 3.736685e-07
I3379 n1_M2_89700_98340 0 4.015349e-07
I3380 n1_M2_89700_100500 0 4.338130e-07
I3381 n1_M2_89700_101580 0 4.638828e-07
I3382 n1_M2_89700_103740 0 4.871243e-07
I3383 n1_M2_89700_105900 0 5.040056e-07
I3384 n1_M2_89700_108060 0 5.196290e-07
I3385 n1_M2_89700_110220 0 5.390427e-07
I3386 n1_M2_89700_112380 0 5.619592e-07
I3387 n1_M2_89700_113460 0 5.817350e-07
I3388 n1_M2_89700_115620 0 5.895679e-07
I3389 n1_M2_89700_117780 0 5.801081e-07
I3390 n1_M2_89700_119940 0 5.539371e-07
I3391 n1_M2_89700_122100 0 5.159890e-07
I3392 n1_M2_89700_124260 0 4.724486e-07
I3393 n1_M2_89700_126420 0 4.285439e-07
I3394 n1_M2_89700_127500 0 3.876469e-07
I3395 n1_M2_89700_129660 0 3.510083e-07
I3396 n1_M2_89700_131820 0 3.176908e-07
I3397 n1_M2_89700_133980 0 2.849777e-07
I3398 n1_M2_89700_136140 0 2.495076e-07
I3399 n1_M2_89700_138300 0 2.091355e-07
I3400 n1_M2_89700_140460 0 1.648173e-07
I3401 n1_M2_89700_141540 0 1.213255e-07
I3402 n1_M2_89700_143700 0 8.602863e-08
I3403 n1_M2_89700_145860 0 6.617154e-08
I3404 n1_M2_91860_60 0 2.873347e-08
I3405 n1_M2_91860_2220 0 4.022866e-08
I3406 n1_M2_91860_4380 0 6.110560e-08
I3407 n1_M2_91860_5460 0 8.701637e-08
I3408 n1_M2_91860_7620 0 1.120644e-07
I3409 n1_M2_91860_9780 0 1.307588e-07
I3410 n1_M2_91860_11940 0 1.403069e-07
I3411 n1_M2_91860_14100 0 1.416358e-07
I3412 n1_M2_91860_16260 0 1.384033e-07
I3413 n1_M2_91860_18420 0 1.348144e-07
I3414 n1_M2_91860_19500 0 1.336370e-07
I3415 n1_M2_91860_21660 0 1.354538e-07
I3416 n1_M2_91860_23820 0 1.391833e-07
I3417 n1_M2_91860_25980 0 1.433241e-07
I3418 n1_M2_91860_28140 0 1.470867e-07
I3419 n1_M2_91860_30300 0 1.507715e-07
I3420 n1_M2_91860_32460 0 1.552734e-07
I3421 n1_M2_91860_33540 0 1.611617e-07
I3422 n1_M2_91860_35700 0 1.680827e-07
I3423 n1_M2_91860_37860 0 1.749194e-07
I3424 n1_M2_91860_40020 0 1.806134e-07
I3425 n1_M2_91860_42180 0 1.851384e-07
I3426 n1_M2_91860_44340 0 1.901045e-07
I3427 n1_M2_91860_46500 0 1.987323e-07
I3428 n1_M2_91860_47580 0 2.150851e-07
I3429 n1_M2_91860_49740 0 2.426692e-07
I3430 n1_M2_91860_51900 0 2.829452e-07
I3431 n1_M2_91860_54060 0 3.342793e-07
I3432 n1_M2_91860_56220 0 3.916362e-07
I3433 n1_M2_91860_58380 0 4.469103e-07
I3434 n1_M2_91860_59460 0 4.901835e-07
I3435 n1_M2_91860_61620 0 5.125393e-07
I3436 n1_M2_91860_63780 0 5.101038e-07
I3437 n1_M2_91860_65940 0 4.870256e-07
I3438 n1_M2_91860_68100 0 4.544236e-07
I3439 n1_M2_91860_70260 0 4.248582e-07
I3440 n1_M2_91860_72420 0 4.058566e-07
I3441 n1_M2_91860_73500 0 3.971580e-07
I3442 n1_M2_91860_75660 0 3.933363e-07
I3443 n1_M2_91860_77820 0 3.889230e-07
I3444 n1_M2_91860_79980 0 3.817107e-07
I3445 n1_M2_91860_82140 0 3.724639e-07
I3446 n1_M2_91860_84300 0 3.627752e-07
I3447 n1_M2_91860_86460 0 3.538954e-07
I3448 n1_M2_91860_87540 0 3.471900e-07
I3449 n1_M2_91860_89700 0 3.451328e-07
I3450 n1_M2_91860_91860 0 3.515893e-07
I3451 n1_M2_91860_94020 0 3.711173e-07
I3452 n1_M2_91860_96180 0 4.073960e-07
I3453 n1_M2_91860_98340 0 4.607070e-07
I3454 n1_M2_91860_100500 0 5.254900e-07
I3455 n1_M2_91860_101580 0 5.904589e-07
I3456 n1_M2_91860_103740 0 6.431834e-07
I3457 n1_M2_91860_105900 0 6.770813e-07
I3458 n1_M2_91860_108060 0 6.951259e-07
I3459 n1_M2_91860_110220 0 7.062532e-07
I3460 n1_M2_91860_112380 0 7.172564e-07
I3461 n1_M2_91860_113460 0 7.273759e-07
I3462 n1_M2_91860_115620 0 7.297765e-07
I3463 n1_M2_91860_117780 0 7.173370e-07
I3464 n1_M2_91860_119940 0 6.871239e-07
I3465 n1_M2_91860_122100 0 6.409031e-07
I3466 n1_M2_91860_124260 0 5.833233e-07
I3467 n1_M2_91860_126420 0 5.200834e-07
I3468 n1_M2_91860_127500 0 4.566589e-07
I3469 n1_M2_91860_129660 0 3.972445e-07
I3470 n1_M2_91860_131820 0 3.438021e-07
I3471 n1_M2_91860_133980 0 2.957378e-07
I3472 n1_M2_91860_136140 0 2.505381e-07
I3473 n1_M2_91860_138300 0 2.055302e-07
I3474 n1_M2_91860_140460 0 1.601624e-07
I3475 n1_M2_91860_141540 0 1.174400e-07
I3476 n1_M2_91860_143700 0 8.331788e-08
I3477 n1_M2_91860_145860 0 6.421589e-08
I3478 n1_M2_94020_60 0 2.832640e-08
I3479 n1_M2_94020_2220 0 3.985606e-08
I3480 n1_M2_94020_4380 0 6.086247e-08
I3481 n1_M2_94020_5460 0 8.704164e-08
I3482 n1_M2_94020_7620 0 1.124372e-07
I3483 n1_M2_94020_9780 0 1.313810e-07
I3484 n1_M2_94020_11940 0 1.408859e-07
I3485 n1_M2_94020_14100 0 1.418054e-07
I3486 n1_M2_94020_16260 0 1.379048e-07
I3487 n1_M2_94020_18420 0 1.336049e-07
I3488 n1_M2_94020_19500 0 1.318690e-07
I3489 n1_M2_94020_21660 0 1.333759e-07
I3490 n1_M2_94020_23820 0 1.370534e-07
I3491 n1_M2_94020_25980 0 1.413789e-07
I3492 n1_M2_94020_28140 0 1.455439e-07
I3493 n1_M2_94020_30300 0 1.498091e-07
I3494 n1_M2_94020_32460 0 1.549577e-07
I3495 n1_M2_94020_33540 0 1.613706e-07
I3496 n1_M2_94020_35700 0 1.685286e-07
I3497 n1_M2_94020_37860 0 1.753262e-07
I3498 n1_M2_94020_40020 0 1.809478e-07
I3499 n1_M2_94020_42180 0 1.857270e-07
I3500 n1_M2_94020_44340 0 1.915690e-07
I3501 n1_M2_94020_46500 0 2.019116e-07
I3502 n1_M2_94020_47580 0 2.210857e-07
I3503 n1_M2_94020_49740 0 2.529397e-07
I3504 n1_M2_94020_51900 0 2.990425e-07
I3505 n1_M2_94020_54060 0 3.571615e-07
I3506 n1_M2_94020_56220 0 4.207893e-07
I3507 n1_M2_94020_58380 0 4.799389e-07
I3508 n1_M2_94020_59460 0 5.232640e-07
I3509 n1_M2_94020_61620 0 5.414753e-07
I3510 n1_M2_94020_63780 0 5.312892e-07
I3511 n1_M2_94020_65940 0 4.978595e-07
I3512 n1_M2_94020_68100 0 4.533659e-07
I3513 n1_M2_94020_70260 0 4.116256e-07
I3514 n1_M2_94020_72420 0 3.819120e-07
I3515 n1_M2_94020_73500 0 3.660052e-07
I3516 n1_M2_94020_75660 0 3.599348e-07
I3517 n1_M2_94020_77820 0 3.581016e-07
I3518 n1_M2_94020_79980 0 3.564012e-07
I3519 n1_M2_94020_82140 0 3.529694e-07
I3520 n1_M2_94020_84300 0 3.475714e-07
I3521 n1_M2_94020_86460 0 3.413006e-07
I3522 n1_M2_94020_87540 0 3.367238e-07
I3523 n1_M2_94020_89700 0 3.381027e-07
I3524 n1_M2_94020_91860 0 3.514229e-07
I3525 n1_M2_94020_94020 0 3.841386e-07
I3526 n1_M2_94020_96180 0 4.436468e-07
I3527 n1_M2_94020_98340 0 5.331447e-07
I3528 n1_M2_94020_100500 0 6.460116e-07
I3529 n1_M2_94020_101580 0 7.635727e-07
I3530 n1_M2_94020_103740 0 8.611376e-07
I3531 n1_M2_94020_105900 0 9.207287e-07
I3532 n1_M2_94020_108060 0 9.412181e-07
I3533 n1_M2_94020_110220 0 9.368260e-07
I3534 n1_M2_94020_112380 0 9.251024e-07
I3535 n1_M2_94020_113460 0 9.148542e-07
I3536 n1_M2_94020_115620 0 9.032021e-07
I3537 n1_M2_94020_117780 0 8.813842e-07
I3538 n1_M2_94020_119940 0 8.421638e-07
I3539 n1_M2_94020_122100 0 7.834311e-07
I3540 n1_M2_94020_124260 0 7.080811e-07
I3541 n1_M2_94020_126420 0 6.224028e-07
I3542 n1_M2_94020_127500 0 5.340972e-07
I3543 n1_M2_94020_129660 0 4.502159e-07
I3544 n1_M2_94020_131820 0 3.753401e-07
I3545 n1_M2_94020_133980 0 3.106788e-07
I3546 n1_M2_94020_136140 0 2.543868e-07
I3547 n1_M2_94020_138300 0 2.033263e-07
I3548 n1_M2_94020_140460 0 1.556764e-07
I3549 n1_M2_94020_141540 0 1.128938e-07
I3550 n1_M2_94020_143700 0 7.954777e-08
I3551 n1_M2_94020_145860 0 6.108177e-08
I3552 n1_M2_96180_60 0 2.850876e-08
I3553 n1_M2_96180_2220 0 4.042263e-08
I3554 n1_M2_96180_4380 0 6.221945e-08
I3555 n1_M2_96180_5460 0 8.952377e-08
I3556 n1_M2_96180_7620 0 1.161152e-07
I3557 n1_M2_96180_9780 0 1.359290e-07
I3558 n1_M2_96180_11940 0 1.456655e-07
I3559 n1_M2_96180_14100 0 1.461442e-07
I3560 n1_M2_96180_16260 0 1.413677e-07
I3561 n1_M2_96180_18420 0 1.360734e-07
I3562 n1_M2_96180_19500 0 1.334378e-07
I3563 n1_M2_96180_21660 0 1.342151e-07
I3564 n1_M2_96180_23820 0 1.373481e-07
I3565 n1_M2_96180_25980 0 1.413323e-07
I3566 n1_M2_96180_28140 0 1.453725e-07
I3567 n1_M2_96180_30300 0 1.496925e-07
I3568 n1_M2_96180_32460 0 1.549583e-07
I3569 n1_M2_96180_33540 0 1.613814e-07
I3570 n1_M2_96180_35700 0 1.683124e-07
I3571 n1_M2_96180_37860 0 1.746523e-07
I3572 n1_M2_96180_40020 0 1.797333e-07
I3573 n1_M2_96180_42180 0 1.840831e-07
I3574 n1_M2_96180_44340 0 1.897781e-07
I3575 n1_M2_96180_46500 0 2.005256e-07
I3576 n1_M2_96180_47580 0 2.211872e-07
I3577 n1_M2_96180_49740 0 2.562825e-07
I3578 n1_M2_96180_51900 0 3.075823e-07
I3579 n1_M2_96180_54060 0 3.718951e-07
I3580 n1_M2_96180_56220 0 4.405643e-07
I3581 n1_M2_96180_58380 0 5.012972e-07
I3582 n1_M2_96180_59460 0 5.417566e-07
I3583 n1_M2_96180_61620 0 5.536149e-07
I3584 n1_M2_96180_63780 0 5.356756e-07
I3585 n1_M2_96180_65940 0 4.947741e-07
I3586 n1_M2_96180_68100 0 4.436241e-07
I3587 n1_M2_96180_70260 0 3.960580e-07
I3588 n1_M2_96180_72420 0 3.619677e-07
I3589 n1_M2_96180_73500 0 3.446035e-07
I3590 n1_M2_96180_75660 0 3.412534e-07
I3591 n1_M2_96180_77820 0 3.459223e-07
I3592 n1_M2_96180_79980 0 3.520765e-07
I3593 n1_M2_96180_82140 0 3.546265e-07
I3594 n1_M2_96180_84300 0 3.512535e-07
I3595 n1_M2_96180_86460 0 3.432472e-07
I3596 n1_M2_96180_87540 0 3.353546e-07
I3597 n1_M2_96180_89700 0 3.349789e-07
I3598 n1_M2_96180_91860 0 3.516018e-07
I3599 n1_M2_96180_94020 0 3.967060e-07
I3600 n1_M2_96180_96180 0 4.821541e-07
I3601 n1_M2_96180_98340 0 6.143148e-07
I3602 n1_M2_96180_100500 0 7.849953e-07
I3603 n1_M2_96180_101580 0 9.665249e-07
I3604 n1_M2_96180_103740 0 1.119316e-06
I3605 n1_M2_96180_105900 0 1.211134e-06
I3606 n1_M2_96180_108060 0 1.234920e-06
I3607 n1_M2_96180_110220 0 1.210207e-06
I3608 n1_M2_96180_112380 0 1.166983e-06
I3609 n1_M2_96180_113460 0 1.125943e-06
I3610 n1_M2_96180_115620 0 1.090112e-06
I3611 n1_M2_96180_117780 0 1.050273e-06
I3612 n1_M2_96180_119940 0 9.954944e-07
I3613 n1_M2_96180_122100 0 9.201316e-07
I3614 n1_M2_96180_124260 0 8.254720e-07
I3615 n1_M2_96180_126420 0 7.181790e-07
I3616 n1_M2_96180_127500 0 6.074779e-07
I3617 n1_M2_96180_129660 0 5.022252e-07
I3618 n1_M2_96180_131820 0 4.085869e-07
I3619 n1_M2_96180_133980 0 3.288965e-07
I3620 n1_M2_96180_136140 0 2.618055e-07
I3621 n1_M2_96180_138300 0 2.040015e-07
I3622 n1_M2_96180_140460 0 1.529354e-07
I3623 n1_M2_96180_141540 0 1.090297e-07
I3624 n1_M2_96180_143700 0 7.574890e-08
I3625 n1_M2_96180_145860 0 5.759455e-08
I3626 n1_M2_98340_60 0 2.900176e-08
I3627 n1_M2_98340_2220 0 4.151421e-08
I3628 n1_M2_98340_4380 0 6.451728e-08
I3629 n1_M2_98340_5460 0 9.350795e-08
I3630 n1_M2_98340_7620 0 1.218840e-07
I3631 n1_M2_98340_9780 0 1.430426e-07
I3632 n1_M2_98340_11940 0 1.532784e-07
I3633 n1_M2_98340_14100 0 1.533748e-07
I3634 n1_M2_98340_16260 0 1.476331e-07
I3635 n1_M2_98340_18420 0 1.411641e-07
I3636 n1_M2_98340_19500 0 1.373771e-07
I3637 n1_M2_98340_21660 0 1.371015e-07
I3638 n1_M2_98340_23820 0 1.393072e-07
I3639 n1_M2_98340_25980 0 1.425406e-07
I3640 n1_M2_98340_28140 0 1.460626e-07
I3641 n1_M2_98340_30300 0 1.501091e-07
I3642 n1_M2_98340_32460 0 1.552900e-07
I3643 n1_M2_98340_33540 0 1.617159e-07
I3644 n1_M2_98340_35700 0 1.686463e-07
I3645 n1_M2_98340_37860 0 1.749350e-07
I3646 n1_M2_98340_40020 0 1.798710e-07
I3647 n1_M2_98340_42180 0 1.838649e-07
I3648 n1_M2_98340_44340 0 1.888503e-07
I3649 n1_M2_98340_46500 0 1.986223e-07
I3650 n1_M2_98340_47580 0 2.185961e-07
I3651 n1_M2_98340_49740 0 2.541357e-07
I3652 n1_M2_98340_51900 0 3.074058e-07
I3653 n1_M2_98340_54060 0 3.743894e-07
I3654 n1_M2_98340_56220 0 4.444399e-07
I3655 n1_M2_98340_58380 0 5.033629e-07
I3656 n1_M2_98340_59460 0 5.386311e-07
I3657 n1_M2_98340_61620 0 5.439094e-07
I3658 n1_M2_98340_63780 0 5.208696e-07
I3659 n1_M2_98340_65940 0 4.780872e-07
I3660 n1_M2_98340_68100 0 4.280955e-07
I3661 n1_M2_98340_70260 0 3.836917e-07
I3662 n1_M2_98340_72420 0 3.545162e-07
I3663 n1_M2_98340_73500 0 3.447468e-07
I3664 n1_M2_98340_75660 0 3.524248e-07
I3665 n1_M2_98340_77820 0 3.703549e-07
I3666 n1_M2_98340_79980 0 3.885003e-07
I3667 n1_M2_98340_82140 0 3.976416e-07
I3668 n1_M2_98340_84300 0 3.931551e-07
I3669 n1_M2_98340_86460 0 3.772140e-07
I3670 n1_M2_98340_87540 0 3.581648e-07
I3671 n1_M2_98340_89700 0 3.481916e-07
I3672 n1_M2_98340_91860 0 3.615111e-07
I3673 n1_M2_98340_94020 0 4.140348e-07
I3674 n1_M2_98340_96180 0 5.216529e-07
I3675 n1_M2_98340_98340 0 6.931484e-07
I3676 n1_M2_98340_100500 0 9.183980e-07
I3677 n1_M2_98340_101580 0 1.161143e-06
I3678 n1_M2_98340_103740 0 1.367708e-06
I3679 n1_M2_98340_105900 0 1.491898e-06
I3680 n1_M2_98340_108060 0 1.519819e-06
I3681 n1_M2_98340_110220 0 1.474463e-06
I3682 n1_M2_98340_112380 0 1.396602e-06
I3683 n1_M2_98340_113460 0 1.318530e-06
I3684 n1_M2_98340_115620 0 1.250538e-06
I3685 n1_M2_98340_117780 0 1.185253e-06
I3686 n1_M2_98340_119940 0 1.110212e-06
I3687 n1_M2_98340_122100 0 1.017508e-06
I3688 n1_M2_98340_124260 0 9.069596e-07
I3689 n1_M2_98340_126420 0 7.847280e-07
I3690 n1_M2_98340_127500 0 6.600122e-07
I3691 n1_M2_98340_129660 0 5.417465e-07
I3692 n1_M2_98340_131820 0 4.362856e-07
I3693 n1_M2_98340_133980 0 3.463293e-07
I3694 n1_M2_98340_136140 0 2.709481e-07
I3695 n1_M2_98340_138300 0 2.071101e-07
I3696 n1_M2_98340_140460 0 1.522564e-07
I3697 n1_M2_98340_141540 0 1.064748e-07
I3698 n1_M2_98340_143700 0 7.260095e-08
I3699 n1_M2_98340_145860 0 5.440453e-08
I3700 n1_M2_100500_60 0 2.948298e-08
I3701 n1_M2_100500_2220 0 4.262093e-08
I3702 n1_M2_100500_4380 0 6.690120e-08
I3703 n1_M2_100500_5460 0 9.771990e-08
I3704 n1_M2_100500_7620 0 1.281139e-07
I3705 n1_M2_100500_9780 0 1.509394e-07
I3706 n1_M2_100500_11940 0 1.620474e-07
I3707 n1_M2_100500_14100 0 1.621140e-07
I3708 n1_M2_100500_16260 0 1.556608e-07
I3709 n1_M2_100500_18420 0 1.481221e-07
I3710 n1_M2_100500_19500 0 1.431396e-07
I3711 n1_M2_100500_21660 0 1.416587e-07
I3712 n1_M2_100500_23820 0 1.427287e-07
I3713 n1_M2_100500_25980 0 1.449920e-07
I3714 n1_M2_100500_28140 0 1.478143e-07
I3715 n1_M2_100500_30300 0 1.515222e-07
I3716 n1_M2_100500_32460 0 1.567822e-07
I3717 n1_M2_100500_33540 0 1.637198e-07
I3718 n1_M2_100500_35700 0 1.715519e-07
I3719 n1_M2_100500_37860 0 1.789934e-07
I3720 n1_M2_100500_40020 0 1.850235e-07
I3721 n1_M2_100500_42180 0 1.895311e-07
I3722 n1_M2_100500_44340 0 1.938666e-07
I3723 n1_M2_100500_46500 0 2.015295e-07
I3724 n1_M2_100500_47580 0 2.182193e-07
I3725 n1_M2_100500_49740 0 2.500422e-07
I3726 n1_M2_100500_51900 0 2.997521e-07
I3727 n1_M2_100500_54060 0 3.631649e-07
I3728 n1_M2_100500_56220 0 4.287844e-07
I3729 n1_M2_100500_58380 0 4.818666e-07
I3730 n1_M2_100500_59460 0 5.107721e-07
I3731 n1_M2_100500_61620 0 5.115654e-07
I3732 n1_M2_100500_63780 0 4.884884e-07
I3733 n1_M2_100500_65940 0 4.511572e-07
I3734 n1_M2_100500_68100 0 4.112576e-07
I3735 n1_M2_100500_70260 0 3.802167e-07
I3736 n1_M2_100500_72420 0 3.674153e-07
I3737 n1_M2_100500_73500 0 3.779015e-07
I3738 n1_M2_100500_75660 0 4.097985e-07
I3739 n1_M2_100500_77820 0 4.530895e-07
I3740 n1_M2_100500_79980 0 4.919571e-07
I3741 n1_M2_100500_82140 0 5.110104e-07
I3742 n1_M2_100500_84300 0 5.024877e-07
I3743 n1_M2_100500_86460 0 4.702450e-07
I3744 n1_M2_100500_87540 0 4.282937e-07
I3745 n1_M2_100500_89700 0 3.959434e-07
I3746 n1_M2_100500_91860 0 3.936450e-07
I3747 n1_M2_100500_94020 0 4.416617e-07
I3748 n1_M2_100500_96180 0 5.583945e-07
I3749 n1_M2_100500_98340 0 7.532878e-07
I3750 n1_M2_100500_100500 0 1.014082e-06
I3751 n1_M2_100500_101580 0 1.298421e-06
I3752 n1_M2_100500_103740 0 1.542995e-06
I3753 n1_M2_100500_105900 0 1.691428e-06
I3754 n1_M2_100500_108060 0 1.723388e-06
I3755 n1_M2_100500_110220 0 1.661899e-06
I3756 n1_M2_100500_112380 0 1.553634e-06
I3757 n1_M2_100500_113460 0 1.439417e-06
I3758 n1_M2_100500_115620 0 1.337153e-06
I3759 n1_M2_100500_117780 0 1.244117e-06
I3760 n1_M2_100500_119940 0 1.149381e-06
I3761 n1_M2_100500_122100 0 1.044415e-06
I3762 n1_M2_100500_124260 0 9.273690e-07
I3763 n1_M2_100500_126420 0 8.023984e-07
I3764 n1_M2_100500_127500 0 6.766971e-07
I3765 n1_M2_100500_129660 0 5.575042e-07
I3766 n1_M2_100500_131820 0 4.501630e-07
I3767 n1_M2_100500_133980 0 3.571863e-07
I3768 n1_M2_100500_136140 0 2.780818e-07
I3769 n1_M2_100500_138300 0 2.105523e-07
I3770 n1_M2_100500_140460 0 1.527218e-07
I3771 n1_M2_100500_141540 0 1.050549e-07
I3772 n1_M2_100500_143700 0 7.031235e-08
I3773 n1_M2_100500_145860 0 5.186426e-08
I3774 n1_M2_101580_60 0 2.970281e-08
I3775 n1_M2_101580_2220 0 4.330966e-08
I3776 n1_M2_101580_4380 0 6.858846e-08
I3777 n1_M2_101580_5460 0 1.009310e-07
I3778 n1_M2_101580_7620 0 1.331745e-07
I3779 n1_M2_101580_9780 0 1.577944e-07
I3780 n1_M2_101580_11940 0 1.702444e-07
I3781 n1_M2_101580_14100 0 1.709691e-07
I3782 n1_M2_101580_16260 0 1.644800e-07
I3783 n1_M2_101580_18420 0 1.563431e-07
I3784 n1_M2_101580_19500 0 1.503824e-07
I3785 n1_M2_101580_21660 0 1.477345e-07
I3786 n1_M2_101580_23820 0 1.476419e-07
I3787 n1_M2_101580_25980 0 1.489287e-07
I3788 n1_M2_101580_28140 0 1.511272e-07
I3789 n1_M2_101580_30300 0 1.547324e-07
I3790 n1_M2_101580_32460 0 1.605876e-07
I3791 n1_M2_101580_33540 0 1.689633e-07
I3792 n1_M2_101580_35700 0 1.790905e-07
I3793 n1_M2_101580_37860 0 1.894401e-07
I3794 n1_M2_101580_40020 0 1.983932e-07
I3795 n1_M2_101580_42180 0 2.049115e-07
I3796 n1_M2_101580_44340 0 2.093310e-07
I3797 n1_M2_101580_46500 0 2.144180e-07
I3798 n1_M2_101580_47580 0 2.256944e-07
I3799 n1_M2_101580_49740 0 2.496322e-07
I3800 n1_M2_101580_51900 0 2.896298e-07
I3801 n1_M2_101580_54060 0 3.422172e-07
I3802 n1_M2_101580_56220 0 3.967664e-07
I3803 n1_M2_101580_58380 0 4.399044e-07
I3804 n1_M2_101580_59460 0 4.620567e-07
I3805 n1_M2_101580_61620 0 4.615858e-07
I3806 n1_M2_101580_63780 0 4.442700e-07
I3807 n1_M2_101580_65940 0 4.197197e-07
I3808 n1_M2_101580_68100 0 3.984746e-07
I3809 n1_M2_101580_70260 0 3.911714e-07
I3810 n1_M2_101580_72420 0 4.079121e-07
I3811 n1_M2_101580_73500 0 4.551489e-07
I3812 n1_M2_101580_75660 0 5.302819e-07
I3813 n1_M2_101580_77820 0 6.178671e-07
I3814 n1_M2_101580_79980 0 6.923885e-07
I3815 n1_M2_101580_82140 0 7.285367e-07
I3816 n1_M2_101580_84300 0 7.135430e-07
I3817 n1_M2_101580_86460 0 6.537970e-07
I3818 n1_M2_101580_87540 0 5.719573e-07
I3819 n1_M2_101580_89700 0 4.979299e-07
I3820 n1_M2_101580_91860 0 4.606150e-07
I3821 n1_M2_101580_94020 0 4.846081e-07
I3822 n1_M2_101580_96180 0 5.888788e-07
I3823 n1_M2_101580_98340 0 7.813345e-07
I3824 n1_M2_101580_100500 0 1.047498e-06
I3825 n1_M2_101580_101580 0 1.342491e-06
I3826 n1_M2_101580_103740 0 1.599697e-06
I3827 n1_M2_101580_105900 0 1.758212e-06
I3828 n1_M2_101580_108060 0 1.792599e-06
I3829 n1_M2_101580_110220 0 1.722087e-06
I3830 n1_M2_101580_112380 0 1.593044e-06
I3831 n1_M2_101580_113460 0 1.450307e-06
I3832 n1_M2_101580_115620 0 1.318700e-06
I3833 n1_M2_101580_117780 0 1.202382e-06
I3834 n1_M2_101580_119940 0 1.094655e-06
I3835 n1_M2_101580_122100 0 9.876326e-07
I3836 n1_M2_101580_124260 0 8.772451e-07
I3837 n1_M2_101580_126420 0 7.640101e-07
I3838 n1_M2_101580_127500 0 6.514001e-07
I3839 n1_M2_101580_129660 0 5.437556e-07
I3840 n1_M2_101580_131820 0 4.447942e-07
I3841 n1_M2_101580_133980 0 3.566405e-07
I3842 n1_M2_101580_136140 0 2.793157e-07
I3843 n1_M2_101580_138300 0 2.115628e-07
I3844 n1_M2_101580_140460 0 1.526581e-07
I3845 n1_M2_101580_141540 0 1.039640e-07
I3846 n1_M2_101580_143700 0 6.863320e-08
I3847 n1_M2_101580_145860 0 4.998018e-08
I3848 n1_M2_103740_60 0 2.964902e-08
I3849 n1_M2_103740_2220 0 4.347861e-08
I3850 n1_M2_103740_4380 0 6.928654e-08
I3851 n1_M2_103740_5460 0 1.025681e-07
I3852 n1_M2_103740_7620 0 1.361898e-07
I3853 n1_M2_103740_9780 0 1.625145e-07
I3854 n1_M2_103740_11940 0 1.767325e-07
I3855 n1_M2_103740_14100 0 1.789395e-07
I3856 n1_M2_103740_16260 0 1.733297e-07
I3857 n1_M2_103740_18420 0 1.653116e-07
I3858 n1_M2_103740_19500 0 1.587830e-07
I3859 n1_M2_103740_21660 0 1.551506e-07
I3860 n1_M2_103740_23820 0 1.540085e-07
I3861 n1_M2_103740_25980 0 1.544965e-07
I3862 n1_M2_103740_28140 0 1.563963e-07
I3863 n1_M2_103740_30300 0 1.604366e-07
I3864 n1_M2_103740_32460 0 1.677231e-07
I3865 n1_M2_103740_33540 0 1.787656e-07
I3866 n1_M2_103740_35700 0 1.928316e-07
I3867 n1_M2_103740_37860 0 2.080186e-07
I3868 n1_M2_103740_40020 0 2.218390e-07
I3869 n1_M2_103740_42180 0 2.320282e-07
I3870 n1_M2_103740_44340 0 2.376644e-07
I3871 n1_M2_103740_46500 0 2.405208e-07
I3872 n1_M2_103740_47580 0 2.455306e-07
I3873 n1_M2_103740_49740 0 2.590300e-07
I3874 n1_M2_103740_51900 0 2.848841e-07
I3875 n1_M2_103740_54060 0 3.209834e-07
I3876 n1_M2_103740_56220 0 3.591036e-07
I3877 n1_M2_103740_58380 0 3.890076e-07
I3878 n1_M2_103740_59460 0 4.042016e-07
I3879 n1_M2_103740_61620 0 4.051324e-07
I3880 n1_M2_103740_63780 0 3.981382e-07
I3881 n1_M2_103740_65940 0 3.920944e-07
I3882 n1_M2_103740_68100 0 3.966117e-07
I3883 n1_M2_103740_70260 0 4.226660e-07
I3884 n1_M2_103740_72420 0 4.825010e-07
I3885 n1_M2_103740_73500 0 5.847495e-07
I3886 n1_M2_103740_75660 0 7.252050e-07
I3887 n1_M2_103740_77820 0 8.798314e-07
I3888 n1_M2_103740_79980 0 1.008459e-06
I3889 n1_M2_103740_82140 0 1.070968e-06
I3890 n1_M2_103740_84300 0 1.047055e-06
I3891 n1_M2_103740_86460 0 9.466429e-07
I3892 n1_M2_103740_87540 0 8.047217e-07
I3893 n1_M2_103740_89700 0 6.659901e-07
I3894 n1_M2_103740_91860 0 5.704644e-07
I3895 n1_M2_103740_94020 0 5.473539e-07
I3896 n1_M2_103740_96180 0 6.146450e-07
I3897 n1_M2_103740_98340 0 7.769506e-07
I3898 n1_M2_103740_100500 0 1.017651e-06
I3899 n1_M2_103740_101580 0 1.292478e-06
I3900 n1_M2_103740_103740 0 1.536918e-06
I3901 n1_M2_103740_105900 0 1.690432e-06
I3902 n1_M2_103740_108060 0 1.723936e-06
I3903 n1_M2_103740_110220 0 1.650190e-06
I3904 n1_M2_103740_112380 0 1.510490e-06
I3905 n1_M2_103740_113460 0 1.349826e-06
I3906 n1_M2_103740_115620 0 1.198592e-06
I3907 n1_M2_103740_117780 0 1.068481e-06
I3908 n1_M2_103740_119940 0 9.581199e-07
I3909 n1_M2_103740_122100 0 8.606179e-07
I3910 n1_M2_103740_124260 0 7.690983e-07
I3911 n1_M2_103740_126420 0 6.794300e-07
I3912 n1_M2_103740_127500 0 5.905596e-07
I3913 n1_M2_103740_129660 0 5.035987e-07
I3914 n1_M2_103740_131820 0 4.206312e-07
I3915 n1_M2_103740_133980 0 3.434620e-07
I3916 n1_M2_103740_136140 0 2.726891e-07
I3917 n1_M2_103740_138300 0 2.081908e-07
I3918 n1_M2_103740_140460 0 1.505556e-07
I3919 n1_M2_103740_141540 0 1.022519e-07
I3920 n1_M2_103740_143700 0 6.706533e-08
I3921 n1_M2_103740_145860 0 4.849332e-08
I3922 n1_M2_105900_60 0 2.964013e-08
I3923 n1_M2_105900_2220 0 4.351875e-08
I3924 n1_M2_105900_4380 0 6.948662e-08
I3925 n1_M2_105900_5460 0 1.031807e-07
I3926 n1_M2_105900_7620 0 1.376673e-07
I3927 n1_M2_105900_9780 0 1.654540e-07
I3928 n1_M2_105900_11940 0 1.816493e-07
I3929 n1_M2_105900_14100 0 1.859590e-07
I3930 n1_M2_105900_16260 0 1.820157e-07
I3931 n1_M2_105900_18420 0 1.747951e-07
I3932 n1_M2_105900_19500 0 1.681318e-07
I3933 n1_M2_105900_21660 0 1.637454e-07
I3934 n1_M2_105900_23820 0 1.617278e-07
I3935 n1_M2_105900_25980 0 1.616866e-07
I3936 n1_M2_105900_28140 0 1.637588e-07
I3937 n1_M2_105900_30300 0 1.689700e-07
I3938 n1_M2_105900_32460 0 1.787333e-07
I3939 n1_M2_105900_33540 0 1.938117e-07
I3940 n1_M2_105900_35700 0 2.134314e-07
I3941 n1_M2_105900_37860 0 2.351114e-07
I3942 n1_M2_105900_40020 0 2.552500e-07
I3943 n1_M2_105900_42180 0 2.702458e-07
I3944 n1_M2_105900_44340 0 2.780104e-07
I3945 n1_M2_105900_46500 0 2.794455e-07
I3946 n1_M2_105900_47580 0 2.787760e-07
I3947 n1_M2_105900_49740 0 2.817900e-07
I3948 n1_M2_105900_51900 0 2.924357e-07
I3949 n1_M2_105900_54060 0 3.100653e-07
I3950 n1_M2_105900_56220 0 3.296002e-07
I3951 n1_M2_105900_58380 0 3.449371e-07
I3952 n1_M2_105900_59460 0 3.533086e-07
I3953 n1_M2_105900_61620 0 3.572617e-07
I3954 n1_M2_105900_63780 0 3.633694e-07
I3955 n1_M2_105900_65940 0 3.796569e-07
I3956 n1_M2_105900_68100 0 4.151650e-07
I3957 n1_M2_105900_70260 0 4.819211e-07
I3958 n1_M2_105900_72420 0 5.950829e-07
I3959 n1_M2_105900_73500 0 7.658831e-07
I3960 n1_M2_105900_75660 0 9.879231e-07
I3961 n1_M2_105900_77820 0 1.226328e-06
I3962 n1_M2_105900_79980 0 1.422501e-06
I3963 n1_M2_105900_82140 0 1.517661e-06
I3964 n1_M2_105900_84300 0 1.482074e-06
I3965 n1_M2_105900_86460 0 1.330245e-06
I3966 n1_M2_105900_87540 0 1.112559e-06
I3967 n1_M2_105900_89700 0 8.915856e-07
I3968 n1_M2_105900_91860 0 7.201029e-07
I3969 n1_M2_105900_94020 0 6.320000e-07
I3970 n1_M2_105900_96180 0 6.435460e-07
I3971 n1_M2_105900_98340 0 7.554956e-07
I3972 n1_M2_105900_100500 0 9.494954e-07
I3973 n1_M2_105900_101580 0 1.183607e-06
I3974 n1_M2_105900_103740 0 1.398022e-06
I3975 n1_M2_105900_105900 0 1.534983e-06
I3976 n1_M2_105900_108060 0 1.562895e-06
I3977 n1_M2_105900_110220 0 1.487592e-06
I3978 n1_M2_105900_112380 0 1.343760e-06
I3979 n1_M2_105900_113460 0 1.174696e-06
I3980 n1_M2_105900_115620 0 1.014693e-06
I3981 n1_M2_105900_117780 0 8.816318e-07
I3982 n1_M2_105900_119940 0 7.784848e-07
I3983 n1_M2_105900_122100 0 6.988019e-07
I3984 n1_M2_105900_124260 0 6.327543e-07
I3985 n1_M2_105900_126420 0 5.717663e-07
I3986 n1_M2_105900_127500 0 5.106976e-07
I3987 n1_M2_105900_129660 0 4.479062e-07
I3988 n1_M2_105900_131820 0 3.841431e-07
I3989 n1_M2_105900_133980 0 3.209579e-07
I3990 n1_M2_105900_136140 0 2.594534e-07
I3991 n1_M2_105900_138300 0 2.005424e-07
I3992 n1_M2_105900_140460 0 1.460416e-07
I3993 n1_M2_105900_141540 0 9.946413e-08
I3994 n1_M2_105900_143700 0 6.523184e-08
I3995 n1_M2_105900_145860 0 4.710405e-08
I3996 n1_M2_108060_60 0 3.018932e-08
I3997 n1_M2_108060_2220 0 4.414307e-08
I3998 n1_M2_108060_4380 0 7.024326e-08
I3999 n1_M2_108060_5460 0 1.041871e-07
I4000 n1_M2_108060_7620 0 1.392558e-07
I4001 n1_M2_108060_9780 0 1.682382e-07
I4002 n1_M2_108060_11940 0 1.863307e-07
I4003 n1_M2_108060_14100 0 1.929240e-07
I4004 n1_M2_108060_16260 0 1.910115e-07
I4005 n1_M2_108060_18420 0 1.849765e-07
I4006 n1_M2_108060_19500 0 1.784672e-07
I4007 n1_M2_108060_21660 0 1.734983e-07
I4008 n1_M2_108060_23820 0 1.707399e-07
I4009 n1_M2_108060_25980 0 1.703922e-07
I4010 n1_M2_108060_28140 0 1.730619e-07
I4011 n1_M2_108060_30300 0 1.801475e-07
I4012 n1_M2_108060_32460 0 1.933861e-07
I4013 n1_M2_108060_33540 0 2.137136e-07
I4014 n1_M2_108060_35700 0 2.400998e-07
I4015 n1_M2_108060_37860 0 2.691817e-07
I4016 n1_M2_108060_40020 0 2.960345e-07
I4017 n1_M2_108060_42180 0 3.158298e-07
I4018 n1_M2_108060_44340 0 3.257646e-07
I4019 n1_M2_108060_46500 0 3.264067e-07
I4020 n1_M2_108060_47580 0 3.215335e-07
I4021 n1_M2_108060_49740 0 3.162116e-07
I4022 n1_M2_108060_51900 0 3.140201e-07
I4023 n1_M2_108060_54060 0 3.153538e-07
I4024 n1_M2_108060_56220 0 3.181113e-07
I4025 n1_M2_108060_58380 0 3.204037e-07
I4026 n1_M2_108060_59460 0 3.234217e-07
I4027 n1_M2_108060_61620 0 3.321265e-07
I4028 n1_M2_108060_63780 0 3.536368e-07
I4029 n1_M2_108060_65940 0 3.952514e-07
I4030 n1_M2_108060_68100 0 4.650824e-07
I4031 n1_M2_108060_70260 0 5.753168e-07
I4032 n1_M2_108060_72420 0 7.430454e-07
I4033 n1_M2_108060_73500 0 9.817206e-07
I4034 n1_M2_108060_75660 0 1.283237e-06
I4035 n1_M2_108060_77820 0 1.602776e-06
I4036 n1_M2_108060_79980 0 1.863924e-06
I4037 n1_M2_108060_82140 0 1.989404e-06
I4038 n1_M2_108060_84300 0 1.940211e-06
I4039 n1_M2_108060_86460 0 1.735809e-06
I4040 n1_M2_108060_87540 0 1.442116e-06
I4041 n1_M2_108060_89700 0 1.138876e-06
I4042 n1_M2_108060_91860 0 8.902792e-07
I4043 n1_M2_108060_94020 0 7.338200e-07
I4044 n1_M2_108060_96180 0 6.840077e-07
I4045 n1_M2_108060_98340 0 7.385808e-07
I4046 n1_M2_108060_100500 0 8.784353e-07
I4047 n1_M2_108060_101580 0 1.064473e-06
I4048 n1_M2_108060_103740 0 1.241699e-06
I4049 n1_M2_108060_105900 0 1.355474e-06
I4050 n1_M2_108060_108060 0 1.372806e-06
I4051 n1_M2_108060_110220 0 1.294330e-06
I4052 n1_M2_108060_112380 0 1.149436e-06
I4053 n1_M2_108060_113460 0 9.794857e-07
I4054 n1_M2_108060_115620 0 8.205971e-07
I4055 n1_M2_108060_117780 0 6.938344e-07
I4056 n1_M2_108060_119940 0 6.040586e-07
I4057 n1_M2_108060_122100 0 5.443648e-07
I4058 n1_M2_108060_124260 0 5.026788e-07
I4059 n1_M2_108060_126420 0 4.675672e-07
I4060 n1_M2_108060_127500 0 4.313801e-07
I4061 n1_M2_108060_129660 0 3.906839e-07
I4062 n1_M2_108060_131820 0 3.451174e-07
I4063 n1_M2_108060_133980 0 2.957307e-07
I4064 n1_M2_108060_136140 0 2.437988e-07
I4065 n1_M2_108060_138300 0 1.910272e-07
I4066 n1_M2_108060_140460 0 1.403026e-07
I4067 n1_M2_108060_141540 0 9.603961e-08
I4068 n1_M2_108060_143700 0 6.318417e-08
I4069 n1_M2_108060_145860 0 4.571207e-08
I4070 n1_M2_110220_60 0 3.162541e-08
I4071 n1_M2_110220_2220 0 4.585844e-08
I4072 n1_M2_110220_4380 0 7.238803e-08
I4073 n1_M2_110220_5460 0 1.068040e-07
I4074 n1_M2_110220_7620 0 1.424764e-07
I4075 n1_M2_110220_9780 0 1.724713e-07
I4076 n1_M2_110220_11940 0 1.921950e-07
I4077 n1_M2_110220_14100 0 2.008770e-07
I4078 n1_M2_110220_16260 0 2.009486e-07
I4079 n1_M2_110220_18420 0 1.961652e-07
I4080 n1_M2_110220_19500 0 1.898959e-07
I4081 n1_M2_110220_21660 0 1.843856e-07
I4082 n1_M2_110220_23820 0 1.808927e-07
I4083 n1_M2_110220_25980 0 1.802840e-07
I4084 n1_M2_110220_28140 0 1.837326e-07
I4085 n1_M2_110220_30300 0 1.930798e-07
I4086 n1_M2_110220_32460 0 2.103751e-07
I4087 n1_M2_110220_33540 0 2.365748e-07
I4088 n1_M2_110220_35700 0 2.700929e-07
I4089 n1_M2_110220_37860 0 3.063579e-07
I4090 n1_M2_110220_40020 0 3.390097e-07
I4091 n1_M2_110220_42180 0 3.622944e-07
I4092 n1_M2_110220_44340 0 3.733724e-07
I4093 n1_M2_110220_46500 0 3.732439e-07
I4094 n1_M2_110220_47580 0 3.657564e-07
I4095 n1_M2_110220_49740 0 3.553393e-07
I4096 n1_M2_110220_51900 0 3.448582e-07
I4097 n1_M2_110220_54060 0 3.350968e-07
I4098 n1_M2_110220_56220 0 3.261771e-07
I4099 n1_M2_110220_58380 0 3.198631e-07
I4100 n1_M2_110220_59460 0 3.212260e-07
I4101 n1_M2_110220_61620 0 3.380869e-07
I4102 n1_M2_110220_63780 0 3.785894e-07
I4103 n1_M2_110220_65940 0 4.489715e-07
I4104 n1_M2_110220_68100 0 5.545804e-07
I4105 n1_M2_110220_70260 0 7.046188e-07
I4106 n1_M2_110220_72420 0 9.149901e-07
I4107 n1_M2_110220_73500 0 1.200234e-06
I4108 n1_M2_110220_75660 0 1.552840e-06
I4109 n1_M2_110220_77820 0 1.923669e-06
I4110 n1_M2_110220_79980 0 2.225590e-06
I4111 n1_M2_110220_82140 0 2.368723e-06
I4112 n1_M2_110220_84300 0 2.307339e-06
I4113 n1_M2_110220_86460 0 2.064388e-06
I4114 n1_M2_110220_87540 0 1.716616e-06
I4115 n1_M2_110220_89700 0 1.354901e-06
I4116 n1_M2_110220_91860 0 1.049719e-06
I4117 n1_M2_110220_94020 0 8.396304e-07
I4118 n1_M2_110220_96180 0 7.376605e-07
I4119 n1_M2_110220_98340 0 7.403665e-07
I4120 n1_M2_110220_100500 0 8.294914e-07
I4121 n1_M2_110220_101580 0 9.690977e-07
I4122 n1_M2_110220_103740 0 1.108482e-06
I4123 n1_M2_110220_105900 0 1.196204e-06
I4124 n1_M2_110220_108060 0 1.199580e-06
I4125 n1_M2_110220_110220 0 1.116886e-06
I4126 n1_M2_110220_112380 0 9.743586e-07
I4127 n1_M2_110220_113460 0 8.111914e-07
I4128 n1_M2_110220_115620 0 6.625487e-07
I4129 n1_M2_110220_117780 0 5.488958e-07
I4130 n1_M2_110220_119940 0 4.742324e-07
I4131 n1_M2_110220_122100 0 4.307244e-07
I4132 n1_M2_110220_124260 0 4.057176e-07
I4133 n1_M2_110220_126420 0 3.875704e-07
I4134 n1_M2_110220_127500 0 3.684003e-07
I4135 n1_M2_110220_129660 0 3.440688e-07
I4136 n1_M2_110220_131820 0 3.130077e-07
I4137 n1_M2_110220_133980 0 2.750900e-07
I4138 n1_M2_110220_136140 0 2.311394e-07
I4139 n1_M2_110220_138300 0 1.833430e-07
I4140 n1_M2_110220_140460 0 1.355822e-07
I4141 n1_M2_110220_141540 0 9.313836e-08
I4142 n1_M2_110220_143700 0 6.140696e-08
I4143 n1_M2_110220_145860 0 4.449253e-08
I4144 n1_M2_112380_60 0 3.370515e-08
I4145 n1_M2_112380_2220 0 4.841472e-08
I4146 n1_M2_112380_4380 0 7.569088e-08
I4147 n1_M2_112380_5460 0 1.108801e-07
I4148 n1_M2_112380_7620 0 1.473035e-07
I4149 n1_M2_112380_9780 0 1.782447e-07
I4150 n1_M2_112380_11940 0 1.993803e-07
I4151 n1_M2_112380_14100 0 2.099132e-07
I4152 n1_M2_112380_16260 0 2.118153e-07
I4153 n1_M2_112380_18420 0 2.082186e-07
I4154 n1_M2_112380_19500 0 2.021435e-07
I4155 n1_M2_112380_21660 0 1.959993e-07
I4156 n1_M2_112380_23820 0 1.916185e-07
I4157 n1_M2_112380_25980 0 1.905663e-07
I4158 n1_M2_112380_28140 0 1.946259e-07
I4159 n1_M2_112380_30300 0 2.060983e-07
I4160 n1_M2_112380_32460 0 2.272893e-07
I4161 n1_M2_112380_33540 0 2.590085e-07
I4162 n1_M2_112380_35700 0 2.988718e-07
I4163 n1_M2_112380_37860 0 3.409200e-07
I4164 n1_M2_112380_40020 0 3.774266e-07
I4165 n1_M2_112380_42180 0 4.021171e-07
I4166 n1_M2_112380_44340 0 4.127573e-07
I4167 n1_M2_112380_46500 0 4.114533e-07
I4168 n1_M2_112380_47580 0 4.026462e-07
I4169 n1_M2_112380_49740 0 3.903872e-07
I4170 n1_M2_112380_51900 0 3.767136e-07
I4171 n1_M2_112380_54060 0 3.622397e-07
I4172 n1_M2_112380_56220 0 3.484288e-07
I4173 n1_M2_112380_58380 0 3.399101e-07
I4174 n1_M2_112380_59460 0 3.454063e-07
I4175 n1_M2_112380_61620 0 3.759550e-07
I4176 n1_M2_112380_63780 0 4.409054e-07
I4177 n1_M2_112380_65940 0 5.442462e-07
I4178 n1_M2_112380_68100 0 6.852664e-07
I4179 n1_M2_112380_70260 0 8.653260e-07
I4180 n1_M2_112380_72420 0 1.094688e-06
I4181 n1_M2_112380_73500 0 1.387710e-06
I4182 n1_M2_112380_75660 0 1.741625e-06
I4183 n1_M2_112380_77820 0 2.112694e-06
I4184 n1_M2_112380_79980 0 2.415527e-06
I4185 n1_M2_112380_82140 0 2.557890e-06
I4186 n1_M2_112380_84300 0 2.491000e-06
I4187 n1_M2_112380_86460 0 2.237234e-06
I4188 n1_M2_112380_87540 0 1.874943e-06
I4189 n1_M2_112380_89700 0 1.496078e-06
I4190 n1_M2_112380_91860 0 1.170102e-06
I4191 n1_M2_112380_94020 0 9.335116e-07
I4192 n1_M2_112380_96180 0 7.982094e-07
I4193 n1_M2_112380_98340 0 7.615613e-07
I4194 n1_M2_112380_100500 0 8.079807e-07
I4195 n1_M2_112380_101580 0 9.055869e-07
I4196 n1_M2_112380_103740 0 1.008468e-06
I4197 n1_M2_112380_105900 0 1.069610e-06
I4198 n1_M2_112380_108060 0 1.059004e-06
I4199 n1_M2_112380_110220 0 9.751176e-07
I4200 n1_M2_112380_112380 0 8.421070e-07
I4201 n1_M2_112380_113460 0 6.955914e-07
I4202 n1_M2_112380_115620 0 5.664363e-07
I4203 n1_M2_112380_117780 0 4.709277e-07
I4204 n1_M2_112380_119940 0 4.101220e-07
I4205 n1_M2_112380_122100 0 3.755089e-07
I4206 n1_M2_112380_124260 0 3.561115e-07
I4207 n1_M2_112380_126420 0 3.431364e-07
I4208 n1_M2_112380_127500 0 3.309299e-07
I4209 n1_M2_112380_129660 0 3.156798e-07
I4210 n1_M2_112380_131820 0 2.942861e-07
I4211 n1_M2_112380_133980 0 2.644956e-07
I4212 n1_M2_112380_136140 0 2.258723e-07
I4213 n1_M2_112380_138300 0 1.807504e-07
I4214 n1_M2_112380_140460 0 1.340384e-07
I4215 n1_M2_112380_141540 0 9.200499e-08
I4216 n1_M2_112380_143700 0 6.052594e-08
I4217 n1_M2_112380_145860 0 4.376981e-08
I4218 n1_M2_113460_60 0 3.557790e-08
I4219 n1_M2_113460_2220 0 5.073749e-08
I4220 n1_M2_113460_4380 0 7.873153e-08
I4221 n1_M2_113460_5460 0 1.146872e-07
I4222 n1_M2_113460_7620 0 1.518800e-07
I4223 n1_M2_113460_9780 0 1.837981e-07
I4224 n1_M2_113460_11940 0 2.063837e-07
I4225 n1_M2_113460_14100 0 2.188206e-07
I4226 n1_M2_113460_16260 0 2.226150e-07
I4227 n1_M2_113460_18420 0 2.202349e-07
I4228 n1_M2_113460_19500 0 2.143030e-07
I4229 n1_M2_113460_21660 0 2.073743e-07
I4230 n1_M2_113460_23820 0 2.018657e-07
I4231 n1_M2_113460_25980 0 2.000418e-07
I4232 n1_M2_113460_28140 0 2.042567e-07
I4233 n1_M2_113460_30300 0 2.171883e-07
I4234 n1_M2_113460_32460 0 2.412865e-07
I4235 n1_M2_113460_33540 0 2.771092e-07
I4236 n1_M2_113460_35700 0 3.214471e-07
I4237 n1_M2_113460_37860 0 3.670823e-07
I4238 n1_M2_113460_40020 0 4.052189e-07
I4239 n1_M2_113460_42180 0 4.294406e-07
I4240 n1_M2_113460_44340 0 4.384682e-07
I4241 n1_M2_113460_46500 0 4.358133e-07
I4242 n1_M2_113460_47580 0 4.268193e-07
I4243 n1_M2_113460_49740 0 4.154685e-07
I4244 n1_M2_113460_51900 0 4.030981e-07
I4245 n1_M2_113460_54060 0 3.898732e-07
I4246 n1_M2_113460_56220 0 3.779098e-07
I4247 n1_M2_113460_58380 0 3.740033e-07
I4248 n1_M2_113460_59460 0 3.902679e-07
I4249 n1_M2_113460_61620 0 4.411052e-07
I4250 n1_M2_113460_63780 0 5.368143e-07
I4251 n1_M2_113460_65940 0 6.773527e-07
I4252 n1_M2_113460_68100 0 8.521854e-07
I4253 n1_M2_113460_70260 0 1.049887e-06
I4254 n1_M2_113460_72420 0 1.270969e-06
I4255 n1_M2_113460_73500 0 1.528919e-06
I4256 n1_M2_113460_75660 0 1.830580e-06
I4257 n1_M2_113460_77820 0 2.148237e-06
I4258 n1_M2_113460_79980 0 2.411638e-06
I4259 n1_M2_113460_82140 0 2.536808e-06
I4260 n1_M2_113460_84300 0 2.474771e-06
I4261 n1_M2_113460_86460 0 2.241570e-06
I4262 n1_M2_113460_87540 0 1.906530e-06
I4263 n1_M2_113460_89700 0 1.552526e-06
I4264 n1_M2_113460_91860 0 1.241720e-06
I4265 n1_M2_113460_94020 0 1.006338e-06
I4266 n1_M2_113460_96180 0 8.574789e-07
I4267 n1_M2_113460_98340 0 7.945623e-07
I4268 n1_M2_113460_100500 0 8.059997e-07
I4269 n1_M2_113460_101580 0 8.653199e-07
I4270 n1_M2_113460_103740 0 9.331060e-07
I4271 n1_M2_113460_105900 0 9.690161e-07
I4272 n1_M2_113460_108060 0 9.480418e-07
I4273 n1_M2_113460_110220 0 8.701972e-07
I4274 n1_M2_113460_112380 0 7.570755e-07
I4275 n1_M2_113460_113460 0 6.384411e-07
I4276 n1_M2_113460_115620 0 5.377522e-07
I4277 n1_M2_113460_117780 0 4.644817e-07
I4278 n1_M2_113460_119940 0 4.155281e-07
I4279 n1_M2_113460_122100 0 3.822554e-07
I4280 n1_M2_113460_124260 0 3.574112e-07
I4281 n1_M2_113460_126420 0 3.377611e-07
I4282 n1_M2_113460_127500 0 3.221651e-07
I4283 n1_M2_113460_129660 0 3.082224e-07
I4284 n1_M2_113460_131820 0 2.911420e-07
I4285 n1_M2_113460_133980 0 2.657149e-07
I4286 n1_M2_113460_136140 0 2.294436e-07
I4287 n1_M2_113460_138300 0 1.844117e-07
I4288 n1_M2_113460_140460 0 1.365416e-07
I4289 n1_M2_113460_141540 0 9.322492e-08
I4290 n1_M2_113460_143700 0 6.090023e-08
I4291 n1_M2_113460_145860 0 4.377959e-08
I4292 n1_M2_115620_60 0 3.624038e-08
I4293 n1_M2_115620_2220 0 5.152841e-08
I4294 n1_M2_115620_4380 0 7.973986e-08
I4295 n1_M2_115620_5460 0 1.160033e-07
I4296 n1_M2_115620_7620 0 1.537387e-07
I4297 n1_M2_115620_9780 0 1.867044e-07
I4298 n1_M2_115620_11940 0 2.110340e-07
I4299 n1_M2_115620_14100 0 2.257444e-07
I4300 n1_M2_115620_16260 0 2.317413e-07
I4301 n1_M2_115620_18420 0 2.307545e-07
I4302 n1_M2_115620_19500 0 2.250053e-07
I4303 n1_M2_115620_21660 0 2.172329e-07
I4304 n1_M2_115620_23820 0 2.104633e-07
I4305 n1_M2_115620_25980 0 2.076134e-07
I4306 n1_M2_115620_28140 0 2.114696e-07
I4307 n1_M2_115620_30300 0 2.248941e-07
I4308 n1_M2_115620_32460 0 2.503278e-07
I4309 n1_M2_115620_33540 0 2.880840e-07
I4310 n1_M2_115620_35700 0 3.343885e-07
I4311 n1_M2_115620_37860 0 3.812403e-07
I4312 n1_M2_115620_40020 0 4.192624e-07
I4313 n1_M2_115620_42180 0 4.421536e-07
I4314 n1_M2_115620_44340 0 4.495439e-07
I4315 n1_M2_115620_46500 0 4.461939e-07
I4316 n1_M2_115620_47580 0 4.383599e-07
I4317 n1_M2_115620_49740 0 4.302067e-07
I4318 n1_M2_115620_51900 0 4.226423e-07
I4319 n1_M2_115620_54060 0 4.153613e-07
I4320 n1_M2_115620_56220 0 4.107183e-07
I4321 n1_M2_115620_58380 0 4.171652e-07
I4322 n1_M2_115620_59460 0 4.499395e-07
I4323 n1_M2_115620_61620 0 5.267271e-07
I4324 n1_M2_115620_63780 0 6.582920e-07
I4325 n1_M2_115620_65940 0 8.389636e-07
I4326 n1_M2_115620_68100 0 1.045618e-06
I4327 n1_M2_115620_70260 0 1.250881e-06
I4328 n1_M2_115620_72420 0 1.443258e-06
I4329 n1_M2_115620_73500 0 1.635458e-06
I4330 n1_M2_115620_75660 0 1.847577e-06
I4331 n1_M2_115620_77820 0 2.075328e-06
I4332 n1_M2_115620_79980 0 2.272827e-06
I4333 n1_M2_115620_82140 0 2.371402e-06
I4334 n1_M2_115620_84300 0 2.323025e-06
I4335 n1_M2_115620_86460 0 2.132323e-06
I4336 n1_M2_115620_87540 0 1.851757e-06
I4337 n1_M2_115620_89700 0 1.548863e-06
I4338 n1_M2_115620_91860 0 1.275660e-06
I4339 n1_M2_115620_94020 0 1.059661e-06
I4340 n1_M2_115620_96180 0 9.112811e-07
I4341 n1_M2_115620_98340 0 8.319817e-07
I4342 n1_M2_115620_100500 0 8.144013e-07
I4343 n1_M2_115620_101580 0 8.385382e-07
I4344 n1_M2_115620_103740 0 8.733475e-07
I4345 n1_M2_115620_105900 0 8.872316e-07
I4346 n1_M2_115620_108060 0 8.615921e-07
I4347 n1_M2_115620_110220 0 7.980950e-07
I4348 n1_M2_115620_112380 0 7.145987e-07
I4349 n1_M2_115620_113460 0 6.331437e-07
I4350 n1_M2_115620_115620 0 5.679409e-07
I4351 n1_M2_115620_117780 0 5.202909e-07
I4352 n1_M2_115620_119940 0 4.822124e-07
I4353 n1_M2_115620_122100 0 4.449917e-07
I4354 n1_M2_115620_124260 0 4.060718e-07
I4355 n1_M2_115620_126420 0 3.695273e-07
I4356 n1_M2_115620_127500 0 3.406606e-07
I4357 n1_M2_115620_129660 0 3.198734e-07
I4358 n1_M2_115620_131820 0 3.011650e-07
I4359 n1_M2_115620_133980 0 2.760862e-07
I4360 n1_M2_115620_136140 0 2.394590e-07
I4361 n1_M2_115620_138300 0 1.925620e-07
I4362 n1_M2_115620_140460 0 1.420251e-07
I4363 n1_M2_115620_141540 0 9.627802e-08
I4364 n1_M2_115620_143700 0 6.233604e-08
I4365 n1_M2_115620_145860 0 4.446778e-08
I4366 n1_M2_117780_60 0 3.520163e-08
I4367 n1_M2_117780_2220 0 5.014429e-08
I4368 n1_M2_117780_4380 0 7.782708e-08
I4369 n1_M2_117780_5460 0 1.136981e-07
I4370 n1_M2_117780_7620 0 1.515984e-07
I4371 n1_M2_117780_9780 0 1.856436e-07
I4372 n1_M2_117780_11940 0 2.120311e-07
I4373 n1_M2_117780_14100 0 2.293923e-07
I4374 n1_M2_117780_16260 0 2.378846e-07
I4375 n1_M2_117780_18420 0 2.384846e-07
I4376 n1_M2_117780_19500 0 2.330806e-07
I4377 n1_M2_117780_21660 0 2.246561e-07
I4378 n1_M2_117780_23820 0 2.168279e-07
I4379 n1_M2_117780_25980 0 2.130363e-07
I4380 n1_M2_117780_28140 0 2.162671e-07
I4381 n1_M2_117780_30300 0 2.292938e-07
I4382 n1_M2_117780_32460 0 2.543739e-07
I4383 n1_M2_117780_33540 0 2.916820e-07
I4384 n1_M2_117780_35700 0 3.373582e-07
I4385 n1_M2_117780_37860 0 3.833330e-07
I4386 n1_M2_117780_40020 0 4.202412e-07
I4387 n1_M2_117780_42180 0 4.420335e-07
I4388 n1_M2_117780_44340 0 4.489169e-07
I4389 n1_M2_117780_46500 0 4.464311e-07
I4390 n1_M2_117780_47580 0 4.415271e-07
I4391 n1_M2_117780_49740 0 4.386942e-07
I4392 n1_M2_117780_51900 0 4.386881e-07
I4393 n1_M2_117780_54060 0 4.408142e-07
I4394 n1_M2_117780_56220 0 4.473847e-07
I4395 n1_M2_117780_58380 0 4.680238e-07
I4396 n1_M2_117780_59460 0 5.206480e-07
I4397 n1_M2_117780_61620 0 6.258964e-07
I4398 n1_M2_117780_63780 0 7.946673e-07
I4399 n1_M2_117780_65940 0 1.015204e-06
I4400 n1_M2_117780_68100 0 1.251360e-06
I4401 n1_M2_117780_70260 0 1.459616e-06
I4402 n1_M2_117780_72420 0 1.616523e-06
I4403 n1_M2_117780_73500 0 1.734168e-06
I4404 n1_M2_117780_75660 0 1.846388e-06
I4405 n1_M2_117780_77820 0 1.973716e-06
I4406 n1_M2_117780_79980 0 2.097044e-06
I4407 n1_M2_117780_82140 0 2.165262e-06
I4408 n1_M2_117780_84300 0 2.131732e-06
I4409 n1_M2_117780_86460 0 1.987902e-06
I4410 n1_M2_117780_87540 0 1.766972e-06
I4411 n1_M2_117780_89700 0 1.520067e-06
I4412 n1_M2_117780_91860 0 1.289613e-06
I4413 n1_M2_117780_94020 0 1.099204e-06
I4414 n1_M2_117780_96180 0 9.583480e-07
I4415 n1_M2_117780_98340 0 8.694375e-07
I4416 n1_M2_117780_100500 0 8.284245e-07
I4417 n1_M2_117780_101580 0 8.218493e-07
I4418 n1_M2_117780_103740 0 8.278961e-07
I4419 n1_M2_117780_105900 0 8.245279e-07
I4420 n1_M2_117780_108060 0 7.997060e-07
I4421 n1_M2_117780_110220 0 7.562169e-07
I4422 n1_M2_117780_112380 0 7.074914e-07
I4423 n1_M2_117780_113460 0 6.674680e-07
I4424 n1_M2_117780_115620 0 6.410719e-07
I4425 n1_M2_117780_117780 0 6.213003e-07
I4426 n1_M2_117780_119940 0 5.946818e-07
I4427 n1_M2_117780_122100 0 5.515081e-07
I4428 n1_M2_117780_124260 0 4.933936e-07
I4429 n1_M2_117780_126420 0 4.322024e-07
I4430 n1_M2_117780_127500 0 3.811241e-07
I4431 n1_M2_117780_129660 0 3.451265e-07
I4432 n1_M2_117780_131820 0 3.183324e-07
I4433 n1_M2_117780_133980 0 2.895375e-07
I4434 n1_M2_117780_136140 0 2.505651e-07
I4435 n1_M2_117780_138300 0 2.011362e-07
I4436 n1_M2_117780_140460 0 1.478398e-07
I4437 n1_M2_117780_141540 0 9.968174e-08
I4438 n1_M2_117780_143700 0 6.410339e-08
I4439 n1_M2_117780_145860 0 4.545331e-08
I4440 n1_M2_119940_60 0 3.283365e-08
I4441 n1_M2_119940_2220 0 4.705636e-08
I4442 n1_M2_119940_4380 0 7.362178e-08
I4443 n1_M2_119940_5460 0 1.085469e-07
I4444 n1_M2_119940_7620 0 1.462950e-07
I4445 n1_M2_119940_9780 0 1.813721e-07
I4446 n1_M2_119940_11940 0 2.099072e-07
I4447 n1_M2_119940_14100 0 2.299873e-07
I4448 n1_M2_119940_16260 0 2.409889e-07
I4449 n1_M2_119940_18420 0 2.432408e-07
I4450 n1_M2_119940_19500 0 2.384293e-07
I4451 n1_M2_119940_21660 0 2.298211e-07
I4452 n1_M2_119940_23820 0 2.215310e-07
I4453 n1_M2_119940_25980 0 2.173201e-07
I4454 n1_M2_119940_28140 0 2.200883e-07
I4455 n1_M2_119940_30300 0 2.322102e-07
I4456 n1_M2_119940_32460 0 2.555706e-07
I4457 n1_M2_119940_33540 0 2.903356e-07
I4458 n1_M2_119940_35700 0 3.330994e-07
I4459 n1_M2_119940_37860 0 3.764942e-07
I4460 n1_M2_119940_40020 0 4.117684e-07
I4461 n1_M2_119940_42180 0 4.332177e-07
I4462 n1_M2_119940_44340 0 4.412269e-07
I4463 n1_M2_119940_46500 0 4.415784e-07
I4464 n1_M2_119940_47580 0 4.416303e-07
I4465 n1_M2_119940_49740 0 4.462715e-07
I4466 n1_M2_119940_51900 0 4.563355e-07
I4467 n1_M2_119940_54060 0 4.707819e-07
I4468 n1_M2_119940_56220 0 4.914902e-07
I4469 n1_M2_119940_58380 0 5.284395e-07
I4470 n1_M2_119940_59460 0 6.012392e-07
I4471 n1_M2_119940_61620 0 7.327710e-07
I4472 n1_M2_119940_63780 0 9.342063e-07
I4473 n1_M2_119940_65940 0 1.189107e-06
I4474 n1_M2_119940_68100 0 1.450906e-06
I4475 n1_M2_119940_70260 0 1.662855e-06
I4476 n1_M2_119940_72420 0 1.791239e-06
I4477 n1_M2_119940_73500 0 1.846584e-06
I4478 n1_M2_119940_75660 0 1.872763e-06
I4479 n1_M2_119940_77820 0 1.910251e-06
I4480 n1_M2_119940_79980 0 1.963110e-06
I4481 n1_M2_119940_82140 0 1.997060e-06
I4482 n1_M2_119940_84300 0 1.968732e-06
I4483 n1_M2_119940_86460 0 1.859398e-06
I4484 n1_M2_119940_87540 0 1.685890e-06
I4485 n1_M2_119940_89700 0 1.485280e-06
I4486 n1_M2_119940_91860 0 1.292074e-06
I4487 n1_M2_119940_94020 0 1.126539e-06
I4488 n1_M2_119940_96180 0 9.966076e-07
I4489 n1_M2_119940_98340 0 9.041188e-07
I4490 n1_M2_119940_100500 0 8.468486e-07
I4491 n1_M2_119940_101580 0 8.168820e-07
I4492 n1_M2_119940_103740 0 8.009915e-07
I4493 n1_M2_119940_105900 0 7.860032e-07
I4494 n1_M2_119940_108060 0 7.656491e-07
I4495 n1_M2_119940_110220 0 7.433767e-07
I4496 n1_M2_119940_112380 0 7.285734e-07
I4497 n1_M2_119940_113460 0 7.283283e-07
I4498 n1_M2_119940_115620 0 7.397797e-07
I4499 n1_M2_119940_117780 0 7.484009e-07
I4500 n1_M2_119940_119940 0 7.346701e-07
I4501 n1_M2_119940_122100 0 6.862243e-07
I4502 n1_M2_119940_124260 0 6.071231e-07
I4503 n1_M2_119940_126420 0 5.163536e-07
I4504 n1_M2_119940_127500 0 4.358206e-07
I4505 n1_M2_119940_129660 0 3.769114e-07
I4506 n1_M2_119940_131820 0 3.357863e-07
I4507 n1_M2_119940_133980 0 2.996077e-07
I4508 n1_M2_119940_136140 0 2.572044e-07
I4509 n1_M2_119940_138300 0 2.058978e-07
I4510 n1_M2_119940_140460 0 1.511562e-07
I4511 n1_M2_119940_141540 0 1.017782e-07
I4512 n1_M2_119940_143700 0 6.531996e-08
I4513 n1_M2_119940_145860 0 4.622287e-08
I4514 n1_M2_122100_60 0 3.012293e-08
I4515 n1_M2_122100_2220 0 4.352715e-08
I4516 n1_M2_122100_4380 0 6.882846e-08
I4517 n1_M2_122100_5460 0 1.026847e-07
I4518 n1_M2_122100_7620 0 1.402163e-07
I4519 n1_M2_122100_9780 0 1.762802e-07
I4520 n1_M2_122100_11940 0 2.068511e-07
I4521 n1_M2_122100_14100 0 2.294354e-07
I4522 n1_M2_122100_16260 0 2.427138e-07
I4523 n1_M2_122100_18420 0 2.465382e-07
I4524 n1_M2_122100_19500 0 2.425300e-07
I4525 n1_M2_122100_21660 0 2.342568e-07
I4526 n1_M2_122100_23820 0 2.262253e-07
I4527 n1_M2_122100_25980 0 2.223251e-07
I4528 n1_M2_122100_28140 0 2.251055e-07
I4529 n1_M2_122100_30300 0 2.362422e-07
I4530 n1_M2_122100_32460 0 2.570414e-07
I4531 n1_M2_122100_33540 0 2.877392e-07
I4532 n1_M2_122100_35700 0 3.258311e-07
I4533 n1_M2_122100_37860 0 3.653091e-07
I4534 n1_M2_122100_40020 0 3.985584e-07
I4535 n1_M2_122100_42180 0 4.203189e-07
I4536 n1_M2_122100_44340 0 4.308467e-07
I4537 n1_M2_122100_46500 0 4.357440e-07
I4538 n1_M2_122100_47580 0 4.425687e-07
I4539 n1_M2_122100_49740 0 4.567394e-07
I4540 n1_M2_122100_51900 0 4.794514e-07
I4541 n1_M2_122100_54060 0 5.093605e-07
I4542 n1_M2_122100_56220 0 5.473100e-07
I4543 n1_M2_122100_58380 0 6.022031e-07
I4544 n1_M2_122100_59460 0 6.934518e-07
I4545 n1_M2_122100_61620 0 8.448264e-07
I4546 n1_M2_122100_63780 0 1.068324e-06
I4547 n1_M2_122100_65940 0 1.346123e-06
I4548 n1_M2_122100_68100 0 1.626670e-06
I4549 n1_M2_122100_70260 0 1.845342e-06
I4550 n1_M2_122100_72420 0 1.960517e-06
I4551 n1_M2_122100_73500 0 1.978512e-06
I4552 n1_M2_122100_75660 0 1.945856e-06
I4553 n1_M2_122100_77820 0 1.913723e-06
I4554 n1_M2_122100_79980 0 1.902548e-06
I4555 n1_M2_122100_82140 0 1.893795e-06
I4556 n1_M2_122100_84300 0 1.852020e-06
I4557 n1_M2_122100_86460 0 1.755574e-06
I4558 n1_M2_122100_87540 0 1.610998e-06
I4559 n1_M2_122100_89700 0 1.444299e-06
I4560 n1_M2_122100_91860 0 1.282376e-06
I4561 n1_M2_122100_94020 0 1.141250e-06
I4562 n1_M2_122100_96180 0 1.026124e-06
I4563 n1_M2_122100_98340 0 9.371616e-07
I4564 n1_M2_122100_100500 0 8.727323e-07
I4565 n1_M2_122100_101580 0 8.289706e-07
I4566 n1_M2_122100_103740 0 7.994970e-07
I4567 n1_M2_122100_105900 0 7.782692e-07
I4568 n1_M2_122100_108060 0 7.636315e-07
I4569 n1_M2_122100_110220 0 7.596929e-07
I4570 n1_M2_122100_112380 0 7.731558e-07
I4571 n1_M2_122100_113460 0 8.065376e-07
I4572 n1_M2_122100_115620 0 8.514362e-07
I4573 n1_M2_122100_117780 0 8.869748e-07
I4574 n1_M2_122100_119940 0 8.871329e-07
I4575 n1_M2_122100_122100 0 8.350981e-07
I4576 n1_M2_122100_124260 0 7.352533e-07
I4577 n1_M2_122100_126420 0 6.124499e-07
I4578 n1_M2_122100_127500 0 4.975491e-07
I4579 n1_M2_122100_129660 0 4.098504e-07
I4580 n1_M2_122100_131820 0 3.494151e-07
I4581 n1_M2_122100_133980 0 3.030612e-07
I4582 n1_M2_122100_136140 0 2.568358e-07
I4583 n1_M2_122100_138300 0 2.049417e-07
I4584 n1_M2_122100_140460 0 1.506547e-07
I4585 n1_M2_122100_141540 0 1.017331e-07
I4586 n1_M2_122100_143700 0 6.548786e-08
I4587 n1_M2_122100_145860 0 4.644653e-08
I4588 n1_M2_124260_60 0 2.804299e-08
I4589 n1_M2_124260_2220 0 4.080408e-08
I4590 n1_M2_124260_4380 0 6.513652e-08
I4591 n1_M2_124260_5460 0 9.824757e-08
I4592 n1_M2_124260_7620 0 1.358154e-07
I4593 n1_M2_124260_9780 0 1.729742e-07
I4594 n1_M2_124260_11940 0 2.055210e-07
I4595 n1_M2_124260_14100 0 2.304175e-07
I4596 n1_M2_124260_16260 0 2.457393e-07
I4597 n1_M2_124260_18420 0 2.509728e-07
I4598 n1_M2_124260_19500 0 2.477636e-07
I4599 n1_M2_124260_21660 0 2.400180e-07
I4600 n1_M2_124260_23820 0 2.326172e-07
I4601 n1_M2_124260_25980 0 2.294983e-07
I4602 n1_M2_124260_28140 0 2.326960e-07
I4603 n1_M2_124260_30300 0 2.429547e-07
I4604 n1_M2_124260_32460 0 2.608113e-07
I4605 n1_M2_124260_33540 0 2.865752e-07
I4606 n1_M2_124260_35700 0 3.189130e-07
I4607 n1_M2_124260_37860 0 3.536063e-07
I4608 n1_M2_124260_40020 0 3.845363e-07
I4609 n1_M2_124260_42180 0 4.069661e-07
I4610 n1_M2_124260_44340 0 4.208234e-07
I4611 n1_M2_124260_46500 0 4.312523e-07
I4612 n1_M2_124260_47580 0 4.459307e-07
I4613 n1_M2_124260_49740 0 4.710884e-07
I4614 n1_M2_124260_51900 0 5.088032e-07
I4615 n1_M2_124260_54060 0 5.577304e-07
I4616 n1_M2_124260_56220 0 6.171335e-07
I4617 n1_M2_124260_58380 0 6.929852e-07
I4618 n1_M2_124260_59460 0 8.016918e-07
I4619 n1_M2_124260_61620 0 9.656018e-07
I4620 n1_M2_124260_63780 0 1.197802e-06
I4621 n1_M2_124260_65940 0 1.483191e-06
I4622 n1_M2_124260_68100 0 1.772213e-06
I4623 n1_M2_124260_70260 0 1.999068e-06
I4624 n1_M2_124260_72420 0 2.116898e-06
I4625 n1_M2_124260_73500 0 2.124328e-06
I4626 n1_M2_124260_75660 0 2.061730e-06
I4627 n1_M2_124260_77820 0 1.980496e-06
I4628 n1_M2_124260_79980 0 1.910221e-06
I4629 n1_M2_124260_82140 0 1.847810e-06
I4630 n1_M2_124260_84300 0 1.772172e-06
I4631 n1_M2_124260_86460 0 1.667846e-06
I4632 n1_M2_124260_87540 0 1.537830e-06
I4633 n1_M2_124260_89700 0 1.398943e-06
I4634 n1_M2_124260_91860 0 1.268603e-06
I4635 n1_M2_124260_94020 0 1.155805e-06
I4636 n1_M2_124260_96180 0 1.061350e-06
I4637 n1_M2_124260_98340 0 9.832636e-07
I4638 n1_M2_124260_100500 0 9.202213e-07
I4639 n1_M2_124260_101580 0 8.713523e-07
I4640 n1_M2_124260_103740 0 8.352453e-07
I4641 n1_M2_124260_105900 0 8.110006e-07
I4642 n1_M2_124260_108060 0 8.004861e-07
I4643 n1_M2_124260_110220 0 8.089208e-07
I4644 n1_M2_124260_112380 0 8.422024e-07
I4645 n1_M2_124260_113460 0 9.008172e-07
I4646 n1_M2_124260_115620 0 9.729783e-07
I4647 n1_M2_124260_117780 0 1.032404e-06
I4648 n1_M2_124260_119940 0 1.046082e-06
I4649 n1_M2_124260_122100 0 9.912498e-07
I4650 n1_M2_124260_124260 0 8.709254e-07
I4651 n1_M2_124260_126420 0 7.147740e-07
I4652 n1_M2_124260_127500 0 5.626075e-07
I4653 n1_M2_124260_129660 0 4.425192e-07
I4654 n1_M2_124260_131820 0 3.596703e-07
I4655 n1_M2_124260_133980 0 3.014126e-07
I4656 n1_M2_124260_136140 0 2.512005e-07
I4657 n1_M2_124260_138300 0 1.996764e-07
I4658 n1_M2_124260_140460 0 1.472193e-07
I4659 n1_M2_124260_141540 0 9.997977e-08
I4660 n1_M2_124260_143700 0 6.476284e-08
I4661 n1_M2_124260_145860 0 4.615958e-08
I4662 n1_M2_126420_60 0 2.702814e-08
I4663 n1_M2_126420_2220 0 3.944987e-08
I4664 n1_M2_126420_4380 0 6.331752e-08
I4665 n1_M2_126420_5460 0 9.622765e-08
I4666 n1_M2_126420_7620 0 1.342731e-07
I4667 n1_M2_126420_9780 0 1.728010e-07
I4668 n1_M2_126420_11940 0 2.074419e-07
I4669 n1_M2_126420_14100 0 2.346434e-07
I4670 n1_M2_126420_16260 0 2.518827e-07
I4671 n1_M2_126420_18420 0 2.582796e-07
I4672 n1_M2_126420_19500 0 2.555318e-07
I4673 n1_M2_126420_21660 0 2.479581e-07
I4674 n1_M2_126420_23820 0 2.409031e-07
I4675 n1_M2_126420_25980 0 2.384059e-07
I4676 n1_M2_126420_28140 0 2.419715e-07
I4677 n1_M2_126420_30300 0 2.513339e-07
I4678 n1_M2_126420_32460 0 2.661663e-07
I4679 n1_M2_126420_33540 0 2.868099e-07
I4680 n1_M2_126420_35700 0 3.131532e-07
I4681 n1_M2_126420_37860 0 3.428927e-07
I4682 n1_M2_126420_40020 0 3.715246e-07
I4683 n1_M2_126420_42180 0 3.948422e-07
I4684 n1_M2_126420_44340 0 4.123060e-07
I4685 n1_M2_126420_46500 0 4.284031e-07
I4686 n1_M2_126420_47580 0 4.508968e-07
I4687 n1_M2_126420_49740 0 4.872055e-07
I4688 n1_M2_126420_51900 0 5.411207e-07
I4689 n1_M2_126420_54060 0 6.121872e-07
I4690 n1_M2_126420_56220 0 6.982331e-07
I4691 n1_M2_126420_58380 0 8.008162e-07
I4692 n1_M2_126420_59460 0 9.301779e-07
I4693 n1_M2_126420_61620 0 1.103809e-06
I4694 n1_M2_126420_63780 0 1.334641e-06
I4695 n1_M2_126420_65940 0 1.613130e-06
I4696 n1_M2_126420_68100 0 1.898127e-06
I4697 n1_M2_126420_70260 0 2.129522e-06
I4698 n1_M2_126420_72420 0 2.258681e-06
I4699 n1_M2_126420_73500 0 2.274446e-06
I4700 n1_M2_126420_75660 0 2.204159e-06
I4701 n1_M2_126420_77820 0 2.090977e-06
I4702 n1_M2_126420_79980 0 1.967734e-06
I4703 n1_M2_126420_82140 0 1.846371e-06
I4704 n1_M2_126420_84300 0 1.725305e-06
I4705 n1_M2_126420_86460 0 1.602745e-06
I4706 n1_M2_126420_87540 0 1.483515e-06
I4707 n1_M2_126420_89700 0 1.375961e-06
I4708 n1_M2_126420_91860 0 1.284910e-06
I4709 n1_M2_126420_94020 0 1.208452e-06
I4710 n1_M2_126420_96180 0 1.140907e-06
I4711 n1_M2_126420_98340 0 1.078300e-06
I4712 n1_M2_126420_100500 0 1.020606e-06
I4713 n1_M2_126420_101580 0 9.701379e-07
I4714 n1_M2_126420_103740 0 9.293269e-07
I4715 n1_M2_126420_105900 0 9.007595e-07
I4716 n1_M2_126420_108060 0 8.889426e-07
I4717 n1_M2_126420_110220 0 9.008809e-07
I4718 n1_M2_126420_112380 0 9.436628e-07
I4719 n1_M2_126420_113460 0 1.018079e-06
I4720 n1_M2_126420_115620 0 1.110539e-06
I4721 n1_M2_126420_117780 0 1.189622e-06
I4722 n1_M2_126420_119940 0 1.214519e-06
I4723 n1_M2_126420_122100 0 1.155370e-06
I4724 n1_M2_126420_124260 0 1.013027e-06
I4725 n1_M2_126420_126420 0 8.217327e-07
I4726 n1_M2_126420_127500 0 6.304151e-07
I4727 n1_M2_126420_129660 0 4.762496e-07
I4728 n1_M2_126420_131820 0 3.697273e-07
I4729 n1_M2_126420_133980 0 2.988329e-07
I4730 n1_M2_126420_136140 0 2.443878e-07
I4731 n1_M2_126420_138300 0 1.933307e-07
I4732 n1_M2_126420_140460 0 1.429617e-07
I4733 n1_M2_126420_141540 0 9.767782e-08
I4734 n1_M2_126420_143700 0 6.369403e-08
I4735 n1_M2_126420_145860 0 4.563303e-08
I4736 n1_M2_127500_60 0 2.684616e-08
I4737 n1_M2_127500_2220 0 3.917689e-08
I4738 n1_M2_127500_4380 0 6.298435e-08
I4739 n1_M2_127500_5460 0 9.611198e-08
I4740 n1_M2_127500_7620 0 1.349455e-07
I4741 n1_M2_127500_9780 0 1.750009e-07
I4742 n1_M2_127500_11940 0 2.117648e-07
I4743 n1_M2_127500_14100 0 2.411953e-07
I4744 n1_M2_127500_16260 0 2.601485e-07
I4745 n1_M2_127500_18420 0 2.673335e-07
I4746 n1_M2_127500_19500 0 2.644839e-07
I4747 n1_M2_127500_21660 0 2.563653e-07
I4748 n1_M2_127500_23820 0 2.488573e-07
I4749 n1_M2_127500_25980 0 2.462030e-07
I4750 n1_M2_127500_28140 0 2.495208e-07
I4751 n1_M2_127500_30300 0 2.576929e-07
I4752 n1_M2_127500_32460 0 2.696257e-07
I4753 n1_M2_127500_33540 0 2.856429e-07
I4754 n1_M2_127500_35700 0 3.066613e-07
I4755 n1_M2_127500_37860 0 3.320660e-07
I4756 n1_M2_127500_40020 0 3.588243e-07
I4757 n1_M2_127500_42180 0 3.832019e-07
I4758 n1_M2_127500_44340 0 4.041165e-07
I4759 n1_M2_127500_46500 0 4.252349e-07
I4760 n1_M2_127500_47580 0 4.542817e-07
I4761 n1_M2_127500_49740 0 5.001180e-07
I4762 n1_M2_127500_51900 0 5.692036e-07
I4763 n1_M2_127500_54060 0 6.635248e-07
I4764 n1_M2_127500_56220 0 7.808566e-07
I4765 n1_M2_127500_58380 0 9.182488e-07
I4766 n1_M2_127500_59460 0 1.077320e-06
I4767 n1_M2_127500_61620 0 1.266497e-06
I4768 n1_M2_127500_63780 0 1.494888e-06
I4769 n1_M2_127500_65940 0 1.758051e-06
I4770 n1_M2_127500_68100 0 2.026856e-06
I4771 n1_M2_127500_70260 0 2.252715e-06
I4772 n1_M2_127500_72420 0 2.390026e-06
I4773 n1_M2_127500_73500 0 2.419317e-06
I4774 n1_M2_127500_75660 0 2.352872e-06
I4775 n1_M2_127500_77820 0 2.221570e-06
I4776 n1_M2_127500_79980 0 2.057525e-06
I4777 n1_M2_127500_82140 0 1.885726e-06
I4778 n1_M2_127500_84300 0 1.724974e-06
I4779 n1_M2_127500_86460 0 1.590097e-06
I4780 n1_M2_127500_87540 0 1.490468e-06
I4781 n1_M2_127500_89700 0 1.426173e-06
I4782 n1_M2_127500_91860 0 1.386785e-06
I4783 n1_M2_127500_94020 0 1.355851e-06
I4784 n1_M2_127500_96180 0 1.319179e-06
I4785 n1_M2_127500_98340 0 1.271429e-06
I4786 n1_M2_127500_100500 0 1.216044e-06
I4787 n1_M2_127500_101580 0 1.160084e-06
I4788 n1_M2_127500_103740 0 1.109639e-06
I4789 n1_M2_127500_105900 0 1.069511e-06
I4790 n1_M2_127500_108060 0 1.046049e-06
I4791 n1_M2_127500_110220 0 1.048750e-06
I4792 n1_M2_127500_112380 0 1.087854e-06
I4793 n1_M2_127500_113460 0 1.166535e-06
I4794 n1_M2_127500_115620 0 1.270465e-06
I4795 n1_M2_127500_117780 0 1.362808e-06
I4796 n1_M2_127500_119940 0 1.393962e-06
I4797 n1_M2_127500_122100 0 1.326253e-06
I4798 n1_M2_127500_124260 0 1.158417e-06
I4799 n1_M2_127500_126420 0 9.297546e-07
I4800 n1_M2_127500_127500 0 6.985214e-07
I4801 n1_M2_127500_129660 0 5.105945e-07
I4802 n1_M2_127500_131820 0 3.810614e-07
I4803 n1_M2_127500_133980 0 2.979238e-07
I4804 n1_M2_127500_136140 0 2.391516e-07
I4805 n1_M2_127500_138300 0 1.881217e-07
I4806 n1_M2_127500_140460 0 1.393250e-07
I4807 n1_M2_127500_141540 0 9.560400e-08
I4808 n1_M2_127500_143700 0 6.263736e-08
I4809 n1_M2_127500_145860 0 4.503521e-08
I4810 n1_M2_129660_60 0 2.682749e-08
I4811 n1_M2_129660_2220 0 3.911997e-08
I4812 n1_M2_129660_4380 0 6.291773e-08
I4813 n1_M2_129660_5460 0 9.621919e-08
I4814 n1_M2_129660_7620 0 1.356191e-07
I4815 n1_M2_129660_9780 0 1.767794e-07
I4816 n1_M2_129660_11940 0 2.151024e-07
I4817 n1_M2_129660_14100 0 2.461671e-07
I4818 n1_M2_129660_16260 0 2.663035e-07
I4819 n1_M2_129660_18420 0 2.738355e-07
I4820 n1_M2_129660_19500 0 2.704639e-07
I4821 n1_M2_129660_21660 0 2.612596e-07
I4822 n1_M2_129660_23820 0 2.525146e-07
I4823 n1_M2_129660_25980 0 2.487055e-07
I4824 n1_M2_129660_28140 0 2.508283e-07
I4825 n1_M2_129660_30300 0 2.573305e-07
I4826 n1_M2_129660_32460 0 2.666653e-07
I4827 n1_M2_129660_33540 0 2.790950e-07
I4828 n1_M2_129660_35700 0 2.961439e-07
I4829 n1_M2_129660_37860 0 3.183434e-07
I4830 n1_M2_129660_40020 0 3.437807e-07
I4831 n1_M2_129660_42180 0 3.691370e-07
I4832 n1_M2_129660_44340 0 3.928384e-07
I4833 n1_M2_129660_46500 0 4.176343e-07
I4834 n1_M2_129660_47580 0 4.509324e-07
I4835 n1_M2_129660_49740 0 5.029290e-07
I4836 n1_M2_129660_51900 0 5.834150e-07
I4837 n1_M2_129660_54060 0 6.986113e-07
I4838 n1_M2_129660_56220 0 8.487645e-07
I4839 n1_M2_129660_58380 0 1.028246e-06
I4840 n1_M2_129660_59460 0 1.229423e-06
I4841 n1_M2_129660_61620 0 1.447881e-06
I4842 n1_M2_129660_63780 0 1.683389e-06
I4843 n1_M2_129660_65940 0 1.932340e-06
I4844 n1_M2_129660_68100 0 2.177129e-06
I4845 n1_M2_129660_70260 0 2.384193e-06
I4846 n1_M2_129660_72420 0 2.516541e-06
I4847 n1_M2_129660_73500 0 2.551678e-06
I4848 n1_M2_129660_75660 0 2.490286e-06
I4849 n1_M2_129660_77820 0 2.351850e-06
I4850 n1_M2_129660_79980 0 2.165864e-06
I4851 n1_M2_129660_82140 0 1.966425e-06
I4852 n1_M2_129660_84300 0 1.788643e-06
I4853 n1_M2_129660_86460 0 1.661696e-06
I4854 n1_M2_129660_87540 0 1.599324e-06
I4855 n1_M2_129660_89700 0 1.593625e-06
I4856 n1_M2_129660_91860 0 1.617938e-06
I4857 n1_M2_129660_94020 0 1.639227e-06
I4858 n1_M2_129660_96180 0 1.633590e-06
I4859 n1_M2_129660_98340 0 1.595400e-06
I4860 n1_M2_129660_100500 0 1.534206e-06
I4861 n1_M2_129660_101580 0 1.463844e-06
I4862 n1_M2_129660_103740 0 1.394090e-06
I4863 n1_M2_129660_105900 0 1.330622e-06
I4864 n1_M2_129660_108060 0 1.280703e-06
I4865 n1_M2_129660_110220 0 1.257006e-06
I4866 n1_M2_129660_112380 0 1.274878e-06
I4867 n1_M2_129660_113460 0 1.341862e-06
I4868 n1_M2_129660_115620 0 1.443915e-06
I4869 n1_M2_129660_117780 0 1.538804e-06
I4870 n1_M2_129660_119940 0 1.567862e-06
I4871 n1_M2_129660_122100 0 1.485766e-06
I4872 n1_M2_129660_124260 0 1.289701e-06
I4873 n1_M2_129660_126420 0 1.024247e-06
I4874 n1_M2_129660_127500 0 7.562449e-07
I4875 n1_M2_129660_129660 0 5.387204e-07
I4876 n1_M2_129660_131820 0 3.897934e-07
I4877 n1_M2_129660_133980 0 2.966265e-07
I4878 n1_M2_129660_136140 0 2.343475e-07
I4879 n1_M2_129660_138300 0 1.833043e-07
I4880 n1_M2_129660_140460 0 1.357622e-07
I4881 n1_M2_129660_141540 0 9.335771e-08
I4882 n1_M2_129660_143700 0 6.131348e-08
I4883 n1_M2_129660_145860 0 4.415911e-08
I4884 n1_M2_131820_60 0 2.622999e-08
I4885 n1_M2_131820_2220 0 3.828076e-08
I4886 n1_M2_131820_4380 0 6.163975e-08
I4887 n1_M2_131820_5460 0 9.441488e-08
I4888 n1_M2_131820_7620 0 1.333673e-07
I4889 n1_M2_131820_9780 0 1.743250e-07
I4890 n1_M2_131820_11940 0 2.127561e-07
I4891 n1_M2_131820_14100 0 2.441420e-07
I4892 n1_M2_131820_16260 0 2.645839e-07
I4893 n1_M2_131820_18420 0 2.721539e-07
I4894 n1_M2_131820_19500 0 2.683664e-07
I4895 n1_M2_131820_21660 0 2.582107e-07
I4896 n1_M2_131820_23820 0 2.480057e-07
I4897 n1_M2_131820_25980 0 2.423559e-07
I4898 n1_M2_131820_28140 0 2.424409e-07
I4899 n1_M2_131820_30300 0 2.468372e-07
I4900 n1_M2_131820_32460 0 2.539825e-07
I4901 n1_M2_131820_33540 0 2.640406e-07
I4902 n1_M2_131820_35700 0 2.786056e-07
I4903 n1_M2_131820_37860 0 2.986579e-07
I4904 n1_M2_131820_40020 0 3.229691e-07
I4905 n1_M2_131820_42180 0 3.486375e-07
I4906 n1_M2_131820_44340 0 3.738065e-07
I4907 n1_M2_131820_46500 0 4.003412e-07
I4908 n1_M2_131820_47580 0 4.349643e-07
I4909 n1_M2_131820_49740 0 4.886573e-07
I4910 n1_M2_131820_51900 0 5.744805e-07
I4911 n1_M2_131820_54060 0 7.040844e-07
I4912 n1_M2_131820_56220 0 8.828746e-07
I4913 n1_M2_131820_58380 0 1.105795e-06
I4914 n1_M2_131820_59460 0 1.357765e-06
I4915 n1_M2_131820_61620 0 1.620024e-06
I4916 n1_M2_131820_63780 0 1.878026e-06
I4917 n1_M2_131820_65940 0 2.122758e-06
I4918 n1_M2_131820_68100 0 2.343933e-06
I4919 n1_M2_131820_70260 0 2.523073e-06
I4920 n1_M2_131820_72420 0 2.636119e-06
I4921 n1_M2_131820_73500 0 2.664340e-06
I4922 n1_M2_131820_75660 0 2.603570e-06
I4923 n1_M2_131820_77820 0 2.466108e-06
I4924 n1_M2_131820_79980 0 2.278643e-06
I4925 n1_M2_131820_82140 0 2.079673e-06
I4926 n1_M2_131820_84300 0 1.913652e-06
I4927 n1_M2_131820_86460 0 1.818437e-06
I4928 n1_M2_131820_87540 0 1.809930e-06
I4929 n1_M2_131820_89700 0 1.872922e-06
I4930 n1_M2_131820_91860 0 1.965853e-06
I4931 n1_M2_131820_94020 0 2.039781e-06
I4932 n1_M2_131820_96180 0 2.061594e-06
I4933 n1_M2_131820_98340 0 2.026647e-06
I4934 n1_M2_131820_100500 0 1.952337e-06
I4935 n1_M2_131820_101580 0 1.860096e-06
I4936 n1_M2_131820_103740 0 1.762428e-06
I4937 n1_M2_131820_105900 0 1.664023e-06
I4938 n1_M2_131820_108060 0 1.571981e-06
I4939 n1_M2_131820_110220 0 1.502798e-06
I4940 n1_M2_131820_112380 0 1.478757e-06
I4941 n1_M2_131820_113460 0 1.513638e-06
I4942 n1_M2_131820_115620 0 1.595104e-06
I4943 n1_M2_131820_117780 0 1.676868e-06
I4944 n1_M2_131820_119940 0 1.692929e-06
I4945 n1_M2_131820_122100 0 1.592065e-06
I4946 n1_M2_131820_124260 0 1.370565e-06
I4947 n1_M2_131820_126420 0 1.076951e-06
I4948 n1_M2_131820_127500 0 7.835993e-07
I4949 n1_M2_131820_129660 0 5.473280e-07
I4950 n1_M2_131820_131820 0 3.871084e-07
I4951 n1_M2_131820_133980 0 2.888061e-07
I4952 n1_M2_131820_136140 0 2.254868e-07
I4953 n1_M2_131820_138300 0 1.755994e-07
I4954 n1_M2_131820_140460 0 1.300119e-07
I4955 n1_M2_131820_141540 0 8.950670e-08
I4956 n1_M2_131820_143700 0 5.886758e-08
I4957 n1_M2_131820_145860 0 4.244156e-08
I4958 n1_M2_133980_60 0 2.453702e-08
I4959 n1_M2_133980_2220 0 3.591281e-08
I4960 n1_M2_133980_4380 0 5.796505e-08
I4961 n1_M2_133980_5460 0 8.890610e-08
I4962 n1_M2_133980_7620 0 1.256781e-07
I4963 n1_M2_133980_9780 0 1.643696e-07
I4964 n1_M2_133980_11940 0 2.007696e-07
I4965 n1_M2_133980_14100 0 2.306810e-07
I4966 n1_M2_133980_16260 0 2.504052e-07
I4967 n1_M2_133980_18420 0 2.579485e-07
I4968 n1_M2_133980_19500 0 2.544199e-07
I4969 n1_M2_133980_21660 0 2.441913e-07
I4970 n1_M2_133980_23820 0 2.330702e-07
I4971 n1_M2_133980_25980 0 2.255714e-07
I4972 n1_M2_133980_28140 0 2.232831e-07
I4973 n1_M2_133980_30300 0 2.254025e-07
I4974 n1_M2_133980_32460 0 2.307441e-07
I4975 n1_M2_133980_33540 0 2.393510e-07
I4976 n1_M2_133980_35700 0 2.524249e-07
I4977 n1_M2_133980_37860 0 2.707825e-07
I4978 n1_M2_133980_40020 0 2.934992e-07
I4979 n1_M2_133980_42180 0 3.181390e-07
I4980 n1_M2_133980_44340 0 3.428651e-07
I4981 n1_M2_133980_46500 0 3.688343e-07
I4982 n1_M2_133980_47580 0 4.017708e-07
I4983 n1_M2_133980_49740 0 4.525848e-07
I4984 n1_M2_133980_51900 0 5.366314e-07
I4985 n1_M2_133980_54060 0 6.707695e-07
I4986 n1_M2_133980_56220 0 8.669869e-07
I4987 n1_M2_133980_58380 0 1.124033e-06
I4988 n1_M2_133980_59460 0 1.423206e-06
I4989 n1_M2_133980_61620 0 1.733564e-06
I4990 n1_M2_133980_63780 0 2.024851e-06
I4991 n1_M2_133980_65940 0 2.277820e-06
I4992 n1_M2_133980_68100 0 2.483686e-06
I4993 n1_M2_133980_70260 0 2.635584e-06
I4994 n1_M2_133980_72420 0 2.723274e-06
I4995 n1_M2_133980_73500 0 2.736610e-06
I4996 n1_M2_133980_75660 0 2.672938e-06
I4997 n1_M2_133980_77820 0 2.542153e-06
I4998 n1_M2_133980_79980 0 2.368878e-06
I4999 n1_M2_133980_82140 0 2.192062e-06
I5000 n1_M2_133980_84300 0 2.058663e-06
I5001 n1_M2_133980_86460 0 2.008936e-06
I5002 n1_M2_133980_87540 0 2.058218e-06
I5003 n1_M2_133980_89700 0 2.185459e-06
I5004 n1_M2_133980_91860 0 2.338197e-06
I5005 n1_M2_133980_94020 0 2.455710e-06
I5006 n1_M2_133980_96180 0 2.498406e-06
I5007 n1_M2_133980_98340 0 2.463561e-06
I5008 n1_M2_133980_100500 0 2.375783e-06
I5009 n1_M2_133980_101580 0 2.262222e-06
I5010 n1_M2_133980_103740 0 2.135578e-06
I5011 n1_M2_133980_105900 0 1.997364e-06
I5012 n1_M2_133980_108060 0 1.853587e-06
I5013 n1_M2_133980_110220 0 1.724995e-06
I5014 n1_M2_133980_112380 0 1.641896e-06
I5015 n1_M2_133980_113460 0 1.625487e-06
I5016 n1_M2_133980_115620 0 1.666830e-06
I5017 n1_M2_133980_117780 0 1.718691e-06
I5018 n1_M2_133980_119940 0 1.712064e-06
I5019 n1_M2_133980_122100 0 1.593434e-06
I5020 n1_M2_133980_124260 0 1.358632e-06
I5021 n1_M2_133980_126420 0 1.056602e-06
I5022 n1_M2_133980_127500 0 7.594853e-07
I5023 n1_M2_133980_129660 0 5.228111e-07
I5024 n1_M2_133980_131820 0 3.640279e-07
I5025 n1_M2_133980_133980 0 2.680886e-07
I5026 n1_M2_133980_136140 0 2.077950e-07
I5027 n1_M2_133980_138300 0 1.614731e-07
I5028 n1_M2_133980_140460 0 1.196274e-07
I5029 n1_M2_133980_141540 0 8.249732e-08
I5030 n1_M2_133980_143700 0 5.436542e-08
I5031 n1_M2_133980_145860 0 3.925896e-08
I5032 n1_M2_136140_60 0 2.160794e-08
I5033 n1_M2_136140_2220 0 3.175686e-08
I5034 n1_M2_136140_4380 0 5.141162e-08
I5035 n1_M2_136140_5460 0 7.892493e-08
I5036 n1_M2_136140_7620 0 1.115028e-07
I5037 n1_M2_136140_9780 0 1.456583e-07
I5038 n1_M2_136140_11940 0 1.777895e-07
I5039 n1_M2_136140_14100 0 2.044237e-07
I5040 n1_M2_136140_16260 0 2.224524e-07
I5041 n1_M2_136140_18420 0 2.299855e-07
I5042 n1_M2_136140_19500 0 2.275478e-07
I5043 n1_M2_136140_21660 0 2.184419e-07
I5044 n1_M2_136140_23820 0 2.074860e-07
I5045 n1_M2_136140_25980 0 1.988398e-07
I5046 n1_M2_136140_28140 0 1.945259e-07
I5047 n1_M2_136140_30300 0 1.945786e-07
I5048 n1_M2_136140_32460 0 1.983901e-07
I5049 n1_M2_136140_33540 0 2.058948e-07
I5050 n1_M2_136140_35700 0 2.176798e-07
I5051 n1_M2_136140_37860 0 2.340636e-07
I5052 n1_M2_136140_40020 0 2.541918e-07
I5053 n1_M2_136140_42180 0 2.761324e-07
I5054 n1_M2_136140_44340 0 2.983353e-07
I5055 n1_M2_136140_46500 0 3.215014e-07
I5056 n1_M2_136140_47580 0 3.502057e-07
I5057 n1_M2_136140_49740 0 3.943884e-07
I5058 n1_M2_136140_51900 0 4.700176e-07
I5059 n1_M2_136140_54060 0 5.972877e-07
I5060 n1_M2_136140_56220 0 7.939497e-07
I5061 n1_M2_136140_58380 0 1.064193e-06
I5062 n1_M2_136140_59460 0 1.390115e-06
I5063 n1_M2_136140_61620 0 1.734197e-06
I5064 n1_M2_136140_63780 0 2.054197e-06
I5065 n1_M2_136140_65940 0 2.320057e-06
I5066 n1_M2_136140_68100 0 2.519939e-06
I5067 n1_M2_136140_70260 0 2.653084e-06
I5068 n1_M2_136140_72420 0 2.720055e-06
I5069 n1_M2_136140_73500 0 2.720045e-06
I5070 n1_M2_136140_75660 0 2.655093e-06
I5071 n1_M2_136140_77820 0 2.535707e-06
I5072 n1_M2_136140_79980 0 2.385059e-06
I5073 n1_M2_136140_82140 0 2.239926e-06
I5074 n1_M2_136140_84300 0 2.144781e-06
I5075 n1_M2_136140_86460 0 2.137341e-06
I5076 n1_M2_136140_87540 0 2.230339e-06
I5077 n1_M2_136140_89700 0 2.399444e-06
I5078 n1_M2_136140_91860 0 2.587740e-06
I5079 n1_M2_136140_94020 0 2.730062e-06
I5080 n1_M2_136140_96180 0 2.784999e-06
I5081 n1_M2_136140_98340 0 2.751891e-06
I5082 n1_M2_136140_100500 0 2.659059e-06
I5083 n1_M2_136140_101580 0 2.534835e-06
I5084 n1_M2_136140_103740 0 2.388761e-06
I5085 n1_M2_136140_105900 0 2.217641e-06
I5086 n1_M2_136140_108060 0 2.026003e-06
I5087 n1_M2_136140_110220 0 1.838569e-06
I5088 n1_M2_136140_112380 0 1.692984e-06
I5089 n1_M2_136140_113460 0 1.617358e-06
I5090 n1_M2_136140_115620 0 1.607414e-06
I5091 n1_M2_136140_117780 0 1.619131e-06
I5092 n1_M2_136140_119940 0 1.586604e-06
I5093 n1_M2_136140_122100 0 1.458792e-06
I5094 n1_M2_136140_124260 0 1.231233e-06
I5095 n1_M2_136140_126420 0 9.484136e-07
I5096 n1_M2_136140_127500 0 6.751399e-07
I5097 n1_M2_136140_129660 0 4.601305e-07
I5098 n1_M2_136140_131820 0 3.174013e-07
I5099 n1_M2_136140_133980 0 2.321892e-07
I5100 n1_M2_136140_136140 0 1.794746e-07
I5101 n1_M2_136140_138300 0 1.395382e-07
I5102 n1_M2_136140_140460 0 1.036135e-07
I5103 n1_M2_136140_141540 0 7.167094e-08
I5104 n1_M2_136140_143700 0 4.738673e-08
I5105 n1_M2_136140_145860 0 3.431230e-08
I5106 n1_M2_138300_60 0 1.769150e-08
I5107 n1_M2_138300_2220 0 2.611490e-08
I5108 n1_M2_138300_4380 0 4.239837e-08
I5109 n1_M2_138300_5460 0 6.510221e-08
I5110 n1_M2_138300_7620 0 9.182191e-08
I5111 n1_M2_138300_9780 0 1.196680e-07
I5112 n1_M2_138300_11940 0 1.458510e-07
I5113 n1_M2_138300_14100 0 1.678436e-07
I5114 n1_M2_138300_16260 0 1.833356e-07
I5115 n1_M2_138300_18420 0 1.906671e-07
I5116 n1_M2_138300_19500 0 1.897626e-07
I5117 n1_M2_138300_21660 0 1.826943e-07
I5118 n1_M2_138300_23820 0 1.730452e-07
I5119 n1_M2_138300_25980 0 1.643712e-07
I5120 n1_M2_138300_28140 0 1.589296e-07
I5121 n1_M2_138300_30300 0 1.574717e-07
I5122 n1_M2_138300_32460 0 1.599410e-07
I5123 n1_M2_138300_33540 0 1.662135e-07
I5124 n1_M2_138300_35700 0 1.763165e-07
I5125 n1_M2_138300_37860 0 1.900549e-07
I5126 n1_M2_138300_40020 0 2.065726e-07
I5127 n1_M2_138300_42180 0 2.244248e-07
I5128 n1_M2_138300_44340 0 2.424805e-07
I5129 n1_M2_138300_46500 0 2.612086e-07
I5130 n1_M2_138300_47580 0 2.840568e-07
I5131 n1_M2_138300_49740 0 3.193116e-07
I5132 n1_M2_138300_51900 0 3.817022e-07
I5133 n1_M2_138300_54060 0 4.918374e-07
I5134 n1_M2_138300_56220 0 6.703692e-07
I5135 n1_M2_138300_58380 0 9.262456e-07
I5136 n1_M2_138300_59460 0 1.245677e-06
I5137 n1_M2_138300_61620 0 1.591535e-06
I5138 n1_M2_138300_63780 0 1.917153e-06
I5139 n1_M2_138300_65940 0 2.185735e-06
I5140 n1_M2_138300_68100 0 2.381047e-06
I5141 n1_M2_138300_70260 0 2.503364e-06
I5142 n1_M2_138300_72420 0 2.558868e-06
I5143 n1_M2_138300_73500 0 2.553310e-06
I5144 n1_M2_138300_75660 0 2.493073e-06
I5145 n1_M2_138300_77820 0 2.389798e-06
I5146 n1_M2_138300_79980 0 2.265004e-06
I5147 n1_M2_138300_82140 0 2.151521e-06
I5148 n1_M2_138300_84300 0 2.088196e-06
I5149 n1_M2_138300_86460 0 2.107060e-06
I5150 n1_M2_138300_87540 0 2.217344e-06
I5151 n1_M2_138300_89700 0 2.394796e-06
I5152 n1_M2_138300_91860 0 2.585616e-06
I5153 n1_M2_138300_94020 0 2.728894e-06
I5154 n1_M2_138300_96180 0 2.786680e-06
I5155 n1_M2_138300_98340 0 2.759687e-06
I5156 n1_M2_138300_100500 0 2.674865e-06
I5157 n1_M2_138300_101580 0 2.556447e-06
I5158 n1_M2_138300_103740 0 2.408376e-06
I5159 n1_M2_138300_105900 0 2.222891e-06
I5160 n1_M2_138300_108060 0 2.003314e-06
I5161 n1_M2_138300_110220 0 1.776829e-06
I5162 n1_M2_138300_112380 0 1.585287e-06
I5163 n1_M2_138300_113460 0 1.460975e-06
I5164 n1_M2_138300_115620 0 1.404298e-06
I5165 n1_M2_138300_117780 0 1.378210e-06
I5166 n1_M2_138300_119940 0 1.325802e-06
I5167 n1_M2_138300_122100 0 1.202972e-06
I5168 n1_M2_138300_124260 0 1.005032e-06
I5169 n1_M2_138300_126420 0 7.677007e-07
I5170 n1_M2_138300_127500 0 5.426540e-07
I5171 n1_M2_138300_129660 0 3.677866e-07
I5172 n1_M2_138300_131820 0 2.528229e-07
I5173 n1_M2_138300_133980 0 1.847855e-07
I5174 n1_M2_138300_136140 0 1.430451e-07
I5175 n1_M2_138300_138300 0 1.115591e-07
I5176 n1_M2_138300_140460 0 8.316388e-08
I5177 n1_M2_138300_141540 0 5.777474e-08
I5178 n1_M2_138300_143700 0 3.836942e-08
I5179 n1_M2_138300_145860 0 2.788307e-08
I5180 n1_M2_140460_60 0 1.334576e-08
I5181 n1_M2_140460_2220 0 1.977613e-08
I5182 n1_M2_140460_4380 0 3.217736e-08
I5183 n1_M2_140460_5460 0 4.938352e-08
I5184 n1_M2_140460_7620 0 6.948553e-08
I5185 n1_M2_140460_9780 0 9.029019e-08
I5186 n1_M2_140460_11940 0 1.098576e-07
I5187 n1_M2_140460_14100 0 1.265839e-07
I5188 n1_M2_140460_16260 0 1.389500e-07
I5189 n1_M2_140460_18420 0 1.456094e-07
I5190 n1_M2_140460_19500 0 1.460581e-07
I5191 n1_M2_140460_21660 0 1.413007e-07
I5192 n1_M2_140460_23820 0 1.337164e-07
I5193 n1_M2_140460_25980 0 1.260906e-07
I5194 n1_M2_140460_28140 0 1.205924e-07
I5195 n1_M2_140460_30300 0 1.183522e-07
I5196 n1_M2_140460_32460 0 1.196842e-07
I5197 n1_M2_140460_33540 0 1.244712e-07
I5198 n1_M2_140460_35700 0 1.324067e-07
I5199 n1_M2_140460_37860 0 1.429770e-07
I5200 n1_M2_140460_40020 0 1.553614e-07
I5201 n1_M2_140460_42180 0 1.685323e-07
I5202 n1_M2_140460_44340 0 1.817628e-07
I5203 n1_M2_140460_46500 0 1.954179e-07
I5204 n1_M2_140460_47580 0 2.119572e-07
I5205 n1_M2_140460_49740 0 2.376965e-07
I5206 n1_M2_140460_51900 0 2.847287e-07
I5207 n1_M2_140460_54060 0 3.712702e-07
I5208 n1_M2_140460_56220 0 5.172967e-07
I5209 n1_M2_140460_58380 0 7.341368e-07
I5210 n1_M2_140460_59460 0 1.013306e-06
I5211 n1_M2_140460_61620 0 1.323685e-06
I5212 n1_M2_140460_63780 0 1.622191e-06
I5213 n1_M2_140460_65940 0 1.871717e-06
I5214 n1_M2_140460_68100 0 2.053413e-06
I5215 n1_M2_140460_70260 0 2.165807e-06
I5216 n1_M2_140460_72420 0 2.215966e-06
I5217 n1_M2_140460_73500 0 2.212186e-06
I5218 n1_M2_140460_75660 0 2.162880e-06
I5219 n1_M2_140460_77820 0 2.079686e-06
I5220 n1_M2_140460_79980 0 1.981518e-06
I5221 n1_M2_140460_82140 0 1.895857e-06
I5222 n1_M2_140460_84300 0 1.854091e-06
I5223 n1_M2_140460_86460 0 1.881005e-06
I5224 n1_M2_140460_87540 0 1.982406e-06
I5225 n1_M2_140460_89700 0 2.137275e-06
I5226 n1_M2_140460_91860 0 2.301220e-06
I5227 n1_M2_140460_94020 0 2.424647e-06
I5228 n1_M2_140460_96180 0 2.477105e-06
I5229 n1_M2_140460_98340 0 2.459664e-06
I5230 n1_M2_140460_100500 0 2.393589e-06
I5231 n1_M2_140460_101580 0 2.295507e-06
I5232 n1_M2_140460_103740 0 2.163562e-06
I5233 n1_M2_140460_105900 0 1.987273e-06
I5234 n1_M2_140460_108060 0 1.769361e-06
I5235 n1_M2_140460_110220 0 1.536840e-06
I5236 n1_M2_140460_112380 0 1.330907e-06
I5237 n1_M2_140460_113460 0 1.183761e-06
I5238 n1_M2_140460_115620 0 1.099180e-06
I5239 n1_M2_140460_117780 0 1.049119e-06
I5240 n1_M2_140460_119940 0 9.893143e-07
I5241 n1_M2_140460_122100 0 8.853341e-07
I5242 n1_M2_140460_124260 0 7.324469e-07
I5243 n1_M2_140460_126420 0 5.556373e-07
I5244 n1_M2_140460_127500 0 3.911175e-07
I5245 n1_M2_140460_129660 0 2.648038e-07
I5246 n1_M2_140460_131820 0 1.824423e-07
I5247 n1_M2_140460_133980 0 1.339553e-07
I5248 n1_M2_140460_136140 0 1.042429e-07
I5249 n1_M2_140460_138300 0 8.172155e-08
I5250 n1_M2_140460_140460 0 6.123315e-08
I5251 n1_M2_140460_141540 0 4.275653e-08
I5252 n1_M2_140460_143700 0 2.853838e-08
I5253 n1_M2_140460_145860 0 2.082091e-08
I5254 n1_M2_141540_60 0 9.277495e-09
I5255 n1_M2_141540_2220 0 1.378957e-08
I5256 n1_M2_141540_4380 0 2.246812e-08
I5257 n1_M2_141540_5460 0 3.444515e-08
I5258 n1_M2_141540_7620 0 4.832967e-08
I5259 n1_M2_141540_9780 0 6.259772e-08
I5260 n1_M2_141540_11940 0 7.603360e-08
I5261 n1_M2_141540_14100 0 8.775424e-08
I5262 n1_M2_141540_16260 0 9.687292e-08
I5263 n1_M2_141540_18420 0 1.023848e-07
I5264 n1_M2_141540_19500 0 1.036098e-07
I5265 n1_M2_141540_21660 0 1.008358e-07
I5266 n1_M2_141540_23820 0 9.547217e-08
I5267 n1_M2_141540_25980 0 8.951018e-08
I5268 n1_M2_141540_28140 0 8.476193e-08
I5269 n1_M2_141540_30300 0 8.239040e-08
I5270 n1_M2_141540_32460 0 8.286758e-08
I5271 n1_M2_141540_33540 0 8.612857e-08
I5272 n1_M2_141540_35700 0 9.177225e-08
I5273 n1_M2_141540_37860 0 9.919835e-08
I5274 n1_M2_141540_40020 0 1.076889e-07
I5275 n1_M2_141540_42180 0 1.165343e-07
I5276 n1_M2_141540_44340 0 1.253085e-07
I5277 n1_M2_141540_46500 0 1.343139e-07
I5278 n1_M2_141540_47580 0 1.452200e-07
I5279 n1_M2_141540_49740 0 1.624594e-07
I5280 n1_M2_141540_51900 0 1.949668e-07
I5281 n1_M2_141540_54060 0 2.569591e-07
I5282 n1_M2_141540_56220 0 3.650992e-07
I5283 n1_M2_141540_58380 0 5.305156e-07
I5284 n1_M2_141540_59460 0 7.493124e-07
I5285 n1_M2_141540_61620 0 9.988242e-07
I5286 n1_M2_141540_63780 0 1.244637e-06
I5287 n1_M2_141540_65940 0 1.454685e-06
I5288 n1_M2_141540_68100 0 1.610491e-06
I5289 n1_M2_141540_70260 0 1.708492e-06
I5290 n1_M2_141540_72420 0 1.754007e-06
I5291 n1_M2_141540_73500 0 1.754821e-06
I5292 n1_M2_141540_75660 0 1.719101e-06
I5293 n1_M2_141540_77820 0 1.657111e-06
I5294 n1_M2_141540_79980 0 1.584256e-06
I5295 n1_M2_141540_82140 0 1.521929e-06
I5296 n1_M2_141540_84300 0 1.493526e-06
I5297 n1_M2_141540_86460 0 1.516504e-06
I5298 n1_M2_141540_87540 0 1.593936e-06
I5299 n1_M2_141540_89700 0 1.709787e-06
I5300 n1_M2_141540_91860 0 1.831887e-06
I5301 n1_M2_141540_94020 0 1.924847e-06
I5302 n1_M2_141540_96180 0 1.967143e-06
I5303 n1_M2_141540_98340 0 1.959437e-06
I5304 n1_M2_141540_100500 0 1.915607e-06
I5305 n1_M2_141540_101580 0 1.844256e-06
I5306 n1_M2_141540_103740 0 1.739535e-06
I5307 n1_M2_141540_105900 0 1.590683e-06
I5308 n1_M2_141540_108060 0 1.400287e-06
I5309 n1_M2_141540_110220 0 1.192540e-06
I5310 n1_M2_141540_112380 0 1.003533e-06
I5311 n1_M2_141540_113460 0 8.615075e-07
I5312 n1_M2_141540_115620 0 7.717190e-07
I5313 n1_M2_141540_117780 0 7.149192e-07
I5314 n1_M2_141540_119940 0 6.598789e-07
I5315 n1_M2_141540_122100 0 5.821110e-07
I5316 n1_M2_141540_124260 0 4.771569e-07
I5317 n1_M2_141540_126420 0 3.601185e-07
I5318 n1_M2_141540_127500 0 2.532477e-07
I5319 n1_M2_141540_129660 0 1.721084e-07
I5320 n1_M2_141540_131820 0 1.195379e-07
I5321 n1_M2_141540_133980 0 8.862627e-08
I5322 n1_M2_141540_136140 0 6.955849e-08
I5323 n1_M2_141540_138300 0 5.490191e-08
I5324 n1_M2_141540_140460 0 4.137602e-08
I5325 n1_M2_141540_141540 0 2.904592e-08
I5326 n1_M2_141540_143700 0 1.948486e-08
I5327 n1_M2_141540_145860 0 1.427034e-08
I5328 n1_M2_143700_60 0 6.158678e-09
I5329 n1_M2_143700_2220 0 9.174569e-09
I5330 n1_M2_143700_4380 0 1.495916e-08
I5331 n1_M2_143700_5460 0 2.289889e-08
I5332 n1_M2_143700_7620 0 3.203101e-08
I5333 n1_M2_143700_9780 0 4.134929e-08
I5334 n1_M2_143700_11940 0 5.013993e-08
I5335 n1_M2_143700_14100 0 5.797443e-08
I5336 n1_M2_143700_16260 0 6.437912e-08
I5337 n1_M2_143700_18420 0 6.864347e-08
I5338 n1_M2_143700_19500 0 7.009926e-08
I5339 n1_M2_143700_21660 0 6.866438e-08
I5340 n1_M2_143700_23820 0 6.510481e-08
I5341 n1_M2_143700_25980 0 6.076181e-08
I5342 n1_M2_143700_28140 0 5.701684e-08
I5343 n1_M2_143700_30300 0 5.487468e-08
I5344 n1_M2_143700_32460 0 5.482019e-08
I5345 n1_M2_143700_33540 0 5.684856e-08
I5346 n1_M2_143700_35700 0 6.060286e-08
I5347 n1_M2_143700_37860 0 6.553920e-08
I5348 n1_M2_143700_40020 0 7.106960e-08
I5349 n1_M2_143700_42180 0 7.669748e-08
I5350 n1_M2_143700_44340 0 8.217627e-08
I5351 n1_M2_143700_46500 0 8.775217e-08
I5352 n1_M2_143700_47580 0 9.453984e-08
I5353 n1_M2_143700_49740 0 1.055200e-07
I5354 n1_M2_143700_51900 0 1.269033e-07
I5355 n1_M2_143700_54060 0 1.689834e-07
I5356 n1_M2_143700_56220 0 2.444677e-07
I5357 n1_M2_143700_58380 0 3.628742e-07
I5358 n1_M2_143700_59460 0 5.232637e-07
I5359 n1_M2_143700_61620 0 7.105298e-07
I5360 n1_M2_143700_63780 0 8.994858e-07
I5361 n1_M2_143700_65940 0 1.064896e-06
I5362 n1_M2_143700_68100 0 1.190571e-06
I5363 n1_M2_143700_70260 0 1.271744e-06
I5364 n1_M2_143700_72420 0 1.311520e-06
I5365 n1_M2_143700_73500 0 1.315984e-06
I5366 n1_M2_143700_75660 0 1.291977e-06
I5367 n1_M2_143700_77820 0 1.247854e-06
I5368 n1_M2_143700_79980 0 1.195545e-06
I5369 n1_M2_143700_82140 0 1.150943e-06
I5370 n1_M2_143700_84300 0 1.130618e-06
I5371 n1_M2_143700_86460 0 1.146101e-06
I5372 n1_M2_143700_87540 0 1.198658e-06
I5373 n1_M2_143700_89700 0 1.277037e-06
I5374 n1_M2_143700_91860 0 1.359915e-06
I5375 n1_M2_143700_94020 0 1.424268e-06
I5376 n1_M2_143700_96180 0 1.456128e-06
I5377 n1_M2_143700_98340 0 1.455533e-06
I5378 n1_M2_143700_100500 0 1.430048e-06
I5379 n1_M2_143700_101580 0 1.382300e-06
I5380 n1_M2_143700_103740 0 1.304720e-06
I5381 n1_M2_143700_105900 0 1.187841e-06
I5382 n1_M2_143700_108060 0 1.034275e-06
I5383 n1_M2_143700_110220 0 8.642390e-07
I5384 n1_M2_143700_112380 0 7.070454e-07
I5385 n1_M2_143700_113460 0 5.855030e-07
I5386 n1_M2_143700_115620 0 5.049012e-07
I5387 n1_M2_143700_117780 0 4.527376e-07
I5388 n1_M2_143700_119940 0 4.081622e-07
I5389 n1_M2_143700_122100 0 3.546265e-07
I5390 n1_M2_143700_124260 0 2.881626e-07
I5391 n1_M2_143700_126420 0 2.168003e-07
I5392 n1_M2_143700_127500 0 1.528787e-07
I5393 n1_M2_143700_129660 0 1.048493e-07
I5394 n1_M2_143700_131820 0 7.385724e-08
I5395 n1_M2_143700_133980 0 5.556559e-08
I5396 n1_M2_143700_136140 0 4.410688e-08
I5397 n1_M2_143700_138300 0 3.508979e-08
I5398 n1_M2_143700_140460 0 2.660571e-08
I5399 n1_M2_143700_141540 0 1.877517e-08
I5400 n1_M2_143700_143700 0 1.265425e-08
I5401 n1_M2_143700_145860 0 9.299787e-09
I5402 n1_M2_145860_60 0 4.477291e-09
I5403 n1_M2_145860_2220 0 6.679166e-09
I5404 n1_M2_145860_4380 0 1.089276e-08
I5405 n1_M2_145860_5460 0 1.665057e-08
I5406 n1_M2_145860_7620 0 2.323073e-08
I5407 n1_M2_145860_9780 0 2.990621e-08
I5408 n1_M2_145860_11940 0 3.621330e-08
I5409 n1_M2_145860_14100 0 4.193290e-08
I5410 n1_M2_145860_16260 0 4.678890e-08
I5411 n1_M2_145860_18420 0 5.024207e-08
I5412 n1_M2_145860_19500 0 5.168340e-08
I5413 n1_M2_145860_21660 0 5.089481e-08
I5414 n1_M2_145860_23820 0 4.833016e-08
I5415 n1_M2_145860_25980 0 4.496652e-08
I5416 n1_M2_145860_28140 0 4.190098e-08
I5417 n1_M2_145860_30300 0 3.999278e-08
I5418 n1_M2_145860_32460 0 3.969769e-08
I5419 n1_M2_145860_33540 0 4.104814e-08
I5420 n1_M2_145860_35700 0 4.374746e-08
I5421 n1_M2_145860_37860 0 4.732246e-08
I5422 n1_M2_145860_40020 0 5.127471e-08
I5423 n1_M2_145860_42180 0 5.521504e-08
I5424 n1_M2_145860_44340 0 5.897596e-08
I5425 n1_M2_145860_46500 0 6.276535e-08
I5426 n1_M2_145860_47580 0 6.740945e-08
I5427 n1_M2_145860_49740 0 7.510503e-08
I5428 n1_M2_145860_51900 0 9.050946e-08
I5429 n1_M2_145860_54060 0 1.215457e-07
I5430 n1_M2_145860_56220 0 1.783396e-07
I5431 n1_M2_145860_58380 0 2.690419e-07
I5432 n1_M2_145860_59460 0 3.940480e-07
I5433 n1_M2_145860_61620 0 5.425738e-07
I5434 n1_M2_145860_63780 0 6.951700e-07
I5435 n1_M2_145860_65940 0 8.312540e-07
I5436 n1_M2_145860_68100 0 9.366195e-07
I5437 n1_M2_145860_70260 0 1.006119e-06
I5438 n1_M2_145860_72420 0 1.041501e-06
I5439 n1_M2_145860_73500 0 1.047585e-06
I5440 n1_M2_145860_75660 0 1.030150e-06
I5441 n1_M2_145860_77820 0 9.962319e-07
I5442 n1_M2_145860_79980 0 9.555915e-07
I5443 n1_M2_145860_82140 0 9.208304e-07
I5444 n1_M2_145860_84300 0 9.045584e-07
I5445 n1_M2_145860_86460 0 9.150057e-07
I5446 n1_M2_145860_87540 0 9.525636e-07
I5447 n1_M2_145860_89700 0 1.008837e-06
I5448 n1_M2_145860_91860 0 1.068737e-06
I5449 n1_M2_145860_94020 0 1.116252e-06
I5450 n1_M2_145860_96180 0 1.141643e-06
I5451 n1_M2_145860_98340 0 1.144539e-06
I5452 n1_M2_145860_100500 0 1.129021e-06
I5453 n1_M2_145860_101580 0 1.094726e-06
I5454 n1_M2_145860_103740 0 1.033741e-06
I5455 n1_M2_145860_105900 0 9.378442e-07
I5456 n1_M2_145860_108060 0 8.096700e-07
I5457 n1_M2_145860_110220 0 6.665971e-07
I5458 n1_M2_145860_112380 0 5.332441e-07
I5459 n1_M2_145860_113460 0 4.286358e-07
I5460 n1_M2_145860_115620 0 3.576803e-07
I5461 n1_M2_145860_117780 0 3.114707e-07
I5462 n1_M2_145860_119940 0 2.748245e-07
I5463 n1_M2_145860_122100 0 2.355425e-07
I5464 n1_M2_145860_124260 0 1.900463e-07
I5465 n1_M2_145860_126420 0 1.428164e-07
I5466 n1_M2_145860_127500 0 1.012229e-07
I5467 n1_M2_145860_129660 0 7.023030e-08
I5468 n1_M2_145860_131820 0 5.026383e-08
I5469 n1_M2_145860_133980 0 3.839458e-08
I5470 n1_M2_145860_136140 0 3.081064e-08
I5471 n1_M2_145860_138300 0 2.468490e-08
I5472 n1_M2_145860_140460 0 1.881072e-08
I5473 n1_M2_145860_141540 0 1.332915e-08
I5474 n1_M2_145860_143700 0 9.015678e-09
I5475 n1_M2_145860_145860 0 6.642513e-09
.op
.end
