* Small BeGAN-style power grid benchmark (connected subgraph)
* Source: BeGAN Power Grid Benchmarks (ASAP7), UMN-EDA
* https://github.com/UMN-EDA/BeGAN-benchmarks
* Original: dynamic_node_reg_grid.sp (real circuit)
* Elements: R (resistors/vias), I (current loads), V (supply)

R0 n1_M2_95100_71340 n1_M2_96180_71340 0.988200
R1 n1_M2_96180_71340 n1_M2_97260_71340 0.988200
R2 n1_M2_95100_72420 n1_M2_96180_72420 0.988200
R3 n1_M2_96180_72420 n1_M2_97260_72420 0.988200
R4 n1_M2_95100_79980 n1_M2_96180_79980 0.988200
R5 n1_M2_96180_79980 n1_M2_97260_79980 0.988200
R6 n1_M2_94020_81060 n1_M2_95100_81060 0.988200
R7 n1_M2_95100_81060 n1_M2_96180_81060 0.988200
R8 n1_M2_96180_81060 n1_M2_97260_81060 0.988200
R9 n1_M2_97260_81060 n1_M2_98340_81060 0.988200
R10 n1_M2_92940_82140 n1_M2_94020_82140 0.988200
R11 n1_M2_94020_82140 n1_M2_95100_82140 0.988200
R12 n1_M2_95100_82140 n1_M2_96180_82140 0.988200
R13 n1_M2_96180_82140 n1_M2_97260_82140 0.988200
R14 n1_M2_97260_82140 n1_M2_98340_82140 0.988200
R15 n1_M2_98340_82140 n1_M2_99420_82140 0.988200
R16 n1_M2_91860_83220 n1_M2_92940_83220 0.988200
R17 n1_M2_92940_83220 n1_M2_94020_83220 0.988200
R18 n1_M2_94020_83220 n1_M2_95100_83220 0.988200
R19 n1_M2_95100_83220 n1_M2_96180_83220 0.988200
R20 n1_M2_96180_83220 n1_M2_97260_83220 0.988200
R21 n1_M2_97260_83220 n1_M2_98340_83220 0.988200
R22 n1_M2_98340_83220 n1_M2_99420_83220 0.988200
R23 n1_M2_99420_83220 n1_M2_100500_83220 0.988200
R24 n1_M2_92940_84300 n1_M2_94020_84300 0.988200
R25 n1_M2_94020_84300 n1_M2_95100_84300 0.988200
R26 n1_M2_95100_84300 n1_M2_96180_84300 0.988200
R27 n1_M2_96180_84300 n1_M2_97260_84300 0.988200
R28 n1_M2_97260_84300 n1_M2_98340_84300 0.988200
R29 n1_M2_98340_84300 n1_M2_99420_84300 0.988200
R30 n1_M2_92940_85380 n1_M2_94020_85380 0.988200
R31 n1_M2_94020_85380 n1_M2_95100_85380 0.988200
R32 n1_M2_95100_85380 n1_M2_96180_85380 0.988200
R33 n1_M2_96180_85380 n1_M2_97260_85380 0.988200
R34 n1_M2_97260_85380 n1_M2_98340_85380 0.988200
R35 n1_M2_94020_86460 n1_M2_95100_86460 0.988200
R36 n1_M2_95100_86460 n1_M2_96180_86460 0.988200
R37 n1_M2_96180_86460 n1_M2_97260_86460 0.988200
R38 n1_M2_97260_86460 n1_M2_98340_86460 0.988200
R39 n1_M2_95100_87540 n1_M2_96180_87540 0.988200
R40 n1_M2_96180_87540 n1_M2_97260_87540 0.988200
R41 n1_M2_95100_92940 n1_M2_96180_92940 0.988200
R42 n1_M2_96180_92940 n1_M2_97260_92940 0.988200
R43 n1_M2_94020_94020 n1_M2_95100_94020 0.988200
R44 n1_M2_95100_94020 n1_M2_96180_94020 0.988200
R45 n1_M2_96180_94020 n1_M2_97260_94020 0.988200
R46 n1_M2_97260_94020 n1_M2_98340_94020 0.988200
R47 n1_M2_92940_95100 n1_M2_94020_95100 0.988200
R48 n1_M2_94020_95100 n1_M2_95100_95100 0.988200
R49 n1_M2_95100_95100 n1_M2_96180_95100 0.988200
R50 n1_M2_96180_95100 n1_M2_97260_95100 0.988200
R51 n1_M2_97260_95100 n1_M2_98340_95100 0.988200
R52 n1_M2_98340_95100 n1_M2_99420_95100 0.988200
R53 n1_M2_92940_96180 n1_M2_94020_96180 0.988200
R54 n1_M2_94020_96180 n1_M2_95100_96180 0.988200
R55 n1_M2_95100_96180 n1_M2_96180_96180 0.988200
R56 n1_M2_96180_96180 n1_M2_97260_96180 0.988200
R57 n1_M2_97260_96180 n1_M2_98340_96180 0.988200
R58 n1_M2_98340_96180 n1_M2_99420_96180 0.988200
R59 n1_M2_94020_97260 n1_M2_95100_97260 0.988200
R60 n1_M2_95100_97260 n1_M2_96180_97260 0.988200
R61 n1_M2_96180_97260 n1_M2_97260_97260 0.988200
R62 n1_M2_97260_97260 n1_M2_98340_97260 0.988200
R63 n1_M2_95100_98340 n1_M2_96180_98340 0.988200
R64 n1_M2_96180_98340 n1_M2_97260_98340 0.988200
R65 n1_M2_95100_106980 n1_M2_96180_106980 0.988200
R66 n1_M2_96180_106980 n1_M2_97260_106980 0.988200
R67 n1_M2_94020_108060 n1_M2_95100_108060 0.988200
R68 n1_M2_95100_108060 n1_M2_96180_108060 0.988200
R69 n1_M2_96180_108060 n1_M2_97260_108060 0.988200
R70 n1_M2_97260_108060 n1_M2_98340_108060 0.988200
R71 n1_M2_95100_109140 n1_M2_96180_109140 0.988200
R72 n1_M2_96180_109140 n1_M2_97260_109140 0.988200
R73 n1_M5_96060_69180 n1_M5_96060_70260 0.197640
R74 n1_M5_96060_70260 n1_M5_96060_71340 0.197640
R75 n1_M5_96060_71340 n1_M5_96060_72060 0.131760
R76 n1_M5_96060_72420 n1_M5_96060_72060 0.065880
R77 n1_M5_96060_72420 n1_M5_96060_73500 0.197640
R78 n1_M5_96060_73500 n1_M5_96060_74580 0.197640
R79 n1_M5_96060_77820 n1_M5_96060_78900 0.197640
R80 n1_M5_96060_78900 n1_M5_96060_79980 0.197640
R81 n1_M5_96060_79980 n1_M5_96060_81060 0.197640
R82 n1_M5_96060_81060 n1_M5_96060_82140 0.197640
R83 n1_M5_96060_82140 n1_M5_96060_83220 0.197640
R84 n1_M5_96060_83220 n1_M5_96060_84060 0.153720
R85 n1_M5_96060_84300 n1_M5_96060_84060 0.043920
R86 n1_M5_96060_84300 n1_M5_96060_85380 0.197640
R87 n1_M5_96060_85380 n1_M5_96060_86460 0.197640
R88 n1_M5_96060_86460 n1_M5_96060_87540 0.197640
R89 n1_M5_96060_87540 n1_M5_96060_88620 0.197640
R90 n1_M5_96060_88620 n1_M5_96060_89700 0.197640
R91 n1_M5_96060_89700 n1_M5_96060_90780 0.197640
R92 n1_M5_96060_90780 n1_M5_96060_91860 0.197640
R93 n1_M5_96060_91860 n1_M5_96060_92940 0.197640
R94 n1_M5_96060_92940 n1_M5_96060_94020 0.197640
R95 n1_M5_96060_94020 n1_M5_96060_95100 0.197640
R96 n1_M5_96060_95100 n1_M5_96060_96060 0.175680
R97 n1_M5_96060_96180 n1_M5_96060_96060 0.021960
R98 n1_M5_96060_96180 n1_M5_96060_97260 0.197640
R99 n1_M5_96060_97260 n1_M5_96060_98340 0.197640
R100 n1_M5_96060_98340 n1_M5_96060_99420 0.197640
R101 n1_M5_96060_99420 n1_M5_96060_100500 0.197640
R102 n1_M5_96060_104820 n1_M5_96060_105900 0.197640
R103 n1_M5_96060_105900 n1_M5_96060_106980 0.197640
R104 n1_M5_96060_106980 n1_M5_96060_108060 0.197640
R105 n1_M5_96060_108060 n1_M5_96060_109140 0.197640
R106 n1_M5_96060_109140 n1_M5_96060_110220 0.197640
R107 n1_M5_96060_110220 n1_M5_96060_111300 0.197640
R108 n1_M6_84060_60060 n1_M6_86076_60060 0.204960
R109 n1_M6_90060_60060 n1_M6_86076_60060 0.405040
R110 n1_M6_90060_60060 n1_M6_90172_60060 0.011387
R111 n1_M6_90172_60060 n1_M6_94268_60060 0.416427
R112 n1_M6_96060_60060 n1_M6_94268_60060 0.182187
R113 n1_M6_96060_60060 n1_M6_98364_60060 0.234240
R114 n1_M6_78060_72060 n1_M6_77884_72060 0.017893
R115 n1_M6_78060_72060 n1_M6_81980_72060 0.398533
R116 n1_M6_84060_72060 n1_M6_81980_72060 0.211467
R117 n1_M6_84060_72060 n1_M6_86076_72060 0.204960
R118 n1_M6_90060_72060 n1_M6_86076_72060 0.405040
R119 n1_M6_90060_72060 n1_M6_90172_72060 0.011387
R120 n1_M6_90172_72060 n1_M6_94268_72060 0.416427
R121 n1_M6_96060_72060 n1_M6_94268_72060 0.182187
R122 n1_M6_96060_72060 n1_M6_98364_72060 0.234240
R123 n1_M6_102060_72060 n1_M6_98364_72060 0.375760
R124 n1_M6_102060_72060 n1_M6_102460_72060 0.040667
R125 n1_M6_102460_72060 n1_M6_106556_72060 0.416427
R126 n1_M6_72060_84060 n1_M6_69692_84060 0.240747
R127 n1_M6_72060_84060 n1_M6_73788_84060 0.175680
R128 n1_M6_73788_84060 n1_M6_77884_84060 0.416427
R129 n1_M6_78060_84060 n1_M6_77884_84060 0.017893
R130 n1_M6_78060_84060 n1_M6_81980_84060 0.398533
R131 n1_M6_84060_84060 n1_M6_81980_84060 0.211467
R132 n1_M6_84060_84060 n1_M6_86076_84060 0.204960
R133 n1_M6_90060_84060 n1_M6_86076_84060 0.405040
R134 n1_M6_90060_84060 n1_M6_90172_84060 0.011387
R135 n1_M6_90172_84060 n1_M6_94268_84060 0.416427
R136 n1_M6_96060_84060 n1_M6_94268_84060 0.182187
R137 n1_M6_96060_84060 n1_M6_98364_84060 0.234240
R138 n1_M6_102060_84060 n1_M6_98364_84060 0.375760
R139 n1_M6_102060_84060 n1_M6_102460_84060 0.040667
R140 n1_M6_102460_84060 n1_M6_106556_84060 0.416427
R141 n1_M6_108060_84060 n1_M6_106556_84060 0.152907
R142 n1_M6_108060_84060 n1_M6_110652_84060 0.263520
R143 n1_M6_114060_84060 n1_M6_110652_84060 0.346480
R144 n1_M6_72060_96060 n1_M6_73788_96060 0.175680
R145 n1_M6_73788_96060 n1_M6_77884_96060 0.416427
R146 n1_M6_78060_96060 n1_M6_77884_96060 0.017893
R147 n1_M6_78060_96060 n1_M6_81980_96060 0.398533
R148 n1_M6_84060_96060 n1_M6_81980_96060 0.211467
R149 n1_M6_84060_96060 n1_M6_86076_96060 0.204960
R150 n1_M6_90060_96060 n1_M6_86076_96060 0.405040
R151 n1_M6_90060_96060 n1_M6_90172_96060 0.011387
R152 n1_M6_90172_96060 n1_M6_94268_96060 0.416427
R153 n1_M6_96060_96060 n1_M6_94268_96060 0.182187
R154 n1_M6_96060_96060 n1_M6_98364_96060 0.234240
R155 n1_M6_102060_96060 n1_M6_98364_96060 0.375760
R156 n1_M6_102060_96060 n1_M6_102460_96060 0.040667
R157 n1_M6_102460_96060 n1_M6_106556_96060 0.416427
R158 n1_M6_108060_96060 n1_M6_106556_96060 0.152907
R159 n1_M6_108060_96060 n1_M6_110652_96060 0.263520
R160 n1_M6_78060_108060 n1_M6_77884_108060 0.017893
R161 n1_M6_78060_108060 n1_M6_81980_108060 0.398533
R162 n1_M6_84060_108060 n1_M6_81980_108060 0.211467
R163 n1_M6_84060_108060 n1_M6_86076_108060 0.204960
R164 n1_M6_90060_108060 n1_M6_86076_108060 0.405040
R165 n1_M6_90060_108060 n1_M6_90172_108060 0.011387
R166 n1_M6_90172_108060 n1_M6_94268_108060 0.416427
R167 n1_M6_96060_108060 n1_M6_94268_108060 0.182187
R168 n1_M6_96060_108060 n1_M6_98364_108060 0.234240
R169 n1_M6_102060_108060 n1_M6_98364_108060 0.375760
R170 n1_M6_102060_108060 n1_M6_102460_108060 0.040667
R171 n1_M6_102460_108060 n1_M6_106556_108060 0.416427
R172 n1_M6_84060_120060 n1_M6_86076_120060 0.204960
R173 n1_M6_90060_120060 n1_M6_86076_120060 0.405040
R174 n1_M6_90060_120060 n1_M6_90172_120060 0.011387
R175 n1_M6_90172_120060 n1_M6_94268_120060 0.416427
R176 n1_M6_96060_120060 n1_M6_94268_120060 0.182187
R177 n1_M6_96060_120060 n1_M6_98364_120060 0.234240
R178 n1_M7_73788_84060 n1_M7_73788_83260 0.045750
R179 n1_M7_73788_84060 n1_M7_73788_89660 0.320250
R180 n1_M7_73788_96060 n1_M7_73788_89660 0.366000
R181 n1_M7_77884_76860 n1_M7_77884_83260 0.366000
R182 n1_M7_77884_84060 n1_M7_77884_83260 0.045750
R183 n1_M7_77884_84060 n1_M7_77884_89660 0.320250
R184 n1_M7_77884_96060 n1_M7_77884_89660 0.366000
R185 n1_M7_77884_96060 n1_M7_77884_102460 0.366000
R186 n1_M7_81980_72060 n1_M7_81980_70460 0.091500
R187 n1_M7_81980_72060 n1_M7_81980_76860 0.274500
R188 n1_M7_81980_76860 n1_M7_81980_83260 0.366000
R189 n1_M7_81980_84060 n1_M7_81980_83260 0.045750
R190 n1_M7_81980_84060 n1_M7_81980_89660 0.320250
R191 n1_M7_81980_96060 n1_M7_81980_89660 0.366000
R192 n1_M7_81980_96060 n1_M7_81980_102460 0.366000
R193 n1_M7_81980_108060 n1_M7_81980_102460 0.320250
R194 n1_M7_81980_108060 n1_M7_81980_108860 0.045750
R195 n1_M7_86076_60060 n1_M7_86076_57660 0.137250
R196 n1_M7_86076_60060 n1_M7_86076_64060 0.228750
R197 n1_M7_86076_64060 n1_M7_86076_70460 0.366000
R198 n1_M7_86076_72060 n1_M7_86076_70460 0.091500
R199 n1_M7_86076_72060 n1_M7_86076_76860 0.274500
R200 n1_M7_86076_76860 n1_M7_86076_83260 0.366000
R201 n1_M7_86076_84060 n1_M7_86076_83260 0.045750
R202 n1_M7_86076_84060 n1_M7_86076_89660 0.320250
R203 n1_M7_86076_96060 n1_M7_86076_89660 0.366000
R204 n1_M7_86076_96060 n1_M7_86076_102460 0.366000
R205 n1_M7_86076_108060 n1_M7_86076_102460 0.320250
R206 n1_M7_86076_108060 n1_M7_86076_108860 0.045750
R207 n1_M7_86076_108860 n1_M7_86076_115260 0.366000
R208 n1_M7_86076_120060 n1_M7_86076_115260 0.274500
R209 n1_M7_86076_120060 n1_M7_86076_121660 0.091500
R210 n1_M7_86076_121660 n1_M7_86076_128060 0.366000
R211 n1_M7_90172_48060 n1_M7_90172_44860 0.183000
R212 n1_M7_90172_48060 n1_M7_90172_51260 0.183000
R213 n1_M7_90172_51260 n1_M7_90172_57660 0.366000
R214 n1_M7_90172_60060 n1_M7_90172_57660 0.137250
R215 n1_M7_90172_60060 n1_M7_90172_64060 0.228750
R216 n1_M7_90172_64060 n1_M7_90172_70460 0.366000
R217 n1_M7_90172_72060 n1_M7_90172_70460 0.091500
R218 n1_M7_90172_72060 n1_M7_90172_76860 0.274500
R219 n1_M7_90172_76860 n1_M7_90172_83260 0.366000
R220 n1_M7_90172_84060 n1_M7_90172_83260 0.045750
R221 n1_M7_90172_84060 n1_M7_90172_89660 0.320250
R222 n1_M7_90172_96060 n1_M7_90172_89660 0.366000
R223 n1_M7_90172_96060 n1_M7_90172_102460 0.366000
R224 n1_M7_90172_108060 n1_M7_90172_102460 0.320250
R225 n1_M7_90172_108060 n1_M7_90172_108860 0.045750
R226 n1_M7_90172_108860 n1_M7_90172_115260 0.366000
R227 n1_M7_90172_120060 n1_M7_90172_115260 0.274500
R228 n1_M7_90172_120060 n1_M7_90172_121660 0.091500
R229 n1_M7_90172_121660 n1_M7_90172_128060 0.366000
R230 n1_M7_94268_60060 n1_M7_94268_57660 0.137250
R231 n1_M7_94268_60060 n1_M7_94268_64060 0.228750
R232 n1_M7_94268_64060 n1_M7_94268_70460 0.366000
R233 n1_M7_94268_72060 n1_M7_94268_70460 0.091500
R234 n1_M7_94268_72060 n1_M7_94268_76860 0.274500
R235 n1_M7_94268_76860 n1_M7_94268_83260 0.366000
R236 n1_M7_94268_84060 n1_M7_94268_83260 0.045750
R237 n1_M7_94268_84060 n1_M7_94268_89660 0.320250
R238 n1_M7_94268_96060 n1_M7_94268_89660 0.366000
R239 n1_M7_94268_96060 n1_M7_94268_102460 0.366000
R240 n1_M7_94268_108060 n1_M7_94268_102460 0.320250
R241 n1_M7_94268_108060 n1_M7_94268_108860 0.045750
R242 n1_M7_94268_108860 n1_M7_94268_115260 0.366000
R243 n1_M7_94268_120060 n1_M7_94268_115260 0.274500
R244 n1_M7_94268_120060 n1_M7_94268_121660 0.091500
R245 n1_M7_98364_64060 n1_M7_98364_70460 0.366000
R246 n1_M7_98364_72060 n1_M7_98364_70460 0.091500
R247 n1_M7_98364_72060 n1_M7_98364_76860 0.274500
R248 n1_M7_98364_76860 n1_M7_98364_83260 0.366000
R249 n1_M7_98364_84060 n1_M7_98364_83260 0.045750
R250 n1_M7_98364_84060 n1_M7_98364_89660 0.320250
R251 n1_M7_98364_96060 n1_M7_98364_89660 0.366000
R252 n1_M7_98364_96060 n1_M7_98364_102460 0.366000
R253 n1_M7_98364_108060 n1_M7_98364_102460 0.320250
R254 n1_M7_98364_108060 n1_M7_98364_108860 0.045750
R255 n1_M7_98364_108860 n1_M7_98364_115260 0.366000
R256 n1_M7_102460_72060 n1_M7_102460_76860 0.274500
R257 n1_M7_102460_76860 n1_M7_102460_83260 0.366000
R258 n1_M7_102460_84060 n1_M7_102460_83260 0.045750
R259 n1_M7_102460_84060 n1_M7_102460_89660 0.320250
R260 n1_M7_102460_96060 n1_M7_102460_89660 0.366000
R261 n1_M7_102460_96060 n1_M7_102460_102460 0.366000
R262 n1_M7_102460_108060 n1_M7_102460_102460 0.320250
R263 n1_M7_106556_76860 n1_M7_106556_83260 0.366000
R264 n1_M7_106556_84060 n1_M7_106556_83260 0.045750
R265 n1_M7_106556_84060 n1_M7_106556_89660 0.320250
R266 n1_M7_106556_96060 n1_M7_106556_89660 0.366000
R267 n1_M7_106556_96060 n1_M7_106556_102460 0.366000
R268 n1_M8_88620_51260 n1_M8_89700_51260 0.001755
R269 n1_M8_89700_51260 n1_M8_90780_51260 0.001755
R270 n1_M8_87540_57660 n1_M8_88620_57660 0.001755
R271 n1_M8_88620_57660 n1_M8_89700_57660 0.001755
R272 n1_M8_89700_57660 n1_M8_90780_57660 0.001755
R273 n1_M8_90780_57660 n1_M8_91860_57660 0.001755
R274 n1_M8_85380_64060 n1_M8_86460_64060 0.001755
R275 n1_M8_86460_64060 n1_M8_87540_64060 0.001755
R276 n1_M8_87540_64060 n1_M8_88620_64060 0.001755
R277 n1_M8_88620_64060 n1_M8_89700_64060 0.001755
R278 n1_M8_89700_64060 n1_M8_90780_64060 0.001755
R279 n1_M8_90780_64060 n1_M8_91860_64060 0.001755
R280 n1_M8_91860_64060 n1_M8_92940_64060 0.001755
R281 n1_M8_92940_64060 n1_M8_94020_64060 0.001755
R282 n1_M8_94020_64060 n1_M8_95100_64060 0.001755
R283 n1_M8_84300_70460 n1_M8_85380_70460 0.001755
R284 n1_M8_85380_70460 n1_M8_86460_70460 0.001755
R285 n1_M8_86460_70460 n1_M8_87540_70460 0.001755
R286 n1_M8_87540_70460 n1_M8_88620_70460 0.001755
R287 n1_M8_88620_70460 n1_M8_89700_70460 0.001755
R288 n1_M8_89700_70460 n1_M8_90780_70460 0.001755
R289 n1_M8_90780_70460 n1_M8_91860_70460 0.001755
R290 n1_M8_91860_70460 n1_M8_92940_70460 0.001755
R291 n1_M8_92940_70460 n1_M8_94020_70460 0.001755
R292 n1_M8_94020_70460 n1_M8_95100_70460 0.001755
R293 n1_M8_95100_70460 n1_M8_96180_70460 0.001755
R294 n1_M8_81060_76860 n1_M8_82140_76860 0.001755
R295 n1_M8_82140_76860 n1_M8_83220_76860 0.001755
R296 n1_M8_83220_76860 n1_M8_84300_76860 0.001755
R297 n1_M8_84300_76860 n1_M8_85380_76860 0.001755
R298 n1_M8_85380_76860 n1_M8_86460_76860 0.001755
R299 n1_M8_86460_76860 n1_M8_87540_76860 0.001755
R300 n1_M8_87540_76860 n1_M8_88620_76860 0.001755
R301 n1_M8_88620_76860 n1_M8_89700_76860 0.001755
R302 n1_M8_89700_76860 n1_M8_90780_76860 0.001755
R303 n1_M8_90780_76860 n1_M8_91860_76860 0.001755
R304 n1_M8_91860_76860 n1_M8_92940_76860 0.001755
R305 n1_M8_92940_76860 n1_M8_94020_76860 0.001755
R306 n1_M8_94020_76860 n1_M8_95100_76860 0.001755
R307 n1_M8_95100_76860 n1_M8_96180_76860 0.001755
R308 n1_M8_96180_76860 n1_M8_97260_76860 0.001755
R309 n1_M8_97260_76860 n1_M8_98340_76860 0.001755
R310 n1_M8_98340_76860 n1_M8_99420_76860 0.001755
R311 n1_M8_99420_76860 n1_M8_100500_76860 0.001755
R312 n1_M8_79980_83260 n1_M8_81060_83260 0.001755
R313 n1_M8_81060_83260 n1_M8_82140_83260 0.001755
R314 n1_M8_82140_83260 n1_M8_83220_83260 0.001755
R315 n1_M8_83220_83260 n1_M8_84300_83260 0.001755
R316 n1_M8_84300_83260 n1_M8_85380_83260 0.001755
R317 n1_M8_85380_83260 n1_M8_86460_83260 0.001755
R318 n1_M8_86460_83260 n1_M8_87540_83260 0.001755
R319 n1_M8_87540_83260 n1_M8_88620_83260 0.001755
R320 n1_M8_88620_83260 n1_M8_89700_83260 0.001755
R321 n1_M8_89700_83260 n1_M8_90780_83260 0.001755
R322 n1_M8_90780_83260 n1_M8_91860_83260 0.001755
R323 n1_M8_91860_83260 n1_M8_92940_83260 0.001755
R324 n1_M8_92940_83260 n1_M8_94020_83260 0.001755
R325 n1_M8_94020_83260 n1_M8_95100_83260 0.001755
R326 n1_M8_95100_83260 n1_M8_96180_83260 0.001755
R327 n1_M8_96180_83260 n1_M8_97260_83260 0.001755
R328 n1_M8_97260_83260 n1_M8_98340_83260 0.001755
R329 n1_M8_98340_83260 n1_M8_99420_83260 0.001755
R330 n1_M8_99420_83260 n1_M8_100500_83260 0.001755
R331 n1_M8_100500_83260 n1_M8_101580_83260 0.001755
R332 n1_M8_101580_83260 n1_M8_102660_83260 0.001755
R333 n1_M8_102660_83260 n1_M8_103740_83260 0.001755
R334 n1_M8_76740_89660 n1_M8_77820_89660 0.001755
R335 n1_M8_77820_89660 n1_M8_78900_89660 0.001755
R336 n1_M8_78900_89660 n1_M8_79980_89660 0.001755
R337 n1_M8_79980_89660 n1_M8_81060_89660 0.001755
R338 n1_M8_81060_89660 n1_M8_82140_89660 0.001755
R339 n1_M8_82140_89660 n1_M8_83220_89660 0.001755
R340 n1_M8_83220_89660 n1_M8_84300_89660 0.001755
R341 n1_M8_84300_89660 n1_M8_85380_89660 0.001755
R342 n1_M8_85380_89660 n1_M8_86460_89660 0.001755
R343 n1_M8_86460_89660 n1_M8_87540_89660 0.001755
R344 n1_M8_87540_89660 n1_M8_88620_89660 0.001755
R345 n1_M8_88620_89660 n1_M8_89700_89660 0.001755
R346 n1_M8_89700_89660 n1_M8_90780_89660 0.001755
R347 n1_M8_90780_89660 n1_M8_91860_89660 0.001755
R348 n1_M8_91860_89660 n1_M8_92940_89660 0.001755
R349 n1_M8_92940_89660 n1_M8_94020_89660 0.001755
R350 n1_M8_94020_89660 n1_M8_95100_89660 0.001755
R351 n1_M8_95100_89660 n1_M8_96180_89660 0.001755
R352 n1_M8_96180_89660 n1_M8_97260_89660 0.001755
R353 n1_M8_97260_89660 n1_M8_98340_89660 0.001755
R354 n1_M8_98340_89660 n1_M8_99420_89660 0.001755
R355 n1_M8_99420_89660 n1_M8_100500_89660 0.001755
R356 n1_M8_100500_89660 n1_M8_101580_89660 0.001755
R357 n1_M8_101580_89660 n1_M8_102660_89660 0.001755
R358 n1_M8_102660_89660 n1_M8_103740_89660 0.001755
R359 n1_M8_79980_96060 n1_M8_81060_96060 0.001755
R360 n1_M8_81060_96060 n1_M8_82140_96060 0.001755
R361 n1_M8_82140_96060 n1_M8_83220_96060 0.001755
R362 n1_M8_83220_96060 n1_M8_84300_96060 0.001755
R363 n1_M8_84300_96060 n1_M8_85380_96060 0.001755
R364 n1_M8_85380_96060 n1_M8_86460_96060 0.001755
R365 n1_M8_86460_96060 n1_M8_87540_96060 0.001755
R366 n1_M8_87540_96060 n1_M8_88620_96060 0.001755
R367 n1_M8_88620_96060 n1_M8_89700_96060 0.001755
R368 n1_M8_89700_96060 n1_M8_90780_96060 0.001755
R369 n1_M8_90780_96060 n1_M8_91860_96060 0.001755
R370 n1_M8_91860_96060 n1_M8_92940_96060 0.001755
R371 n1_M8_92940_96060 n1_M8_94020_96060 0.001755
R372 n1_M8_94020_96060 n1_M8_95100_96060 0.001755
R373 n1_M8_95100_96060 n1_M8_96180_96060 0.001755
R374 n1_M8_96180_96060 n1_M8_97260_96060 0.001755
R375 n1_M8_97260_96060 n1_M8_98340_96060 0.001755
R376 n1_M8_98340_96060 n1_M8_99420_96060 0.001755
R377 n1_M8_99420_96060 n1_M8_100500_96060 0.001755
R378 n1_M8_100500_96060 n1_M8_101580_96060 0.001755
R379 n1_M8_101580_96060 n1_M8_102660_96060 0.001755
R380 n1_M8_102660_96060 n1_M8_103740_96060 0.001755
R381 n1_M8_81060_102460 n1_M8_82140_102460 0.001755
R382 n1_M8_82140_102460 n1_M8_83220_102460 0.001755
R383 n1_M8_83220_102460 n1_M8_84300_102460 0.001755
R384 n1_M8_84300_102460 n1_M8_85380_102460 0.001755
R385 n1_M8_85380_102460 n1_M8_86460_102460 0.001755
R386 n1_M8_86460_102460 n1_M8_87540_102460 0.001755
R387 n1_M8_87540_102460 n1_M8_88620_102460 0.001755
R388 n1_M8_88620_102460 n1_M8_89700_102460 0.001755
R389 n1_M8_89700_102460 n1_M8_90780_102460 0.001755
R390 n1_M8_90780_102460 n1_M8_91860_102460 0.001755
R391 n1_M8_91860_102460 n1_M8_92940_102460 0.001755
R392 n1_M8_92940_102460 n1_M8_94020_102460 0.001755
R393 n1_M8_94020_102460 n1_M8_95100_102460 0.001755
R394 n1_M8_95100_102460 n1_M8_96180_102460 0.001755
R395 n1_M8_96180_102460 n1_M8_97260_102460 0.001755
R396 n1_M8_97260_102460 n1_M8_98340_102460 0.001755
R397 n1_M8_98340_102460 n1_M8_99420_102460 0.001755
R398 n1_M8_99420_102460 n1_M8_100500_102460 0.001755
R399 n1_M8_83220_108860 n1_M8_84300_108860 0.001755
R400 n1_M8_84300_108860 n1_M8_85380_108860 0.001755
R401 n1_M8_85380_108860 n1_M8_86460_108860 0.001755
R402 n1_M8_86460_108860 n1_M8_87540_108860 0.001755
R403 n1_M8_87540_108860 n1_M8_88620_108860 0.001755
R404 n1_M8_88620_108860 n1_M8_89700_108860 0.001755
R405 n1_M8_89700_108860 n1_M8_90780_108860 0.001755
R406 n1_M8_90780_108860 n1_M8_91860_108860 0.001755
R407 n1_M8_91860_108860 n1_M8_92940_108860 0.001755
R408 n1_M8_92940_108860 n1_M8_94020_108860 0.001755
R409 n1_M8_94020_108860 n1_M8_95100_108860 0.001755
R410 n1_M8_95100_108860 n1_M8_96180_108860 0.001755
R411 n1_M8_84300_115260 n1_M8_85380_115260 0.001755
R412 n1_M8_85380_115260 n1_M8_86460_115260 0.001755
R413 n1_M8_86460_115260 n1_M8_87540_115260 0.001755
R414 n1_M8_87540_115260 n1_M8_88620_115260 0.001755
R415 n1_M8_88620_115260 n1_M8_89700_115260 0.001755
R416 n1_M8_89700_115260 n1_M8_90780_115260 0.001755
R417 n1_M8_90780_115260 n1_M8_91860_115260 0.001755
R418 n1_M8_91860_115260 n1_M8_92940_115260 0.001755
R419 n1_M8_92940_115260 n1_M8_94020_115260 0.001755
R420 n1_M8_94020_115260 n1_M8_95100_115260 0.001755
R421 n1_M8_86460_121660 n1_M8_87540_121660 0.001755
R422 n1_M8_87540_121660 n1_M8_88620_121660 0.001755
R423 n1_M8_88620_121660 n1_M8_89700_121660 0.001755
R424 n1_M8_89700_121660 n1_M8_90780_121660 0.001755
R425 n1_M8_90780_121660 n1_M8_91860_121660 0.001755
R426 n1_M8_88620_128060 n1_M8_89700_128060 0.001755
R427 n1_M8_89700_128060 n1_M8_90780_128060 0.001755
R428 n1_M2_96180_70260 n1_M5_96060_70260 10.000000
R429 n1_M2_96180_71340 n1_M5_96060_71340 10.000000
R430 n1_M2_96180_72420 n1_M5_96060_72420 10.000000
R431 n1_M2_96180_73500 n1_M5_96060_73500 10.000000
R432 n1_M2_96180_78900 n1_M5_96060_78900 10.000000
R433 n1_M2_96180_79980 n1_M5_96060_79980 10.000000
R434 n1_M2_96180_81060 n1_M5_96060_81060 10.000000
R435 n1_M2_96180_82140 n1_M5_96060_82140 10.000000
R436 n1_M2_96180_83220 n1_M5_96060_83220 10.000000
R437 n1_M2_96180_84300 n1_M5_96060_84300 10.000000
R438 n1_M2_96180_85380 n1_M5_96060_85380 10.000000
R439 n1_M2_96180_86460 n1_M5_96060_86460 10.000000
R440 n1_M2_96180_87540 n1_M5_96060_87540 10.000000
R441 n1_M2_96180_88620 n1_M5_96060_88620 10.000000
R442 n1_M2_96180_91860 n1_M5_96060_91860 10.000000
R443 n1_M2_96180_92940 n1_M5_96060_92940 10.000000
R444 n1_M2_96180_94020 n1_M5_96060_94020 10.000000
R445 n1_M2_96180_95100 n1_M5_96060_95100 10.000000
R446 n1_M2_96180_96180 n1_M5_96060_96180 10.000000
R447 n1_M2_96180_97260 n1_M5_96060_97260 10.000000
R448 n1_M2_96180_98340 n1_M5_96060_98340 10.000000
R449 n1_M2_96180_99420 n1_M5_96060_99420 10.000000
R450 n1_M2_96180_105900 n1_M5_96060_105900 10.000000
R451 n1_M2_96180_106980 n1_M5_96060_106980 10.000000
R452 n1_M2_96180_108060 n1_M5_96060_108060 10.000000
R453 n1_M2_96180_109140 n1_M5_96060_109140 10.000000
R454 n1_M2_96180_110220 n1_M5_96060_110220 10.000000
R455 n1_M5_72060_84060 n1_M6_72060_84060 10.000000
R456 n1_M5_96060_60060 n1_M6_96060_60060 10.000000
R457 n1_M5_96060_72060 n1_M6_96060_72060 10.000000
R458 n1_M5_96060_84060 n1_M6_96060_84060 10.000000
R459 n1_M5_96060_96060 n1_M6_96060_96060 10.000000
R460 n1_M5_96060_108060 n1_M6_96060_108060 10.000000
R461 n1_M5_96060_120060 n1_M6_96060_120060 10.000000
R462 n1_M6_73788_84060 n1_M7_73788_84060 10.000000
R463 n1_M6_73788_96060 n1_M7_73788_96060 10.000000
R464 n1_M6_77884_84060 n1_M7_77884_84060 10.000000
R465 n1_M6_77884_96060 n1_M7_77884_96060 10.000000
R466 n1_M6_81980_72060 n1_M7_81980_72060 10.000000
R467 n1_M6_81980_84060 n1_M7_81980_84060 10.000000
R468 n1_M6_81980_96060 n1_M7_81980_96060 10.000000
R469 n1_M6_81980_108060 n1_M7_81980_108060 10.000000
R470 n1_M6_86076_60060 n1_M7_86076_60060 10.000000
R471 n1_M6_86076_72060 n1_M7_86076_72060 10.000000
R472 n1_M6_86076_84060 n1_M7_86076_84060 10.000000
R473 n1_M6_86076_96060 n1_M7_86076_96060 10.000000
R474 n1_M6_86076_108060 n1_M7_86076_108060 10.000000
R475 n1_M6_86076_120060 n1_M7_86076_120060 10.000000
R476 n1_M6_90172_48060 n1_M7_90172_48060 10.000000
R477 n1_M6_90172_60060 n1_M7_90172_60060 10.000000
R478 n1_M6_90172_72060 n1_M7_90172_72060 10.000000
R479 n1_M6_90172_84060 n1_M7_90172_84060 10.000000
R480 n1_M6_90172_96060 n1_M7_90172_96060 10.000000
R481 n1_M6_90172_108060 n1_M7_90172_108060 10.000000
R482 n1_M6_90172_120060 n1_M7_90172_120060 10.000000
R483 n1_M6_94268_60060 n1_M7_94268_60060 10.000000
R484 n1_M6_94268_72060 n1_M7_94268_72060 10.000000
R485 n1_M6_94268_84060 n1_M7_94268_84060 10.000000
R486 n1_M6_94268_96060 n1_M7_94268_96060 10.000000
R487 n1_M6_94268_108060 n1_M7_94268_108060 10.000000
R488 n1_M6_94268_120060 n1_M7_94268_120060 10.000000
R489 n1_M6_98364_72060 n1_M7_98364_72060 10.000000
R490 n1_M6_98364_84060 n1_M7_98364_84060 10.000000
R491 n1_M6_98364_96060 n1_M7_98364_96060 10.000000
R492 n1_M6_98364_108060 n1_M7_98364_108060 10.000000
R493 n1_M6_102460_72060 n1_M7_102460_72060 10.000000
R494 n1_M6_102460_84060 n1_M7_102460_84060 10.000000
R495 n1_M6_102460_96060 n1_M7_102460_96060 10.000000
R496 n1_M6_102460_108060 n1_M7_102460_108060 10.000000
R497 n1_M6_106556_84060 n1_M7_106556_84060 10.000000
R498 n1_M6_106556_96060 n1_M7_106556_96060 10.000000
R499 n1_M6_110652_84060 n1_M7_110652_84060 10.000000
R500 n1_M7_77884_83260 n1_M8_77820_83260 10.000000
R501 n1_M7_77884_89660 n1_M8_77820_89660 10.000000
R502 n1_M7_77884_96060 n1_M8_77820_96060 10.000000
R503 n1_M7_81980_76860 n1_M8_82140_76860 10.000000
R504 n1_M7_81980_83260 n1_M8_82140_83260 10.000000
R505 n1_M7_81980_89660 n1_M8_82140_89660 10.000000
R506 n1_M7_81980_96060 n1_M8_82140_96060 10.000000
R507 n1_M7_81980_102460 n1_M8_82140_102460 10.000000
R508 n1_M7_86076_64060 n1_M8_86460_64060 10.000000
R509 n1_M7_86076_70460 n1_M8_86460_70460 10.000000
R510 n1_M7_86076_76860 n1_M8_86460_76860 10.000000
R511 n1_M7_86076_83260 n1_M8_86460_83260 10.000000
R512 n1_M7_86076_89660 n1_M8_86460_89660 10.000000
R513 n1_M7_86076_96060 n1_M8_86460_96060 10.000000
R514 n1_M7_86076_102460 n1_M8_86460_102460 10.000000
R515 n1_M7_86076_108860 n1_M8_86460_108860 10.000000
R516 n1_M7_86076_115260 n1_M8_86460_115260 10.000000
R517 n1_M7_86076_121660 n1_M8_86460_121660 10.000000
R518 n1_M7_90172_51260 n1_M8_89700_51260 10.000000
R519 n1_M7_90172_57660 n1_M8_89700_57660 10.000000
R520 n1_M7_90172_64060 n1_M8_89700_64060 10.000000
R521 n1_M7_90172_70460 n1_M8_89700_70460 10.000000
R522 n1_M7_90172_76860 n1_M8_89700_76860 10.000000
R523 n1_M7_90172_83260 n1_M8_89700_83260 10.000000
R524 n1_M7_90172_89660 n1_M8_89700_89660 10.000000
R525 n1_M7_90172_96060 n1_M8_89700_96060 10.000000
R526 n1_M7_90172_102460 n1_M8_89700_102460 10.000000
R527 n1_M7_90172_108860 n1_M8_89700_108860 10.000000
R528 n1_M7_90172_115260 n1_M8_89700_115260 10.000000
R529 n1_M7_90172_121660 n1_M8_89700_121660 10.000000
R530 n1_M7_90172_128060 n1_M8_89700_128060 10.000000
R531 n1_M7_94268_64060 n1_M8_94020_64060 10.000000
R532 n1_M7_94268_70460 n1_M8_94020_70460 10.000000
R533 n1_M7_94268_76860 n1_M8_94020_76860 10.000000
R534 n1_M7_94268_83260 n1_M8_94020_83260 10.000000
R535 n1_M7_94268_89660 n1_M8_94020_89660 10.000000
R536 n1_M7_94268_96060 n1_M8_94020_96060 10.000000
R537 n1_M7_94268_102460 n1_M8_94020_102460 10.000000
R538 n1_M7_94268_108860 n1_M8_94020_108860 10.000000
R539 n1_M7_94268_115260 n1_M8_94020_115260 10.000000
R540 n1_M7_98364_70460 n1_M8_98340_70460 10.000000
R541 n1_M7_98364_76860 n1_M8_98340_76860 10.000000
R542 n1_M7_98364_83260 n1_M8_98340_83260 10.000000
R543 n1_M7_98364_89660 n1_M8_98340_89660 10.000000
R544 n1_M7_98364_96060 n1_M8_98340_96060 10.000000
R545 n1_M7_98364_102460 n1_M8_98340_102460 10.000000
R546 n1_M7_98364_108860 n1_M8_98340_108860 10.000000
R547 n1_M7_102460_76860 n1_M8_102660_76860 10.000000
R548 n1_M7_102460_83260 n1_M8_102660_83260 10.000000
R549 n1_M7_102460_89660 n1_M8_102660_89660 10.000000
R550 n1_M7_102460_96060 n1_M8_102660_96060 10.000000
R551 n1_M7_102460_102460 n1_M8_102660_102460 10.000000
R552 n1_M7_106556_83260 n1_M8_106980_83260 10.000000
R553 n1_M7_106556_89660 n1_M8_106980_89660 10.000000
R554 n1_M7_106556_96060 n1_M8_106980_96060 10.000000
V0 n1_M8_89700_89660 0 0.700000
I0 n1_M2_94020_82140 0 3.193363e-05
I1 n1_M2_94020_84300 0 3.098765e-05
I2 n1_M2_94020_86460 0 2.958036e-05
I3 n1_M2_94020_94020 0 2.708169e-05
I4 n1_M2_94020_96180 0 2.800084e-05
I5 n1_M2_94020_108060 0 3.135104e-05
I6 n1_M2_96180_70260 0 2.461747e-05
I7 n1_M2_96180_72420 0 2.618419e-05
I8 n1_M2_96180_73500 0 2.811276e-05
I9 n1_M2_96180_79980 0 3.272011e-05
I10 n1_M2_96180_82140 0 3.272590e-05
I11 n1_M2_96180_84300 0 3.193578e-05
I12 n1_M2_96180_86460 0 3.068590e-05
I13 n1_M2_96180_87540 0 2.936162e-05
I14 n1_M2_96180_91860 0 2.785031e-05
I15 n1_M2_96180_94020 0 2.814326e-05
I16 n1_M2_96180_96180 0 2.915562e-05
I17 n1_M2_96180_98340 0 3.057995e-05
I18 n1_M2_96180_105900 0 3.251048e-05
I19 n1_M2_96180_108060 0 3.197761e-05
I20 n1_M2_96180_110220 0 3.145502e-05
I21 n1_M2_98340_82140 0 3.375030e-05
I22 n1_M2_98340_84300 0 3.336875e-05
I23 n1_M2_98340_86460 0 3.255087e-05
I24 n1_M2_98340_94020 0 3.018136e-05
I25 n1_M2_98340_96180 0 3.117597e-05
I26 n1_M2_98340_108060 0 3.307863e-05
.op
.end
